# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on TOP (solid shape): 25.78,148.89 25.82,148.89 25.86,148.84 28.11,148.84 28.16,148.89 29.54,148.89 29.63,148.79 29.63,148.34 29.45,148.15 29.08,148.15 28.95,148.24 28.8,148.26 28.54,148.26 28.38,148.24 28.26,148.15 28.1,148.15 27.63,147.68 27.63,144.17 27.51,144.05 26.72,144.05 25.48,145.29 25.48,146.12 25.58,146.22 26.15,146.22 26.5,146.57 26.67,146.57 27.07,146.97 26.67,147.38 26.57,147.38 26.13,147.82 24.89,147.82 24.65,148.06 24.65,148.29 24.65,148.31 24.56,148.47 24.4,148.53 24.11,148.53 24.03,148.57 24.01,148.66 24.02,148.71 24.03,148.76 23.91,149.05 23.62,149.17 23.38,149.09 23.23,148.88 23.23,148.87 22.9,148.54 22.82,148.43 22.79,148.29 22.79,148.21 20.13,148.21 20.01,148.33 20.01,148.88 20.16,149.03 22.24,149.03 22.33,149.13 22.5,149.13 23.27,149.89 24.77,149.89
+3V on TOP (solid shape): outline of 133 points within 59.22,90.81 67.98,97.4
+3V on BOTTOM (solid shape): 26.6,138.95 26.6,137.66 26.54,137.61 22.42,137.61 22.01,138.02 20.27,138.02 19.86,137.61 18.74,137.61 18.68,137.67 18.68,138.9 18.78,139 26.55,139
+3V on BOTTOM (solid shape): 211.99,131.31 211.99,129.59 211.99,129.45 211.98,129.3 211.99,129.15 211.99,129.01 211.99,128.36 211.89,128.25 209.71,128.25 209.36,128.61 209.36,130.18 209.01,130.18 208.9,130.28 208.89,130.28 208.86,130.31 208.49,130.31 208.39,130.41 208.39,130.87 208.51,131 208.53,131 210.19,131.17 211.85,131.42 211.87,131.42
+3V on BOTTOM (solid shape): 224.13,115.19 224.13,113.45 223.78,113.1 221.77,113.1 221.67,113.2 221.67,113.4 222.49,113.4 222.49,113.6 221.67,113.6 221.67,113.88 221.69,113.9 222.49,113.9 222.49,113.91 222.53,113.91 222.64,114.01 222.65,114.1 222.65,114.4 222.64,114.47 222.71,114.53 222.74,114.55 223.1,114.91 223.12,114.94 223.14,114.97 223.57,115.4 223.93,115.4
+3V on BOTTOM (solid shape): 196.71,119.81 196.71,119.25 196.7,119.19 196.69,119.14 196.7,119.09 196.71,119.03 196.71,118.74 196.7,118.68 196.69,118.63 196.69,118.38 196.7,118.32 196.71,118.27 196.71,118.18 196.67,118.17 196.45,118.03 196.36,117.78 196.37,117.72 196.38,117.66 196.39,117.63 196.13,117.36 195.24,117.36 195.11,117.49 195.07,117.52 195.03,117.56 195.03,119.73 195.28,119.99 196.54,119.99
+3V on BOTTOM (solid shape): 72.37,190.04 72.44,190.01 72.47,189.94 72.51,189.78 72.61,189.64 72.62,189.63 72.62,189.57 72.61,189.56 72.52,189.43 72.49,189.27 72.52,189.1 72.62,188.97 72.62,187.98 72.39,187.75 71.15,187.75 70.74,188.16 70.72,188.16 70.51,188.36 70.51,188.44 70.52,188.45 70.59,188.57 70.61,188.7 70.58,188.84 70.51,188.96 70.51,189.66 70.85,189.99 70.94,189.99 71.01,190 71.08,190.03 71.09,190.04
+3V on BOTTOM (solid shape): 27.55,69.67 27.55,68.04 27.49,68.03 27.08,67.63 27.49,67.22 27.51,67.22 27.59,67.19 27.62,67.12 27.62,66.87 27.45,66.7 26.39,66.7 26.16,66.47 25.98,66.47 25.95,66.44 25.95,65.45 25.9,65.45 25.83,65.38 25.25,65.38 25.15,65.49 25.01,65.55 24.97,65.56 24.97,66.68 25.98,67.68 25.98,68.25 26.12,68.56 25.98,68.86 25.98,69.77 26.03,69.82 26.06,69.79 26.19,69.71 26.33,69.68 26.55,69.75 26.7,69.91 27.31,69.91
+3V on SVCC (solid shape): outline of 316 points within 32.68,103.65 226.37,177.31
+3V on IN2 (solid shape): outline of 550 points within 222.18,113.81 235.36,120.72
+3V on IN2 (solid shape): outline of 2588 points within 35.21,175.34 118.86,195.56
+3V on IN2 (solid shape): outline of 7760 points within 17.95,66.22 27.95,146.85
+3V on IN3 (solid shape): outline of 390 points within 24.92,136.71 33.28,146.96
+3V on IN3 (solid shape): outline of 567 points within 116.44,186.77 133.81,213.35
+3V3_TPM on TOP (solid shape): outline of 203 points within 86.88,99.69 96.66,102.97
+3V3_TPM_VSB on TOP (solid shape): 93.56,97.06 93.56,96.66 93.73,96.49 94.75,96.49 96.35,96.49 96.47,96.36 96.47,95.76 94.67,95.76 94.47,95.72 94.31,95.61 94.23,95.53 93.55,95.53 93.44,95.64 92.27,95.64 92.05,95.42 92.05,94.74 91.9,94.59 90.2,94.59 89.82,94.97 89.82,96.39 89.87,96.44 90.92,96.44 91.05,96.36 91.21,96.33 91.49,96.45 91.61,96.73 91.59,96.86 91.53,96.98 91.51,97.01 91.72,97.23 93.4,97.23
+3V_CCD_PWR1_C on BOTTOM (solid shape): 71.8,192.51 72,192.51 72,193.44 72.16,193.44 72.3,193.31 72.3,192.51 72.32,192.51 72.32,191.77 72.62,191.46 72.62,190.62 72.48,190.48 71.6,190.48 71.5,190.57 71.5,191.17 71.53,191.2 71.53,191.68 71.55,191.75 71.56,191.82 71.55,191.89 71.53,191.96 71.53,193.34 71.63,193.44 71.8,193.44
+3V_CR on BOTTOM (solid shape): 27.82,65.93 27.97,65.93 28.27,65.93 28.31,65.93 29.08,65.93 29.11,65.93 29.41,65.93 29.46,65.93 29.52,65.88 29.52,64.6 29.47,64.51 29.46,64.41 29.46,64.26 29.41,64.21 29.41,63 29.35,62.94 29.14,62.94 29.11,62.97 29.11,63.21 29.17,63.33 29.19,63.46 29.19,64.08 29.17,64.22 29.11,64.34 29.1,64.36 29.1,64.48 28.47,65.1 27.64,65.1 27.37,65.37 27.23,65.47 27.06,65.5 26.95,65.48 26.85,65.44 26.44,65.44 26.33,65.55 26.33,66.27 26.5,66.44 27.31,66.44
+3V_DEEP_SUS on TOP (solid shape): 111.22,115.14 111.62,115.14 112.12,114.64 112.28,114.64 112.97,113.95 113.11,113.95 113.24,113.82 113.24,113.44 113.01,113.21 112.25,113.21 112.08,113.37 112.08,113.39 112.04,113.58 111.93,113.74 111.43,114.24 111.27,114.35 111.08,114.39 111.06,114.39 110.45,115 110.45,115.45 110.46,115.45 110.46,116.66 110.56,116.76 111.22,116.76
+3V_DEEP_SUS on TOP (solid shape): 82.49,123.98 82.49,123.5 82.24,123.24 82.24,123.12 82.19,123.04 82.18,122.94 82.19,122.85 82.24,122.76 82.24,122.7 81.84,122.31 81.84,121.9 81.84,121.9 81.51,121.9 81.39,121.88 81.29,121.81 81.27,121.79 81.23,121.79 81.02,121.99 81.02,122.39 81.01,122.4 81.01,122.43 80.96,122.54 80.86,122.58 80.78,122.58 80.77,122.59 80.67,122.61 80.56,122.59 80.55,122.58 80.47,122.58 80.39,122.56 80.34,122.5 80.32,122.47 79.69,122.47 79.57,122.59 79.57,123.35 79.68,123.45 80.93,123.45 80.93,123.46 80.95,123.46 81.13,123.54 81.2,123.71 81.2,123.82 81.54,124.15 82.32,124.15
+3V_DEEP_SUS on BOTTOM (solid shape): 114.79,109.26 114.91,109.18 115.05,109.15 115.13,109.15 115.14,109.14 117,109.14 117.05,109.09 117.05,108.38 116.89,108.23 116.01,108.23 115.86,108.4 115.64,108.46 115.43,108.41 115.28,108.25 115.27,108.23 115.22,108.23 115.21,108.24 115.06,108.31 114.91,108.33 114.43,108.33 114.35,108.4 114.35,108.55 114.36,108.6 114.37,108.64 114.36,108.67 114.35,108.72 114.35,109.14 114.18,109.32 113.47,109.32 113.39,109.39 113.39,109.42 113.53,109.57 114.48,109.57
+3V_DEEP_SUS on BOTTOM (solid shape): 113.48,116.8 113.48,116.43 113.49,116.33 113.52,116.24 113.52,116.24 113.39,116.1 113.35,115.91 113.39,115.74 113.5,115.61 113.52,115.59 113.52,115.56 113.62,115.46 113.83,115.46 113.83,115.36 113.86,115.29 113.94,115.26 114.33,115.26 114.43,115.17 114.43,114.98 114.11,114.98 113.99,114.96 113.89,114.89 113.51,114.51 113.44,114.41 113.42,114.29 113.42,113.07 113.36,113.01 113.3,112.91 113.27,112.79 113.27,112.07 113.3,111.95 113.36,111.85 113.4,111.82 113.41,111.76 113.36,111.73 112.73,111.73 112.61,111.85 112.61,112.12 112.64,112.13 112.85,112.28 112.93,112.52 112.81,112.81 112.52,112.93 112.45,112.92 112.38,112.9 112.18,112.9 112.13,112.95 112,113.06 111.83,113.1 111.7,113.08 111.59,113.02 111.54,113.05 111.48,113.06 111.43,113.06 111.34,113.15 111.34,113.28 111.11,113.52 110.95,113.52 110.88,113.55 110.82,113.55 110.28,113.55 110.21,113.63 110.21,114.62 110.3,114.72 111.82,114.72 112.03,114.51 112.87,114.51 112.96,114.59 112.96,116.64 113.17,116.85 113.43,116.85
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 279 points within 89.27,102.94 93.73,110.97
+3V_DEEP_SUS on IN1 (solid shape): 112.98,114.66 113.27,114.66 113.36,114.58 113.36,113.59 113.07,113.3 111.98,113.3 111.92,113.29 111.87,113.28 111.77,113.29 111.73,113.38 111.73,113.86 112.76,114.89
+3V_DEEP_SUS on IN2 (solid shape): outline of 572 points within 88.83,108.61 113.19,119.11
+3V_DEEP_SUS on IN4 (solid shape): 113.75,113.55 113.75,112.59 115,111.34 115,111.31 115.05,111.1 115.17,110.91 116.44,109.64 116.44,108.94 116,108.5 115.15,108.5 114.55,109.1 114.55,109.63 114.39,109.79 113.45,110.73 113.45,111.27 113.29,111.43 112.67,112.05 112.64,112.13 112.69,112.21 112.83,112.34 112.88,112.52 112.77,112.77 112.52,112.87 112.38,112.85 112.26,112.77 112.15,112.74 112.09,112.84 112.09,113.89 112.09,114.27 112.18,114.36 112.94,114.36
+3V_LAN on TOP (solid shape): 15.3,168.82 15.3,168.08 15.31,168.06 15.31,167.71 15.88,167.14 15.88,166.88 15.78,166.77 15.36,166.77 15.13,167 15.13,167.18 14.63,167.68 14.63,168.36 14.41,168.58 14.41,169.17 14.49,169.24 14.88,169.24
+3V_LAN on TOP (solid shape): 25.73,165.53 26.65,165.53 26.77,165.4 26.77,165.1 26.62,164.94 26.29,164.94 26.24,164.89 26.22,164.89 26.09,164.82 26.02,164.69 26.02,164.68 25.81,164.47 24.3,164.47 23.84,164.93 22.63,164.93 22.6,164.96 22.6,165.07 22.64,165.11 23.61,165.11 23.65,165.15 23.65,165.28 23.61,165.32 22.65,165.32 22.62,165.35 22.62,165.47 22.65,165.5 25.19,165.5 25.38,165.7 25.56,165.7
+3V_LAN on TOP (solid shape): 24.83,177.49 25.05,177.29 25.34,177.22 25.39,177.22 25.39,175.38 24.57,174.56 23.77,174.56 23.66,174.62 23.52,174.64 23.24,174.52 23.12,174.23 23.12,173.89 23.06,173.83 23.06,173.3 23.01,173.25 23.01,171.2 22.78,170.97 22.16,170.97 22.07,171.06 22.07,171.24 22.12,171.34 22.13,171.44 22.13,172.57 22.33,172.79 22.4,173.09 22.4,173.84 21.77,174.48 21.13,173.84 21.13,173.44 20.85,173.44 20.81,173.44 20.77,173.43 20.72,173.43 20.35,173.06 20.35,172.07 20.16,171.88 19.66,171.88 19.51,172.03 19.48,172.09 19.5,172.16 19.56,172.27 19.58,172.39 19.56,172.53 19.48,172.64 19.38,172.74 19.38,173.94 20.05,174.61 20.06,174.61 20.11,174.64 20.14,174.69 20.15,174.71 20.15,175.57 20.71,176.13 20.71,176.76 21.01,177.06 23.83,177.06 24.26,177.49
+3V_LAN on IN3 (solid shape): outline of 1381 points within 11.63,160.73 30.61,175.25
+3V_RTC on TOP (solid shape): 78.02,101.37 78.02,100.87 77.93,100.77 77.93,99.84 78.54,99.24 78.98,99.24 79.04,99.18 79.04,98.84 79.06,98.72 79.1,98.62 79.1,98.61 78.97,98.48 78.66,98.48 78.5,98.57 78.32,98.61 77.98,98.61 77.77,98.82 77.28,98.82 77.14,98.91 76.98,98.95 76.86,98.93 76.75,98.87 76.72,98.85 76.5,99.07 76.5,99.37 76.48,99.39 76.48,100.43 77.07,101.01 77.07,101.39 77.19,101.51 77.88,101.51
+3V_S5 on TOP (solid shape): 110.2,117.2 110.2,115.05 110.02,114.87 109.6,114.87 109.44,115.03 109.45,115.1 109.45,115.4 109.45,115.45 109.42,115.51 109.42,116.5 109.72,116.8 109.72,117.23 109.77,117.27 110.13,117.27
+3V_S5 on TOP (solid shape): 36.19,143.87 36.19,143 36.14,142.89 36.12,142.77 36.12,141.89 36.13,141.81 36.15,141.73 36.15,141.45 36.12,141.42 35.89,141.42 35.85,141.46 35.85,142.33 35.84,142.33 35.84,142.52 35.66,142.71 34.17,142.71 34,142.87 33.98,142.91 34,142.95 34.09,143.08 34.12,143.23 34.07,143.42 33.94,143.56 33.92,143.58 33.92,143.62 33.96,143.7 34.05,143.72 34.1,143.71 34.16,143.71 34.27,143.72 34.38,143.77 34.66,143.77 34.79,143.8 34.9,143.87 34.93,143.9 36.17,143.9
+3V_S5 on TOP (solid shape): 94.27,108.93 94.27,108.77 94.44,108.61 95.38,108.61 95.45,108.6 95.51,108.61 96.09,108.61 96.14,108.59 96.18,108.59 96.23,108.59 96.28,108.61 96.85,108.61 96.9,108.59 96.95,108.59 96.99,108.59 97.08,108.61 97.14,108.54 97.14,108.42 97.03,108.3 96.84,108.3 96.68,108.15 96.68,107.95 96.65,107.92 96.56,107.78 96.52,107.61 96.52,107.46 96.21,107.46 95.91,107.76 95.54,107.76 95.24,107.46 95.24,107.21 94.88,106.85 94.88,106.42 94.83,106.37 94.05,106.37 93.99,106.43 93.99,107.29 93.99,107.32 93.99,107.34 93.98,107.52 93.89,107.68 93.86,107.72 93.5,108.07 93.5,108.92 93.56,108.97 94.23,108.97
+3V_S5 on TOP (solid shape): outline of 301 points within 79.41,107.1 92.18,115.61
+3V_S5 on BOTTOM (solid shape): 194.58,119.64 194.58,117.86 194.37,117.65 193.81,117.65 193.56,117.65 193.4,117.48 192.91,117.48 192.81,117.59 192.81,118.18 192.84,118.22 192.84,119.61 192.97,119.73 194.49,119.73
+3V_S5 on BOTTOM (solid shape): 4.59,33.95 4.59,33.45 4.1,32.95 3.5,32.95 3.39,32.84 3.39,32.48 3.11,32.2 2.74,32.2 2.55,32.39 2.55,33.06 2.53,33.08 2.53,33.83 2.75,34.05 4.49,34.05
+3V_S5 on BOTTOM (solid shape): 209.6,126.67 209.6,125.55 209.3,125.24 206.69,125.24 206.54,125.42 206.32,125.48 206.2,125.47 206.09,125.41 205.95,125.55 205.95,126.77 206.1,126.92 209.35,126.92
+3V_S5 on BOTTOM (solid shape): 76.08,117.42 76.08,116.22 78.49,113.81 78.49,113.79 78.52,113.71 78.58,113.64 79.34,112.88 79.34,112.86 79.47,112.61 79.74,112.51 79.88,112.53 80,112.6 80.02,112.61 80.13,112.61 80.56,112.18 80.56,111.88 79.4,110.72 78.83,110.72 74.35,115.19 74.35,117.05 75.11,117.81 75.68,117.81
+3V_S5 on BOTTOM (solid shape): 23.37,68.62 23.37,67.38 24.07,66.69 24.15,66.69 24.16,66.68 24.16,66.05 24.06,65.94 24.03,65.95 23.95,65.97 23.86,65.98 23.71,65.96 23.57,65.89 23.55,65.88 23.53,65.88 23.53,65.86 23.51,65.84 23.4,65.67 23.35,65.47 23.35,65.31 23.35,65.3 23.08,65.3 22.92,65.47 22.92,66.67 22.63,66.96 22.63,67.91 22.64,67.91 22.64,68.64 22.73,68.73 23.26,68.73
+3V_S5 on BOTTOM (solid shape): 95.33,107.49 95.31,107.41 95.31,107.36 95.41,107.09 95.66,106.96 95.68,106.96 95.73,106.91 95.83,106.84 95.95,106.82 96.03,106.82 96.05,106.8 96.13,106.75 96.22,106.74 96.52,106.74 96.56,106.74 96.62,106.68 96.62,105.66 96.4,105.43 95.86,105.43 95.6,105.17 95.59,105.17 95.38,105.02 95.31,104.78 95.33,104.65 95.39,104.53 95.42,104.49 95.38,104.45 95.29,104.31 95.25,104.15 95.25,103.03 94.44,103.03 94.43,103.03 94.28,103.18 94.28,104.63 93.98,104.92 92.82,104.92 92.82,104.93 92.82,106.3 92.89,106.37 93.63,106.37 93.98,106.73 93.98,107.32 93.99,107.36 94,107.43 94.11,107.54 95.28,107.54
+3V_S5 on BOTTOM (solid shape): outline of 528 points within 16.71,115.63 40.95,130.35
+3V_S5 on IN1 (solid shape): 75.59,117.83 75.59,117.33 75.02,116.76 74.75,116.76 74.48,116.71 74.26,116.56 74.16,116.46 70.99,116.46 70.86,116.59 70.86,117.88 71.06,118.07 75.34,118.07
+3V_S5 on IN1 (solid shape): 40.7,130.75 40.7,129.54 40.32,129.16 38.44,129.16 38.29,129.32 38.29,129.46 38.29,129.99 38.29,130.12 38.29,130.77 38.51,131 40.45,131
+3V_S5 on IN2 (solid shape): outline of 5387 points within 79.37,103.66 209.59,127.07
+3V_S5 on IN3 (solid shape): outline of 1752 points within 12.4,65.23 23.57,117.21
+3V_SSD on BOTTOM (solid shape): outline of 1519 points within 10.99,67.86 33.97,78.8
+3V_WLAN_P on TOP (solid shape): outline of 452 points within 191.41,104.12 196.3,122.62
+3V_WLAN_P on BOTTOM (solid shape): 192.65,105.52 194.06,105.52 194.17,105.4 194.17,104.24 194.21,104.2 194.21,104.19 194.25,104.12 194.32,104.08 194.34,104.07 194.37,104.04 194.8,104.04 194.96,103.88 194.96,103.58 194.85,103.48 190.95,103.48 190.64,103.79 190.64,105.55 192.2,105.55 192.2,105.75 190.64,105.75 190.64,105.97 190.71,106.04 192.13,106.04
+3V_WLAN_P on BOTTOM (solid shape): 193.4,123.56 193.39,123.55 193.36,123.46 193.35,123.36 193.45,123.09 193.71,122.96 193.73,122.96 193.9,122.78 193.9,122.77 193.96,122.7 194.05,122.67 194.13,122.65 194.19,122.65 194.24,122.65 194.29,122.65 194.35,122.67 194.43,122.67 194.5,122.69 194.56,122.75 194.57,122.77 194.66,122.77 194.68,122.75 194.73,122.69 194.81,122.67 194.88,122.67 194.94,122.65 195,122.65 195.38,122.65 195.48,122.67 195.57,122.73 195.62,122.77 196.04,122.77 196.17,122.65 196.17,122.15 196.6,121.73 196.6,120.39 196.52,120.31 192.89,120.31 192.69,120.51 192.69,122.29 192.23,122.74 192.2,122.74 192.2,122.75 190.76,122.75 190.64,122.87 190.64,123.05 192.2,123.05 192.2,123.25 190.64,123.25 190.64,123.51 190.74,123.62 192.74,123.62 192.84,123.72 193.4,123.72
+3VLCD_CON on TOP (solid shape): 76.56,194.35 76.63,194.3 76.7,194.26 76.71,194.26 77.02,193.95 77,193.89 77,193.85 77,193.55 77.06,193.38 77.22,193.3 77.24,193.29 77.75,192.78 77.75,190.27 77.55,190.06 75.87,190.06 75.76,190.18 75.76,191.73 76.05,192.02 76.05,193.14 75.9,193.29 75.49,193.29 75.24,193.54 75.24,194.33 75.31,194.41 76.51,194.41
+3VLCD_CON_R on TOP (solid shape): 74.85,193.11 74.93,193.07 74.94,192.97 74.93,192.94 74.93,192.91 74.93,192.59 74.46,192.12 74.37,191.99 74.34,191.83 74.46,191.54 74.74,191.42 74.9,191.45 75.03,191.54 75.43,191.94 75.47,191.94 75.52,191.91 75.51,191.86 75.19,191.54 75.19,190.32 75.16,190.29 74.65,190.29 74.02,190.92 73.55,190.92 73.47,191 73.47,191.3 73.26,191.51 72.98,191.51 72.55,191.94 72.55,192.94 72.72,193.11
+3VLCD_CON_R on BOTTOM (solid shape): 72.8,192.51 73,192.51 73,193.34 73.3,193.34 73.3,192.51 73.5,192.51 73.5,193.34 73.74,193.34 73.8,193.28 73.8,193.14 73.8,193.12 73.76,193.03 73.74,192.93 73.74,192.17 73.76,192.05 73.82,191.94 73.82,190.73 73.64,190.55 72.93,190.55 72.88,190.6 72.88,191.57 72.85,191.59 72.85,191.82 72.57,192.1 72.57,193.34 72.8,193.34
+3VPCU on TOP (solid shape): 75.82,97.25 75.82,96.5 75.93,96.39 76.55,96.39 76.57,96.36 76.57,95.9 76.52,95.85 76.52,95.54 76.51,95.53 76.51,95.09 76.39,94.97 75.51,94.97 75.31,95.17 75.3,95.2 75.3,97.41 75.32,97.43 75.64,97.43
+3VPCU on TOP (solid shape): 30.77,174.46 30.77,173.93 31.4,173.29 36.31,173.29 38.89,170.7 38.89,166.46 38.85,166.42 38.61,166.42 38.59,166.44 37.23,166.44 37.12,166.55 37.12,168.54 37.2,168.67 37.23,168.81 37.2,168.95 37.13,169.08 37.12,169.09 37.12,169.2 37.13,169.21 37.2,169.33 37.23,169.47 37.13,169.73 36.9,169.87 36.88,169.88 34.77,171.99 30.63,171.99 30.33,172.29 30.33,173.03 30.25,173.1 30.18,173.24 30.06,173.31 30.04,173.32 29.78,173.58 29.78,174.49 29.83,174.55 30.68,174.55
+3VPCU on BOTTOM (solid shape): 22.36,66.97 22.36,66.81 22.65,66.53 22.65,65.35 23.2,64.8 23.2,63.99 23.15,63.94 22.09,63.94 21.8,64.24 21.8,64.62 21.91,64.76 21.94,64.94 21.85,65.2 21.55,65.37 21.52,65.44 21.52,65.45 21.49,65.61 21.41,65.74 21.49,65.88 21.52,66.04 21.52,66.11 21.41,66.4 21.12,66.54 21.11,66.55 21.11,67.31 21.18,67.39 21.95,67.39
+3VPCU on BOTTOM (solid shape): 196.71,131.2 196.74,131.17 196.84,131.07 196.89,131.07 196.96,131.05 197.03,131.05 197.1,131.05 197.17,131.07 197.66,131.07 197.82,130.91 197.82,130.68 198.02,130.48 199.58,130.48 199.63,130.47 199.68,130.46 199.71,130.46 199.77,130.47 199.98,130.27 199.98,130.02 199.28,130.02 199.28,129.83 199.98,129.83 199.98,129.62 199.28,129.62 199.28,129.59 199.24,129.58 199.21,129.56 199.17,129.54 199.08,129.54 199.07,129.56 198.92,129.73 198.7,129.8 198.43,129.69 198.26,129.36 198.2,129.33 197.91,129.21 197.8,128.93 197.91,128.65 198.17,128.52 198.24,128.49 198.27,128.43 198.4,128.16 198.67,128.06 198.89,128.12 199.04,128.29 199.05,128.32 199.17,128.32 199.21,128.29 199.24,128.28 199.28,128.27 199.28,128.23 199.98,128.23 199.98,128.02 199.28,128.02 199.28,127.83 199.98,127.83 199.98,127.6 199.93,127.55 197.93,127.55 197.81,127.43 197.81,126.93 197.72,126.83 195.52,126.83 195.1,127.26 195.1,131.62 195.16,131.69 196.22,131.69
+3VPCU on IN1 (solid shape): outline of 656 points within 15.75,113.91 42.41,118.51
+3VPCU on IN2 (solid shape): outline of 591 points within 38.48,98.99 55.68,167.94
+3VPCU on IN2 (solid shape): outline of 2095 points within 11.83,63.67 22.8,116.74
+3VPCU on IN2 (solid shape): outline of 5739 points within 73.69,96.94 215.04,130.49
+3VPCU on IN4 (solid shape): 75.65,101.38 75.68,101.29 75.62,101.21 75.46,101.08 75.39,100.88 75.5,100.63 75.75,100.52 75.95,100.59 76.08,100.75 76.15,100.81 76.25,100.79 77.34,99.7 77.34,98.38 77.07,98.11 73.53,98.11 73,98.64 72.99,98.64 71.3,100.33 71.27,100.42 71.32,100.49 71.46,100.62 71.51,100.81 71.41,101.06 71.16,101.16 70.97,101.11 70.84,100.97 70.77,100.92 70.68,100.95 70.16,101.47 68.47,101.47 68.25,101.54 68.04,101.47 67.7,101.47 65.49,99.26 54.63,99.26 53.8,100.09 53.8,101.14 54.4,101.74 63.49,101.74 65.13,103.37 65.79,103.37 65.85,103.38 65.9,103.42 66.62,104.14 72.89,104.14
+3VPCU_EC on TOP (solid shape): 170.46,109.14 170.46,107.87 170.44,107.85 169.11,107.85 169.09,107.86 169.03,107.92 168.98,107.92 168.9,107.94 168.84,107.95 168.77,107.94 168.7,107.92 168.32,107.92 168.24,107.94 168.18,107.95 168.11,107.94 168,107.92 167.95,107.97 167.95,108.35 168,108.4 168.41,108.4 168.58,108.58 168.58,109.02 168.58,109.19 168.74,109.34 170.26,109.34
+3VSPI on TOP (solid shape): 95.31,99.73 95.31,99 94.96,98.65 94.96,97.21 94.81,97.06 93.92,97.06 93.6,97.38 93.6,97.65 93.63,97.67 93.63,98.05 93.67,98.15 93.68,98.25 93.67,98.35 93.63,98.45 93.63,99.07 93.6,99.1 93.6,99.67 93.74,99.8 95.23,99.8
+3VSPI on BOTTOM (solid shape): 121.67,102.04 121.67,100.4 121.53,100.26 120.01,100.26 119.93,100.34 119.93,100.96 120.25,101.27 120.25,101.72 120.12,101.86 120.12,102.27 120.23,102.38 121.33,102.38
+3VSPI on BOTTOM (solid shape): 122.13,109.75 122.13,108.96 122.1,108.94 119.79,108.94 119.64,108.78 119.64,108.58 119.62,108.54 119.62,108.51 119.62,108.27 119.23,107.88 118.98,107.88 118.97,107.88 118.87,107.91 118.77,107.92 118.43,107.78 118.29,107.44 118.3,107.34 118.33,107.25 118.34,107.24 118.34,106.75 118.27,106.68 117.72,106.68 117.54,106.86 117.47,106.91 117.4,106.95 117.4,107.08 117,107.49 117,107.87 117.16,108.03 117.52,108.03 117.59,108.1 117.59,109.6 117.76,109.78 122.1,109.78
+3VSPI on IN2 (solid shape): 96.29,98.96 96.29,98.62 95.76,98.09 93.78,98.09 93.75,98.12 93.75,98.52 93.86,98.62 95.13,98.62 95.83,99.33 95.92,99.33
+3VSPI on IN2 (solid shape): 121.37,102.05 121.37,101.26 121.18,101.07 121.18,100.73 121.08,100.63 120.39,100.63 120.12,100.9 120.12,101.18 120.22,101.44 120.12,101.7 120.12,102 120.27,102.15 121.27,102.15
+3VSPI on IN4 (solid shape): 121.04,105.04 121.04,104.9 121.01,104.89 120.8,104.56 121.01,104.24 121.04,104.23 121.04,103.93 121.09,103.72 121.21,103.53 121.72,103.02 121.72,102.06 121.28,101.62 120.22,101.62 120.02,101.83 120.02,104.59 119.11,105.5 119.06,105.6 118.99,105.68 117.49,107.18 117.41,107.25 117.31,107.3 117.05,107.57 117.05,107.82 117.2,107.97 118.11,107.97
+5V on TOP (solid shape): 21.69,136.89 21.69,136.02 19.53,133.87 17.25,133.87 17.15,133.97 17.15,135.2 18.37,136.43 18.6,136.43 18.66,136.48 18.8,136.48 19.3,136.98 21.6,136.98
+5V on TOP (solid shape): 22.56,151.06 22.56,149.71 22.13,149.28 20.06,149.28 19.22,148.45 19.19,148.48 19.06,148.57 18.9,148.6 18.68,148.54 18.53,148.36 18.52,148.33 17.68,148.33 16.53,147.18 14.64,147.18 14.53,147.29 14.53,148.19 14.59,148.25 16.14,148.25 16.14,148.25 16.26,148.25 16.32,148.32 16.44,148.32 16.9,148.78 17.8,148.78 17.92,148.9 18.07,148.9 19.3,150.13 19.3,150.62 20.08,151.4 22.21,151.4
+5V on TOP (solid shape): 30.88,161.65 30.88,161.4 31.26,161.02 31.26,160.63 31.38,160.51 31.8,160.51 31.96,160.35 31.96,157.98 31.82,157.9 31.71,157.76 31.08,157.76 30.82,158.01 30.82,159.01 30.46,159.37 30.37,159.49 30.25,159.58 30.2,159.63 30.1,159.63 30.06,159.63 30.03,159.64 29.99,159.63 29.95,159.63 29.62,159.63 29.42,159.83 29.42,161.16 29.52,161.25 29.81,161.25 29.94,161.38 30.08,161.38 30.51,161.81 30.72,161.81
+5V on TOP (solid shape): outline of 159 points within 69.64,187.58 73.78,190.24
+5V on TOP (solid shape): outline of 507 points within 212.8,107.59 223.7,124.2
+5V on BOTTOM (solid shape): 24.74,40.95 24.74,40.29 24.54,40.09 22.88,40.09 22.75,40.23 22.75,41.14 22.8,41.2 24.5,41.2
+5V on BOTTOM (solid shape): 11.01,34.64 11.01,33.69 9.94,32.61 9.94,31.23 9.71,31.01 9.14,31.01 9.07,31.01 8.64,31.01 8.48,31.18 8.48,31.67 8.29,31.86 7.46,31.86 7.32,32 7.32,32.82 7.41,32.91 8.67,32.91 9.61,33.85 10,33.85 10.12,33.97 10.12,34.59 10.24,34.72 10.94,34.72
+5V on BOTTOM (solid shape): 33.26,193.39 33.26,193.37 33.3,193.29 33.38,193.25 33.4,193.25 33.41,193.23 34.14,193.23 34.14,193.16 35.73,193.16 36.08,192.82 36.08,191.51 35.76,191.19 35.18,191.19 34.88,191.49 34.14,191.49 33.91,191.26 32.85,191.26 32.69,191.41 32.69,192.25 32.49,192.45 31.35,192.45 30.86,192.94 30.86,194.36 30.94,194.43 33.26,194.43
+5V on BOTTOM (solid shape): outline of 145 points within 165.85,110.9 170.55,116.98
+5V on IN1 (solid shape): 25,41.22 25,40.44 24.71,40.15 22.19,40.15 21.92,40.42 21.92,41.36 22.1,41.54 24.69,41.54
+5V on IN1 (solid shape): 10.76,35.22 10.76,33.45 10.18,32.87 9.69,32.87 9.46,33.1 9.46,35.28 9.66,35.48 10.51,35.48
+5V on IN1 (solid shape): outline of 384 points within 166.61,116.09 214.4,124.58
+5V on IN1 (solid shape): outline of 916 points within 29.39,175.96 63.86,196.26
+5V on SVCC (solid shape): outline of 515 points within 20.48,89.5 226.37,162.19
+5V on IN2 (solid shape): outline of 488 points within 59.76,189.1 73.67,196.23
+5V on IN2 (solid shape): outline of 931 points within 25.97,160.01 31.42,177.47
+5V on IN4 (solid shape): 10.94,36.56 10.94,33.59 10.21,32.86 9.52,32.86 9.25,33.14 9.25,36.7 9.37,36.82 10.67,36.82
+5V on IN4 (solid shape): 21.77,136.78 21.77,136.05 20.5,134.77 19.42,134.77 19.02,135.17 19.02,135.88 20.18,137.03 21.53,137.03
+5V_FAN on BOTTOM (solid shape): outline of 321 points within 168.12,110.73 181.4,119.19
+5V_HDD on TOP (solid shape): 228.02,109.47 228.02,104.92 228.39,104.55 228.41,104.51 228.4,104.48 228.32,104.36 228.3,104.21 228.39,103.96 228.61,103.82 228.65,103.81 228.65,103.4 228.53,103.27 224.72,103.27 224.59,103.4 224.59,109.55 225,109.95 227.54,109.95
+5V_HDD on BOTTOM (solid shape): 227.26,105 227.26,102.26 227.01,102 225.76,102 225.51,102.26 225.51,102.6 227.01,102.6 227.01,103.74 226.76,103.74 226.76,102.6 226.51,102.6 226.51,103.74 226.26,103.74 226.26,102.6 226.01,102.6 226.01,103.74 225.76,103.74 225.76,102.6 225.51,102.6 225.51,103.91 225.35,104.07 225.35,105.11 225.51,105.26 227,105.26
+5V_HDMIC on TOP (solid shape): 17.12,133.56 17.4,133.56 17.5,133.5 17.47,133.38 17.37,133.25 17.33,133.08 17.45,132.79 17.74,132.67 17.84,132.69 17.94,132.72 18.54,132.72 18.54,131.69 18.42,131.56 17.84,131.56 17.17,132.23 16.12,132.23 15.86,131.97 15.33,131.97 15.25,132.04 15.14,132.06 14.84,132.06 14.74,132.04 14.65,131.97 13.03,131.97 12.6,132.4 12.51,132.46 12.41,132.5 12.39,132.5 12.3,132.59 12.3,133.46 12.45,133.61 17.07,133.61
+5V_HDMIC on BOTTOM (solid shape): 14.13,132.42 14.21,132.42 14.23,132.41 14.28,132.39 14.32,132.38 14.34,132.38 14.7,132.39 14.78,132.3 15.8,132.3 16.08,132.03 16.08,130.06 15.95,129.93 13.1,129.93 12.85,130.18 12.85,130.63 12.41,131.07 11.82,131.07 11.6,131.29 11.6,131.52 12.91,131.52 12.92,131.46 12.93,131.41 12.95,131.35 12.98,131.3 13.01,131.26 13.05,131.22 13.09,131.18 13.14,131.15 13.2,131.13 13.25,131.12 13.31,131.11 13.37,131.11 13.42,131.12 13.48,131.14 13.53,131.17 13.57,131.2 13.62,131.23 13.65,131.28 13.68,131.33 13.71,131.38 13.72,131.43 13.73,131.49 13.73,131.55 13.72,131.6 13.71,131.66 13.68,131.71 13.65,131.76 13.62,131.8 13.57,131.84 13.53,131.87 13.48,131.9 13.42,131.91 13.37,131.92 13.31,131.93 13.25,131.92 13.2,131.91 13.14,131.88 13.09,131.86 13.05,131.82 13.01,131.78 12.98,131.73 12.95,131.68 12.93,131.63 12.92,131.57 12.91,131.52 11.6,131.52 11.6,132.52 12.11,133.03 13.51,133.03
+5V_KB on BOTTOM (solid shape): 224.03,135.82 224.03,133.6 223.68,133.25 220.89,133.25 220.51,133.62 220.51,134.23 222.04,134.23 222.18,134.36 222.18,135.58 222.14,135.62 220.51,135.62 220.51,136.23 223.62,136.23
+5V_KB on BOTTOM (solid shape): 219.94,123.7 219.94,123.03 219.92,122.96 219.91,122.91 219.91,122.59 219.87,122.51 219.79,122.49 219.74,122.5 219.69,122.5 219.54,122.48 219.42,122.4 219.36,122.38 219.29,122.4 219.17,122.48 219.03,122.5 218.97,122.5 218.77,122.41 218.64,122.23 218.62,122.14 218.62,122.09 218.64,121.95 218.68,121.87 218.68,121.76 218.95,121.5 218.95,121.14 218.89,121.08 217.51,121.08 217.5,121.08 217.15,121.08 217.02,121.2 217.02,123.11 217.73,123.82 219.82,123.82
+5V_KB on IN2 (solid shape): 224.08,134.08 224.08,128.55 220.7,125.17 220.7,123.67 219.95,122.92 218.84,122.92 218.65,123.11 218.65,123.7 219.32,124.38 219.32,125.83 222.32,128.83 222.32,134.15 222.51,134.34 223.83,134.34
+5V_PVDD on BOTTOM (solid shape): 22.26,41.75 22.26,39.86 22.1,39.69 22.1,37.63 22.05,37.59 22.05,36.73 21.66,36.33 21.3,36.33 21.28,36.36 21.28,36.43 21.52,36.67 21.52,37.8 21.43,37.88 21.4,37.91 21.37,37.94 21.19,38.12 21.19,40.47 20.99,40.66 19.72,40.66 19.7,40.65 19.4,40.65 19.1,40.34 19.1,39.29 19.54,38.84 19.54,38.06 19.45,37.97 18.95,37.97 18.29,38.62 18.29,41.58 18.65,41.94 22.08,41.94
+5V_S5 on TOP (solid shape): 35.89,159.17 35.89,159.12 36.18,158.82 36.23,158.72 36.33,158.67 37.64,158.67 37.92,158.39 37.92,157.44 37.85,157.37 34.17,157.37 33.82,157.73 33.82,158.55 34.06,158.8 34.06,159.42 35.64,159.42
+5V_S5 on BOTTOM (solid shape): 220.2,110.77 220.2,109.99 219.99,109.78 219.32,109.78 219.23,109.69 219.23,109.14 218.57,108.48 217.71,108.48 216.84,109.36 216.84,109.76 216.73,109.87 216.58,109.87 216.39,110.06 216.39,110.31 216.53,110.45 216.73,110.45 216.97,110.41 217.21,110.39 217.61,110.39 218,110.42 218.21,110.46 218.41,110.5 218.86,110.64 219.29,110.83 220.13,110.83
+5V_S5 on BOTTOM (solid shape): outline of 1808 points within 20.22,92.38 46.43,113.48
+5V_S5 on SVCC (solid shape): outline of 604 points within 42.3,96.03 220.27,110.77
+5V_S5 on IN2 (solid shape): outline of 3849 points within 28.29,108.08 37.07,159.86
+5VA on BOTTOM (solid shape): 11.63,32.42 11.63,32.04 12.12,31.54 13.11,31.54 13.33,31.32 13.33,30.52 13.65,30.2 15.07,30.2 15.57,30.71 16.51,30.71 16.61,30.61 16.51,30.51 16.01,30.51 15.85,30.35 15.85,29.89 16.11,29.64 16.11,29.2 15.61,28.71 15.61,27.16 15.27,26.82 15.27,26.51 15.34,26.44 15.34,26.16 15.19,26.01 14.74,26.01 14.64,26.1 14.64,26.2 14.62,26.2 11.43,29.39 11.43,30.01 10.61,30.83 10.61,32.39 10.7,32.48 11.57,32.48
+5VPCU on TOP (solid shape): 21.72,100.81 21.72,100.54 21.93,100.32 22.73,100.32 22.79,100.31 22.84,100.31 23.12,100.42 23.25,100.69 23.25,100.71 23.41,100.88 23.75,100.88 23.81,100.81 23.81,98.99 23.61,98.79 21.96,98.79 21.29,98.12 19.69,98.12 19.56,98.24 19.56,98.32 19.63,98.39 19.63,99.4 20.26,100.03 20.25,100.06 21.07,100.88 21.65,100.88
+5VPCU on TOP (solid shape): 38.56,166.11 38.56,165.21 38.52,165.17 37.85,165.17 37.85,164.88 37.84,164.83 37.84,164.79 37.84,164.51 37.84,164.47 37.85,164.43 37.85,164.4 37.45,164 37.24,164 37.19,163.99 37.14,163.96 37.13,163.95 36.29,163.95 36.08,163.95 36.08,164.7 35.88,164.7 35.88,163.95 35.68,163.95 35.68,164.26 35.69,164.3 35.69,164.34 35.69,164.98 36.2,165.48 36.27,165.48 36.45,165.56 36.52,165.74 36.52,165.84 36.84,166.15 36.87,166.19 38.48,166.19
+5VPCU on TOP (solid shape): 32.79,166.3 32.85,166.27 32.92,166.26 33.02,166.25 33.07,166.25 33.12,166.25 33.22,166.26 33.27,166.27 33.32,166.28 33.35,166.29 33.69,165.96 33.69,165.74 33.76,165.56 33.94,165.48 34.04,165.48 34.27,165.26 34.27,164.34 34.27,164.31 34.28,164.27 34.28,164.11 34.25,164.08 34.14,164.06 34.08,164.16 34.08,164.7 33.88,164.7 33.88,163.97 32.9,163.97 32.61,164.26 32.32,164.26 32.22,164.36 32.22,165.35 32.22,165.4 32.22,166.16 32.37,166.31 32.78,166.31
+5VPCU on BOTTOM (solid shape): 29.45,113.74 29.45,113.17 29.12,112.84 28.74,112.84 28.54,112.64 28.53,112.64 28.4,112.55 28.32,112.43 28.31,112.42 28.09,112.2 27.72,112.2 27.35,112.57 27.35,113.31 27.93,113.9 29.3,113.9
+5VPCU on BOTTOM (solid shape): 104.33,187.17 104.33,186.57 104.35,186.56 104.35,186 104.6,185.75 105.01,185.75 105.16,185.59 105.16,185.34 105.06,185.24 102.77,185.24 102.72,185.29 102.72,185.79 103.14,186.2 103.14,186.93 103.35,187.14 103.43,187.14 103.59,187.17 103.73,187.24 104.26,187.24
+5VPCU on BOTTOM (solid shape): 223.93,127.81 223.93,126.24 223.8,126.12 221.72,126.12 221.66,126.18 221.66,126.4 222.49,126.4 222.49,126.6 221.66,126.6 221.66,126.9 222.49,126.9 222.49,127.1 221.66,127.1 221.66,127.4 222.49,127.4 222.49,127.6 221.86,127.6 221.78,127.64 221.77,127.73 221.79,127.81 221.82,127.9 223.84,127.9
+5VPCU on BOTTOM (solid shape): 19.42,58.8 19.42,58.68 19.41,58.67 19.4,58.57 19.41,58.47 19.42,58.46 19.42,58.34 20.04,57.72 20.36,57.72 20.36,57.68 20.72,57.68 20.73,57.66 20.73,57.43 20.36,57.43 20.36,57.4 20.05,57.4 19.86,57.21 16.49,57.21 16.35,57.32 16.18,57.35 16.07,57.34 15.97,57.29 15.4,57.29 15.3,57.39 15.3,58.37 15.47,58.54 15.58,58.54 15.62,58.53 15.66,58.54 15.7,58.54 15.9,58.54 16.17,58.81 18.22,58.81 18.23,58.81 19.4,58.81
+5VPCU on BOTTOM (solid shape): 42.51,104.64 42.56,104.64 42.57,104.63 42.75,104.59 42.93,104.63 42.95,104.64 43.23,104.64 45.32,102.55 45.32,102.54 45.41,102.41 45.54,102.33 45.55,102.32 45.86,102.01 46.8,101.07 52.57,101.07 52.76,100.87 52.76,100.72 52.73,100.71 52.47,100.33 52.73,99.95 52.76,99.94 52.76,98.15 52.62,98.01 51.86,98.01 51.85,98.02 51.85,99.69 51.65,99.89 46.39,99.89 42.92,103.35 42.87,103.35 42.7,103.52 42.08,103.52 41.19,104.41 41.19,105 41.58,105.38 41.77,105.38
+5VPCU on BOTTOM (solid shape): 14.41,49.28 14.41,46.61 14.23,46.43 12.12,46.43 12.05,46.45 11.98,46.46 11.91,46.45 11.84,46.43 10.76,46.43 10.62,46.29 10.62,46.04 10.4,45.83 10.09,45.83 10,45.81 9.91,45.77 8.54,45.77 8.47,45.84 8.47,46.71 8.26,46.92 8.07,46.92 8.06,46.95 7.67,47.23 7.29,46.95 7.28,46.92 6.89,46.92 6.63,47.18 6.51,47.4 6.29,47.52 6.24,47.57 6.24,47.78 6.24,48.35 6.26,48.38 8.57,48.38 8.71,48.51 8.71,49.39 8.89,49.57 14.12,49.57
+5VPCU on BOTTOM (solid shape): outline of 402 points within 32.27,163.98 42.65,184.88
+5VPCU on IN1 (solid shape): outline of 550 points within 196.32,124.63 223.79,130.88
+5VPCU on IN1 (solid shape): outline of 641 points within 161,124.87 177.71,133.91
+5VPCU on SVCC (solid shape): outline of 787 points within 2.53,43.46 93.78,190.52
+5VPCU on IN2 (solid shape): outline of 1541 points within 151.8,131.79 164.1,169.56
+5VPCU on IN2 (solid shape): outline of 2018 points within 41.75,175.5 104.66,189.03
+V3.3DX_1.5DX_ADO on TOP (solid shape): 113,118.09 113,117.83 113.27,117.56 113.77,117.56 113.77,117.55 113.92,117.55 113.94,117.53 113.94,117.12 113.52,116.7 112.98,116.7 112.91,116.62 112.5,116.62 112.43,116.69 112.43,118.02 112.5,118.1 112.99,118.1
+V3A_LX on BOTTOM (solid shape): 181.03,134.36 181.03,133.11 182.24,131.9 182.24,125.61 181.84,125.21 181.07,125.21 180.88,125.4 180.88,126.03 178.95,127.96 178.95,130.98 178.72,131.21 176.89,131.21 176.71,131.21 176.71,132.58 179.58,132.58 180.45,133.45 180.45,134.41 180.55,134.5 180.89,134.5
+V3A_OUT on BOTTOM (solid shape): 188.27,132.71 188.27,130.98 188.73,130.53 188.8,130.52 189.61,130.52 189.66,130.53 190.17,130.53 190.22,130.52 191.03,130.52 191.08,130.53 191.62,130.53 191.67,130.52 192.48,130.52 192.53,130.53 192.59,130.53 192.84,130.78 192.84,131.26 193.25,131.67 194.14,131.67 194.24,131.57 194.24,127.83 194.16,127.76 188.73,127.76 187.4,126.44 183.89,126.44 183.89,133.78 183.91,133.85 183.92,133.91 183.92,134.21 183.92,134.26 184.05,134.39 185.36,134.39
+V5P5A_LX on BOTTOM (solid shape): 53.98,182.52 53.99,182.52 54.87,182.52 55.2,182.52 55.2,181.2 54.31,180.31 54.31,179.19 54.18,179.07 53.72,179.07 53.38,179.24 53.05,179.07 52.93,179.07 52.56,179.3 52.19,179.07 50.73,179.07 50.37,179.42 50.37,183.51 52.99,183.51
+V5P5A_OUT on BOTTOM (solid shape): 48.92,188.79 48.92,179.57 47.51,178.17 45.26,178.17 45.12,178.31 45.12,178.79 44.94,178.97 44.45,178.97 43.84,179.57 42.9,179.57 42.78,179.7 42.78,185.33 43.05,185.33 43.06,185.28 43.07,185.22 43.09,185.17 43.12,185.12 43.15,185.07 43.19,185.03 43.23,185 43.28,184.97 43.34,184.95 43.39,184.93 43.45,184.93 43.5,184.93 43.56,184.94 43.61,184.96 43.67,184.98 43.71,185.01 43.76,185.05 43.79,185.09 43.82,185.14 43.84,185.19 43.86,185.25 43.87,185.31 43.87,185.36 43.86,185.42 43.84,185.47 43.82,185.52 43.79,185.57 43.76,185.62 43.71,185.65 43.67,185.69 43.61,185.71 43.56,185.73 43.5,185.74 43.45,185.74 43.39,185.73 43.34,185.72 43.28,185.7 43.23,185.67 43.19,185.64 43.15,185.6 43.12,185.55 43.09,185.5 43.07,185.45 43.06,185.39 43.05,185.33 42.78,185.33 42.78,185.65 42.79,185.66 42.79,186.11 42.93,186.25 43.31,186.25 43.41,186.15 44.4,186.15 44.78,186.53 47.17,186.53 47.58,186.94 47.58,188.84 47.92,189.17 48.54,189.17
+VCC_CORE on TOP (solid shape): outline of 2239 points within 105.77,137.57 145.3,157.94
+VCC_CORE on BOTTOM (solid shape): outline of 402 points within 127.23,135.55 145.98,157.98
+VCC_CORE on BOTTOM (solid shape): outline of 379 points within 105.99,137.79 108.72,146.81
+VCC_CORE on BOTTOM (solid shape): outline of 604 points within 116.45,138.19 120.37,146.84
+VCC_CORE on IN1 (solid shape): outline of 665 points within 107.66,138.59 120.17,147.24
+VCC_CORE on SVCC (solid shape): 151.69,151.55 151.69,146.72 151.49,146.58 151.42,146.35 151.47,146.16 151.61,146.02 151.47,145.88 151.42,145.69 151.49,145.46 151.69,145.33 151.69,137.44 131.73,137.44 131.04,138.12 130.96,138.18 130.86,138.2 106.59,138.2 105.97,138.81 105.97,148.76 106.15,148.94 106.17,148.94 106.42,149.04 106.53,149.29 106.53,149.32 108.69,151.48 108.75,151.56 108.77,151.66 108.77,153.69 120.31,153.69 120.41,153.69 128.31,153.69 128.43,153.58 128.6,153.54 128.77,153.58 128.89,153.69 136.2,153.69 136.38,153.77 136.45,153.95 136.45,156.42 138.03,156.42 138.03,158.01 145.24,158.01
+VCC_CORE on IN2 (solid shape): outline of 4174 points within 105.82,137.66 145.43,158.14
+VCC_XD on BOTTOM (solid shape): 34.01,43.43 34.01,42.16 33.77,41.92 32.91,41.92 32.62,41.63 30.89,41.63 30.66,41.86 30.66,42.81 30.95,43.1 30.95,43.1 31.45,43.6 33.85,43.6
+VCC_XD on BOTTOM (solid shape): 33.77,66.62 33.81,66.61 33.86,66.62 33.91,66.62 33.93,66.62 34.06,66.5 34.06,64.89 33.98,64.82 30.64,64.82 30.21,64.39 30.02,64.39 29.76,64.64 29.76,65.43 30.22,65.89 30.25,65.89 30.29,65.93 30.43,65.93 30.46,65.93 32.76,65.93 32.79,65.97 32.87,65.97 33.53,66.62 33.72,66.62
+VCC_XD on IN1 (solid shape): 34.03,66.46 34.03,65.19 33.81,64.97 31.5,64.97 31.45,65.02 31.45,66.12 31.91,66.57 33.91,66.57
+VCC_XD on IN1 (solid shape): 33.18,44.07 33.31,43.93 33.49,43.89 33.55,43.89 33.91,43.53 33.91,42.3 33.47,41.86 32.77,41.86 32.58,42.05 31.97,42.05 31.64,42.38 31.64,43.79 31.92,44.07
+VCCGT on TOP (solid shape): outline of 1935 points within 107.59,153.21 134.42,171.75
+VCCGT on BOTTOM (solid shape): outline of 2061 points within 110.39,155.29 135.69,173.98
+VCCGT on SVCC (solid shape): 135.94,161.17 133.54,161.17 133.28,161.17 133.28,156.42 135.94,156.42 135.94,154.2 128.78,154.2 128.69,154.24 128.6,154.25 128.51,154.24 128.42,154.2 120.68,154.2 120.55,154.35 120.36,154.4 120.17,154.35 120.04,154.2 119.65,154.2 119.51,154.35 119.32,154.41 119.13,154.35 119,154.2 117.38,154.2 117.26,154.38 117.04,154.45 116.88,154.41 116.75,154.3 116.61,154.42 116.43,154.47 116.21,154.39 116.07,154.2 108.77,154.2 108.77,154.66 109,154.79 109.09,155.04 109,155.29 108.77,155.41 108.77,155.72 108.75,155.82 108.69,155.9 108,156.59 108,159.43 108.36,159.79 108.74,159.79 108.86,159.71 108.99,159.69 109.23,159.78 109.34,160.01 110.47,161.13 110.53,161.21 110.54,161.31 110.54,171.22 135.94,171.22
+VCCGT on IN2 (solid shape): outline of 2951 points within 108.33,154.73 134.82,171.5
+VCCGT_+VCORE on TOP (solid shape): outline of 700 points within 107.8,146.98 123.63,154.96
+VCCGT_+VCORE on BOTTOM (solid shape): outline of 142 points within 116.25,146.98 118.68,154.99
+VCCGT_+VCORE on IN1 (solid shape): 110.41,149 110.93,149 111.06,148.93 111.2,148.9 116.67,148.9 117.12,148.45 117.12,148.05 116.59,147.52 108.58,147.52 108.31,147.79 108.33,147.83 108.35,147.9 108.36,147.98 108.27,148.21 108.03,148.31 107.95,148.3 107.88,148.27 107.85,148.26 107.77,148.33 107.77,148.5 107.8,148.57 107.87,148.6 107.95,148.57 108.03,148.56 108.36,148.89 108.03,149.22 107.95,149.21 107.87,149.18 107.8,149.21 107.77,149.28 107.77,149.65 108.41,150.29 109.12,150.29
+VCCGT_+VCORE on IN4 (solid shape): 123.78,155.42 123.79,155.41 123.84,155.29 123.94,155.21 123.94,153.28 123.83,153.04 123.94,152.8 123.94,150.38 123.87,150.3 123.82,150.2 123.82,150.19 123.59,149.96 123.59,148.95 123.57,148.93 123.38,148.64 123.57,148.34 123.59,148.33 123.59,147.31 123.5,147.21 123.42,147.21 122.99,147.64 122.99,148.41 122.93,148.67 122.79,148.89 122.72,148.96 122.72,154.99 122.81,155.18 122.84,155.39 122.84,155.65 123.55,155.65
+VCCIO on TOP (solid shape): 107.35,138.41 107.35,137.98 107.19,137.82 107.19,136.95 107.26,136.88 107.63,136.88 107.73,136.78 107.73,136.55 107.54,136.37 106.17,136.37 105.97,136.57 105.97,138.2 106.27,138.5 107.26,138.5
+VCCIO on TOP (solid shape): 106.9,148.2 108.71,148.2 108.75,148.16 108.75,147.23 108.9,147.08 108.9,146.81 108.75,146.66 106.76,146.66 106.35,146.25 105.98,146.25 105.83,146.4 105.84,146.43 105.88,146.52 105.89,146.61 105.86,146.75 105.79,146.87 105.79,147.26 105.89,147.52 105.79,147.78 105.79,148.18 105.86,148.3 105.89,148.43 105.88,148.51 105.86,148.57 105.85,148.61 105.97,148.73 106.37,148.73
+VCCIO on TOP (solid shape): 131.39,127.41 131.32,127.29 131.3,127.16 131.41,126.89 131.68,126.78 131.9,126.85 132.04,127.03 132.05,127.06 132.29,127.06 132.35,127.04 132.4,127.04 132.45,127.04 132.51,127.06 133.02,127.06 133.03,127.06 133.12,127.04 133.22,127.06 133.23,127.06 133.32,127.06 133.37,127.01 133.37,126.21 132.69,125.53 132.69,124.12 132.58,124.02 130.86,124.02 130.83,124.05 130.83,124.75 130.98,124.9 130.98,124.92 130.99,124.93 131.06,125.05 131.09,125.19 130.99,125.46 130.73,125.6 130.71,125.6 130.44,125.87 129.87,125.87 129.81,125.82 129.75,125.81 129.7,125.77 128.8,125.77 128.74,125.83 128.74,126.24 129.29,126.78 129.29,127.54 129.47,127.73 131.07,127.73
+VCCIO on BOTTOM (solid shape): 106.35,137.69 107.85,137.69 107.9,137.66 107.97,137.64 108.05,137.56 108.05,137.47 107.92,137.34 107.91,137.34 107.87,137.34 107.72,137.18 107.72,136.9 107.9,136.73 107.97,136.73 108.05,136.65 108.05,136.55 107.92,136.42 106.35,136.42 106.27,136.35 106.09,136.35 105.97,136.47 105.97,136.53 105.97,136.62 105.97,136.69 106.09,136.81 106.09,137.29 105.99,137.39 105.99,137.64 106.09,137.74 106.3,137.74
+VCCIO on BOTTOM (solid shape): 131.29,126.77 131.47,126.64 131.68,126.6 131.78,126.61 131.89,126.64 132.74,126.64 133.76,125.62 133.76,123.61 133.58,123.43 131.77,123.43 131.41,123.78 131.41,124.62 131.04,125 131.05,125.03 131.08,125.11 131.09,125.19 130.97,125.48 130.68,125.6 130.6,125.59 130.52,125.56 130.49,125.55 130.38,125.65 130.38,126.66 130.55,126.83 131.23,126.83
+VCCIO on BOTTOM (solid shape): 106.35,148.68 106.41,148.66 106.48,148.65 106.55,148.66 106.61,148.68 106.62,148.69 107.27,148.69 107.28,148.68 107.34,148.66 107.41,148.65 107.47,148.66 107.53,148.68 107.55,148.69 107.76,148.69 107.78,148.69 107.8,148.67 107.96,148.58 108.18,148.6 108.21,148.58 108.26,148.54 108.26,146.98 108.15,146.87 107.97,146.87 107.94,146.9 106.69,146.9 106.2,146.4 106.05,146.4 105.94,146.51 105.94,146.83 105.95,146.86 105.96,146.86 106.07,147.07 105.96,147.27 105.95,147.28 105.94,147.3 105.94,147.74 105.95,147.77 105.96,147.77 106.07,147.98 105.96,148.18 105.95,148.19 105.94,148.21 105.94,148.51 106.12,148.69 106.34,148.69
+VCCIO on IN2 (solid shape): outline of 5674 points within 105.41,124.73 136.12,149.3
+VCCIO on IN4 (solid shape): outline of 118 points within 105.82,136.01 108.41,148.74
+VCCLDOSRAM_1P24 on TOP (solid shape): outline of 88 points within 107.63,115.99 109.13,120.02
+VCCLDOSRAM_1P24 on IN2 (solid shape): outline of 642 points within 105.6,118.94 110.21,129.64
+VCCPLL on TOP (solid shape): outline of 420 points within 116.79,128.39 134.86,133.65
+VCCPLL_OC on TOP (solid shape): 90.98,139.9 90.98,139.88 90.95,139.81 90.94,139.73 90.95,139.66 90.98,139.59 90.98,139 91.63,138.35 91.63,137.69 91.54,137.6 90.78,137.6 89.36,139.02 89.36,139.71 89.52,139.88 90.21,139.88 90.22,139.87 90.58,139.87 90.66,139.94 90.94,139.94
+VCCPLL_OC on TOP (solid shape): outline of 233 points within 101.75,135.5 106.32,137.71
+VCCRTC on TOP (solid shape): 90.95,111.35 90.95,111.25 91.27,110.93 91.27,110.53 91.24,110.5 90.56,110.5 90.56,110.43 90.5,110.43 90.31,110.24 90.27,110.24 90.26,110.25 90.19,110.27 90.11,110.28 89.27,110.28 89.19,110.32 89.17,110.41 89.18,110.46 89.19,110.52 89.17,110.62 89.13,110.73 89.13,110.88 89.61,111.37 89.64,111.37 89.98,111.71 90.6,111.71
+VCCRTC on IN3 (solid shape): outline of 734 points within 102.23,127.45 108.94,134.31
+VCCSA on TOP (solid shape): outline of 1390 points within 107.8,128.77 152.98,139.72
+VCCSA on BOTTOM (solid shape): 147.37,132.27 147.49,132.2 147.62,132.18 147.75,132.2 147.86,132.26 147.87,132.27 148,132.27 148.01,132.25 148.14,132.18 148.28,132.16 148.43,132.18 148.56,132.27 152.84,132.27 153.35,131.76 153.35,129.16 153.33,129.14 153.29,129.09 153.28,129.03 153.28,128.65 153.29,128.58 153.33,128.53 153.35,128.51 153.35,125.6 153.18,125.43 149.93,125.43 149.78,125.58 149.78,126.76 149.59,126.95 149.59,128.73 149.29,129.03 147.92,129.03 147.73,129.22 147.73,129.43 147.74,129.45 147.77,129.54 147.78,129.63 147.66,129.92 147.38,130.04 147.32,130.04 147.24,130.11 147.22,130.11 147.2,130.1 146.49,130.1 146.47,130.13 146.09,130.4 145.71,130.13 145.7,130.1 145.35,130.1 145.34,130.1 145.26,130.13 145.17,130.14 145.08,130.13 145,130.1 144.99,130.1 144.69,130.1 144.68,130.1 144.6,130.13 144.51,130.14 144.42,130.13 144.34,130.1 144.33,130.1 143.35,130.1 143.11,130.34 143.11,132.15 143.23,132.27
+VCCSA on BOTTOM (solid shape): outline of 138 points within 115.76,133.83 118.61,138.04
+VCCSA on BOTTOM (solid shape): outline of 85 points within 106.3,133.88 109.12,137.33
+VCCSA on SVCC (solid shape): outline of 121 points within 106.48,119.91 152.87,137.69
+VCCST on TOP (solid shape): outline of 901 points within 115.98,130.65 136.7,135.31
+VCCSTG on BOTTOM (solid shape): 127.79,140.12 127.79,139.53 127.85,139.53 127.85,139.43 127.51,139.08 127.51,138.31 127.24,138.05 126.84,138.05 126.75,138.14 126.75,139.45 126.42,139.77 126.42,140.1 126.53,140.21 127.7,140.21
+VDD_IO on TOP (solid shape): 67.78,98.87 68.09,98.56 68.5,98.56 68.65,98.41 68.86,98.35 69.02,98.39 69.16,98.48 69.23,98.52 69.31,98.49 69.42,98.37 69.42,98.19 69.46,98.08 69.57,98.04 70.26,98.04 70.45,97.85 70.45,96.85 70.31,96.72 68.55,96.72 68.51,96.75 68.45,96.8 68.37,96.81 67.95,96.81 67.72,97.04 67.72,97.29 67.65,97.47 67.47,97.54 67.22,97.54 67.01,97.75 66.98,97.78 66.94,97.83 66.94,97.9 66.97,97.98 66.98,98.07 66.94,98.24 66.83,98.38 66.83,98.78 66.93,98.88 67.73,98.88
+VDD_IO on BOTTOM (solid shape): 66.35,99 66.55,99 66.55,100.29 66.85,100.29 66.85,99 66.89,99 66.9,98.96 66.95,98.88 67.05,98.85 67.35,98.85 67.4,98.86 67.45,98.88 67.51,98.9 67.58,98.87 68.13,98.32 68.13,97.92 68.04,97.83 67,97.83 66.94,97.89 66.95,97.92 66.97,97.99 66.98,98.07 66.86,98.36 66.57,98.47 66.54,98.47 66.47,98.46 66.05,98.88 66.05,100.23 66.11,100.29 66.35,100.29
+VDDD_SUPPLY on BOTTOM (solid shape): 18.18,47.7 19.16,47.7 19.24,47.62 19.24,47.4 18.18,47.4 18.18,47.2 19.24,47.2 19.24,46.77 19.22,46.73 19.22,46.69 19.22,45.7 19.22,45.67 19.24,45.63 19.24,44.31 19.15,44.21 19.11,44.08 19.1,44.04 16.49,44.04 16.47,44.06 16.47,44.67 16.69,44.89 16.71,44.89 16.81,44.94 16.85,45.04 16.85,45.12 16.85,45.13 16.87,45.23 16.85,45.34 16.85,45.35 16.85,45.42 16.84,45.45 16.83,45.49 16.83,45.74 16.84,45.78 16.85,45.81 16.85,45.88 16.85,45.89 16.87,46 16.85,46.1 16.85,46.11 16.85,46.19 16.84,46.22 16.83,46.25 16.83,47.36 17.21,47.74 18.18,47.74
+VDDQ_P on TOP (solid shape): 90.12,181.05 90.12,178.03 89.87,177.77 86.16,177.77 86.16,181.15 86.34,181.33 89.84,181.33
+VDDQ_P on BOTTOM (solid shape): 85.25,183.51 85.25,182.7 85.35,182.6 90.55,182.6 90.9,182.25 90.9,181.48 90.91,181.43 90.94,181.37 90.94,179.75 90.93,179.74 90.89,179.56 90.93,179.38 90.94,179.37 90.94,178.8 90.9,178.72 90.81,178.7 90.72,178.71 90.63,178.72 90.23,178.62 89.92,178.36 85.81,178.36 85.73,178.39 85.71,178.47 85.71,178.53 85.56,178.89 85.21,179.04 85.14,179.04 85.07,179.02 85.04,179.02 84.99,179.07 82.32,179.07 81.82,179.57 81.82,183.34 82.16,183.69 85.07,183.69
+VDDQ_VTT on TOP (solid shape): 48.58,105.59 48.58,105.01 47.36,103.78 44.88,103.78 44.85,103.81 44.85,104.63 44.99,104.78 45.16,104.78 45.32,104.83 45.41,104.97 45.42,105.01 46.26,105.01 46.32,105.01 46.39,105.04 46.51,105.04 47.14,105.66 48.51,105.66
+VDDQ_VTT on TOP (solid shape): 55.43,107.08 56.27,107.08 56.31,107.03 56.31,106.48 56.6,106.19 57.37,106.19 57.53,106.03 57.53,104.68 57.5,104.65 54.51,104.65 54.27,104.89 54.27,105.13 54.29,105.15 54.4,105.18 54.5,105.24 54.87,105.61 54.88,105.61 54.88,105.63 54.9,105.64 54.94,105.64 54.95,105.64 55.5,106.04 54.91,106.38 54.81,106.38 54.77,106.47 54.77,107.15 54.83,107.21 55.3,107.21
+VDDQ_VTT on BOTTOM (solid shape): 71.75,179.52 71.93,179.36 72.17,179.29 72.27,179.3 72.32,179.26 72.34,179.2 72.34,178.56 72.3,178.55 72.2,178.51 72.11,178.45 72.04,178.42 71.97,178.44 71.84,178.52 71.69,178.55 71.41,178.43 71.29,178.14 71.31,178.01 71.38,177.88 71.38,177.64 71.35,177.57 71.28,177.54 71.26,177.54 70.97,177.42 70.85,177.13 70.88,176.99 70.95,176.87 70.97,176.8 70.94,176.73 70.39,176.17 69.09,176.17 68.74,176.53 68.74,177.7 69.06,178.02 69.18,177.98 69.31,177.96 69.67,178.11 69.82,178.47 69.81,178.51 69.82,178.55 69.85,178.57 70.08,178.71 70.18,178.96 70.18,179.52
+VDDQ_VTT on BOTTOM (solid shape): outline of 300 points within 43.79,100.72 57.67,105.74
+VIN on TOP (solid shape): outline of 4042 points within 53.24,119.48 175.21,206.52
+VIN on BOTTOM (solid shape): 156.11,140.56 156.11,138.55 156.37,138.3 158.68,138.3 159.24,137.74 159.24,135.18 158.5,134.44 158.41,134.37 158.34,134.29 153.47,134.29 153.24,134.52 153.24,135.35 153.29,135.4 154.44,135.4 154.84,135.81 154.84,135.82 154.84,140.54 154.92,140.61 156.06,140.61
+VIN on BOTTOM (solid shape): 98.96,206.42 98.96,206.07 98.96,206.07 98.96,205.29 98.98,205.27 99.08,205.1 99.24,204.99 99.27,204.97 99.27,200.73 99.06,200.53 98.05,200.53 98,200.58 98,202.51 97.82,202.69 96.5,202.69 96.07,203.12 96.07,206.47 96.22,206.63 98.76,206.63
+VIN on BOTTOM (solid shape): 54.48,188.27 54.48,187.89 54.9,187.47 55.02,187.47 55.2,187.3 55.43,187.3 55.45,187.27 55.45,185.69 55.44,185.63 55.44,185.58 55.44,184.58 55.44,184.53 55.45,184.47 55.45,182.78 55.22,182.78 54.89,183.11 54.89,185.06 54.26,185.7 52.12,185.7 52.07,185.75 52.07,189 52.23,189.15 53.6,189.15
+VIN on BOTTOM (solid shape): 176.98,130.77 176.98,126.87 176.75,126.64 174.1,126.64 173.6,126.14 173.59,126.13 173.53,126.1 173.49,126.04 173.49,126.03 173.31,125.85 171.28,125.85 171.07,126.06 167.26,126.06 166.78,125.57 164.75,125.57 164.39,125.93 164.39,128.75 164.65,129 168.96,129 169.75,128.22 175.14,128.22 175.44,128.52 176.23,128.52 176.46,128.75 176.46,130.96 176.79,130.96
