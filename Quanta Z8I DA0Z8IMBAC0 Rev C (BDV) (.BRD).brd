# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 127.99,117.2 127.99,116.67 127.97,116.65 127.97,114.72 127.93,114.71 127.74,114.58 127.66,114.35 127.67,114.27 127.38,113.98 127.38,113.62 127.28,113.52 127.04,113.52 126.94,113.61 126.94,114.46 126.84,114.56 126.84,114.63 126.79,114.74 126.69,114.79 126.62,114.79 126.47,114.93 126.47,115.61 126.38,115.7 125.9,115.7 125.69,115.91 125.69,116.31 125.88,116.5 127.01,116.5 127.24,116.74 127.24,117.15 127.32,117.23 127.61,117.23 127.65,117.27 127.92,117.27
GND on BOTTOM (solid shape): 29.31,38.52 29.31,38.13 29.3,38.12 29.05,37.85 29.12,37.49 29.15,37.45 29.07,37.38 28.22,37.38 28.04,37.3 27.97,37.12 27.97,37.07 26.83,35.92 26.78,35.85 26.76,35.77 26.76,35.06 26.54,34.84 26,34.84 26,35.6 26.16,35.76 26.16,35.8 26.18,35.83 26.18,36.47 26.62,36.92 26.62,38.35 26.78,38.51 27.47,38.51 27.76,38.79 29.04,38.79
GND on BOTTOM (solid shape): 58.23,121.94 58.21,121.87 58.21,121.83 58.22,121.73 58.27,121.64 58.27,121.53 58.18,121.48 57.6,121.48 57.59,121.5 57.57,121.53 57.54,121.55 57.5,121.56 57.5,121.7 55.82,121.7 55.75,121.73 55.72,121.8 55.72,121.84 55.75,121.92 55.82,121.95 57.5,121.95 57.5,122.09 57.54,122.1 57.57,122.12 57.59,122.14 57.6,122.16 58.01,122.16
GND on BOTTOM (solid shape): 22.13,58.28 22.13,56.21 21.91,55.99 21.9,55.99 21.85,56 21.8,56 21.75,56 21.7,55.99 21.1,55.99 21,56.04 20.88,56.06 20.77,56.04 20.66,55.99 19.93,55.99 19.83,56.04 19.71,56.06 19.6,56.04 19.5,55.99 18.63,55.99 18.13,55.5 17.84,55.5 17.64,55.71 17.64,56.48 18.21,57.05 20.24,57.05 20.36,57.17 20.82,57.17 20.88,57.24 20.88,57.36 20.89,57.37 20.89,57.72 20.88,57.73 20.88,58.28 20.99,58.39 22.02,58.39
GND on BOTTOM (solid shape): 62.4,185.67 62.75,185.32 62.75,185.2 62.8,185.09 62.9,185.05 63.02,185.05 63.27,184.8 63.27,182.55 63.22,182.5 62.61,182.5 62.43,182.32 62.21,182.32 62.15,182.33 62.09,182.34 62.03,182.33 61.96,182.32 61.86,182.32 61.45,182.72 61.41,182.76 61.35,182.78 61.34,182.78 61.11,183.02 60.67,183.02 60.67,183.13 60.63,183.24 60.52,183.28 60.43,183.28 60.12,183.59 60.13,183.64 60.13,183.94 60.11,184.04 60.05,184.12 60.05,185.51 60.22,185.68 62.37,185.68
GND on BOTTOM (solid shape): 16.38,84.49 16.38,83.86 16.87,83.37 16.87,81.68 16.36,81.18 16.36,79.04 15.55,78.24 15.07,78.24 14.55,77.72 12.27,77.72 12.27,79.19 12.34,79.19 12.48,79.2 12.62,79.21 12.76,79.24 12.9,79.27 13.03,79.31 13.17,79.36 13.3,79.41 13.42,79.48 13.55,79.54 13.64,79.6 16.2,79.6 16.2,81.15 16,81.15 16,79.6 15.7,79.6 15.7,81.15 15.5,81.15 15.5,79.6 13.64,79.6 13.67,79.62 13.78,79.7 13.89,79.79 14,79.89 14.1,79.99 14.19,80.09 14.28,80.2 14.36,80.32 14.43,80.44 14.5,80.56 14.56,80.69 14.62,80.82 14.66,80.95 14.7,81.09 14.73,81.22 14.76,81.36 14.77,81.48 15.6,81.48 15.88,81.76 15.9,81.76 16.11,81.96 16.11,83.03 14.91,84.22 14.91,84.48 15.17,84.73 16.13,84.73
GND on BOTTOM (solid shape): 127.49,151.79 127.77,151.79 127.99,151.56 127.99,150.75 127.89,150.64 127.49,150.64 127,150.16 127,148.97 127.18,148.79 128.1,148.79 128.71,149.4 129.44,149.4 129.62,149.58 129.62,150.19 129.86,150.42 134.77,150.42 135.03,150.16 135.03,149.31 134.88,149.16 134.88,148.46 135.64,147.7 136.55,147.7 136.76,147.5 136.76,146.73 136.93,146.55 137.75,146.55 137.85,146.45 137.85,144.09 137.8,144.04 137.22,144.04 136.96,143.79 136.96,143.44 136.83,143.31 136.83,143.2 136.66,143.03 136.66,142.41 136.83,142.24 136.83,141.58 137.24,141.18 137.24,139.67 137.12,139.55 131.64,139.55 131.48,139.7 131.48,140.87 131.27,141.08 129.25,141.08 129.06,141.27 129.06,142.19 128.47,142.78 128.47,146.81 127.96,147.31 127.31,147.31 126.73,147.9 126.73,150.55 127.21,151.03 127.21,151.58 126.95,151.84 126.95,151.96 127.05,152.07 127.21,152.07
GND on BOTTOM (solid shape): 107.45,129.99 107.48,129.9 107.54,129.82 107.68,129.67 107.9,129.64 107.92,129.64 107.95,129.63 108.11,129.47 108.11,129.3 108.02,129.21 107.99,129.08 108.04,128.93 108.18,128.84 108.19,128.84 108.34,128.68 108.35,128.66 108.44,128.5 108.6,128.41 108.62,128.41 108.79,128.23 108.79,126.26 108.69,126.16 108.3,126.16 107.87,126.59 107.54,126.59 107.1,127.03 107.1,128.66 106.99,128.76 106.99,128.76 106.79,128.97 106.79,129.67 107.14,130.03 107.44,130.03
GND on BOTTOM (solid shape): 46.88,142.34 46.87,142.28 46.87,142.24 46.88,142.14 46.93,142.05 46.91,142 46.91,141.94 46.91,141.91 46.92,141.85 46.67,141.6 46.55,141.6 46.48,141.59 46.42,141.55 46.37,141.5 46.3,141.5 46.21,141.57 46.23,141.68 46.32,142.09 45.95,142.3 45.91,142.3 45.78,142.27 45.67,142.2 45.63,142.23 45.61,142.28 45.61,142.45 45.6,142.47 45.6,142.65 46.58,142.65
GND on BOTTOM (solid shape): 19.41,93.75 19.54,93.48 19.82,93.37 19.87,93.37 19.92,93.38 20,93.36 20.04,93.28 20.04,92.4 20.32,92.12 21.29,92.12 21.49,91.92 21.49,89.97 20.72,89.2 20.72,88.5 20.54,88.32 18.08,88.32 17.68,87.91 16.56,87.91 16.23,88.24 16.23,88.92 16.27,89 16.36,89.02 16.43,89 16.61,89.01 16.71,89.06 16.75,89.08 16.86,88.97 16.93,88.9 19.7,88.9 19.75,88.95 19.81,88.99 19.86,89.06 19.92,89.11 19.92,89.9 19.31,90.51 19.31,90.85 19.21,90.95 18.9,90.95 18.8,91.06 18.8,91.56 18.81,91.57 18.81,93.11 18.8,93.11 18.8,93.62 18.98,93.8 19.41,93.8
GND on BOTTOM (solid shape): 46.97,141.19 46.95,141.17 46.87,141.05 46.84,140.91 46.84,140.83 46.87,140.76 46.87,140.69 46.82,140.63 46.69,140.5 46.64,140.32 46.64,140.29 46.65,140.23 46.42,140 46.33,140 46.23,140.06 46.25,140.17 46.32,140.29 46.35,140.42 46.25,140.67 45.99,140.77 45.88,140.75 45.77,140.69 45.67,140.68 45.61,140.75 45.61,140.95 45.6,140.97 45.6,141.14 46.72,141.14 46.83,141.26 46.97,141.26
GND on BOTTOM (solid shape): 171.58,109.44 171.58,106.47 170.63,106.47 170.56,106.49 170.49,106.5 170.42,106.49 170.35,106.47 169.97,106.47 169.9,106.49 169.83,106.5 169.76,106.49 169.69,106.47 169.31,106.47 169.24,106.49 169.17,106.5 169.1,106.49 169.02,106.47 168.77,106.47 167.9,107.34 167.9,108.35 168.18,108.63 168.2,108.63 168.33,108.66 168.44,108.73 168.51,108.75 168.57,108.73 168.7,108.66 168.84,108.63 169.12,108.75 169.24,109.04 169.2,109.22 169.08,109.36 169.04,109.44 169.07,109.52 169.09,109.54 171.48,109.54
GND on BOTTOM (solid shape): 198.92,131.46 202.92,130.97 206.95,130.91 206.97,130.91 207.24,130.64 207.24,129.99 207.11,129.87 206.11,129.87 205.9,130.08 205.89,130.08 205.85,130.12 203.94,130.12 203.53,130.53 201.21,130.53 201.09,130.42 201.09,129.08 201.15,129.02 201.99,129.02 201.99,129.02 201.99,128.85 201.96,128.82 201.28,128.82 201.28,128.82 201.21,128.82 201.1,128.71 201.1,126.87 201.14,126.83 201.14,126.82 201.82,126.14 202.25,126.14 202.59,125.8 202.6,125.8 203.59,125.8 204,125.39 204.06,125.39 204.12,125.33 204.38,125.33 204.47,125.27 204.46,125.17 204.42,125.07 204.41,124.96 204.41,124.68 204.31,124.58 202.92,124.58 201.36,126.15 200.51,126.15 200.36,126.3 198.4,126.3 198.04,126.66 198.04,127.32 198.11,127.4 200.09,127.4 200.2,127.5 200.2,130.43 200.03,130.6 199.86,130.6 199.84,130.63 198.12,130.63 198.06,130.69 198.06,131.25 198.27,131.46 198.91,131.46
GND on BOTTOM (solid shape): 51.71,145.46 51.77,145.43 51.83,145.41 51.86,145.41 51.88,145.37 51.92,145.35 51.95,145.34 51.95,145.2 53.71,145.2 53.71,145.34 53.74,145.35 53.76,145.36 53.79,145.38 53.85,145.42 53.93,145.4 54.05,145.33 54.19,145.31 54.23,145.31 54.29,145.32 54.7,144.91 54.72,144.8 54.62,144.74 53.86,144.74 53.84,144.74 53.81,144.74 53.77,144.78 53.74,144.8 53.71,144.81 53.71,144.95 51.95,144.95 51.95,144.81 51.92,144.8 51.89,144.78 51.86,144.74 51.69,144.74 51.55,144.89 51.49,144.92 51.43,144.94 51.29,144.94 50.64,145.59 50.62,145.7 50.71,145.76 50.87,145.81 50.99,145.94 51.24,145.94
GND on BOTTOM (solid shape): 92.27,180.67 92.27,180.19 92.29,180.11 92.34,180.04 92.5,179.88 92.5,179.46 92.48,179.39 92.48,179.34 92.58,179.07 92.83,178.93 92.9,178.89 92.91,178.8 92.89,178.73 92.88,178.66 93,178.37 93.29,178.25 93.32,178.25 93.36,178.25 93.45,178.21 93.46,178.11 93.34,177.84 93.24,177.56 93.23,177.55 93.13,177.45 92.19,177.45 92.18,177.49 92.03,177.69 91.79,177.77 91.61,177.72 91.46,177.6 91.39,177.55 91.3,177.58 91.19,177.7 91.19,180.57 91.35,180.72 92.22,180.72
GND on BOTTOM (solid shape): 6.74,55.18 6.74,54.41 6.68,54.35 4.15,54.35 3.84,54.03 3.62,54.03 3.4,54.26 2.76,54.26 2.59,54.09 2.59,52.49 2.76,52.32 3.21,52.32 3.45,52.08 3.45,51.46 3.4,51.37 3.29,51.38 3.18,51.44 3.05,51.46 2.76,51.34 2.64,51.05 2.7,50.85 2.85,50.7 2.9,50.62 2.87,50.54 2.52,50.18 2.52,47.22 2.74,46.99 2.77,46.96 2.85,46.88 3.44,46.88 3.64,46.67 3.64,46.36 3.73,46.27 3.73,46.26 3.79,46.18 3.88,46.12 3.89,46.11 3.94,46.06 4.41,46.06 4.6,46.25 4.6,48.35 4.64,48.39 5.05,48.39 5.05,47.78 5.24,47.78 5.24,48.39 5.53,48.39 5.55,48.37 5.55,47.76 5.55,47.76 5.55,47.34 5.82,47.07 5.83,47.02 5.83,45.91 5.44,45.52 3.59,45.52 3.26,45.85 2.35,45.85 2.15,46.05 2.15,54.77 2.43,55.06 4.67,55.06 5.13,55.51 6.41,55.51
GND on BOTTOM (solid shape): outline of 109 points within 127.62,154.3 140.51,157.01
GND on BOTTOM (solid shape): 29,79.6 29.04,79.6 29.05,79.56 29.1,79.48 29.2,79.45 30,79.45 30.1,79.48 30.15,79.56 30.16,79.6 30.2,79.6 30.2,81.15 30.5,81.15 30.5,79.6 30.54,79.6 30.55,79.56 30.6,79.48 30.7,79.45 31.5,79.45 31.6,79.48 31.65,79.56 31.66,79.6 31.7,79.6 31.7,81.15 32,81.15 32,79.6 32.04,79.6 32.05,79.56 32.1,79.48 32.2,79.45 33,79.45 33.1,79.48 33.15,79.56 33.16,79.6 33.2,79.6 33.2,81.15 33.5,81.15 33.5,79.6 33.7,79.6 33.7,81.15 35.34,81.15 35.49,81 35.49,76.49 34.99,75.99 34.16,75.97 33.65,75.3 33.64,75.26 33.44,75.26 33.25,75.46 33.25,77.04 32.38,77.91 32.35,77.91 32.34,77.92 27.95,77.92 27.71,78.15 27.71,79.45 28.5,79.45 28.6,79.48 28.65,79.56 28.66,79.6 28.7,79.6 28.7,81.15 29,81.15
GND on BOTTOM (solid shape): 101.82,198.09 101.95,197.95 102.13,197.87 102.15,197.87 102.26,197.76 102.26,197.68 102.88,197.06 102.96,197.06 103.9,196.12 103.9,194.99 103.73,194.82 103.28,194.82 103.26,194.84 103.05,195.05 102.87,195.12 102.69,195.05 102.49,194.85 102.47,194.83 102.45,194.8 101.28,193.62 100.72,193.62 100.53,193.81 100.46,193.86 100.38,193.88 100.34,193.89 100.33,193.93 100.33,194.21 100.43,194.32 100.51,194.5 100.43,194.67 100.24,194.87 100.06,194.95 99.88,194.87 99.67,194.66 99.64,194.63 99.56,194.59 99.48,194.61 99.09,195.01 99.09,195.64 99.19,195.73 99.25,195.86 99.26,195.87 99.72,196.33 99.79,196.3 99.85,196.29 100.15,196.29 100.33,196.37 100.41,196.55 100.41,197.02 101.48,198.09
GND on BOTTOM (solid shape): 127.1,109.5 127.1,107.68 128.12,106.66 128.12,106.56 128.17,106.45 128.27,106.41 128.3,106.41 128.31,106.39 128.36,106.35 128.43,106.34 129.23,106.34 129.25,106.32 129.3,106.27 129.37,106.25 130.45,106.25 130.83,105.88 130.83,105.12 130.27,104.57 128.12,104.57 128.04,104.61 128.03,104.7 127.27,105.76 126.52,104.7 126.51,104.61 126.43,104.57 124.23,104.57 124.15,104.61 124.13,104.7 124.06,105.38 123.53,105.82 123.5,105.83 123.5,109.52 123.63,109.65 126.95,109.65
GND on BOTTOM (solid shape): outline of 109 points within 83.85,182.69 90.9,185.76
GND on BOTTOM (solid shape): 13.42,192.77 13.42,191.78 13.42,191.7 13.42,190.7 12.41,190.7 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.81,194.89 9.5,195.69 10.5,195.69
GND on BOTTOM (solid shape): 15.49,83.32 15.49,81.74 15.43,81.68 14.03,81.68 13.32,80.97 13.32,80.35 12.67,79.7 12.12,79.7 11.48,79.85 10.92,80.2 9.4,80.2 8.69,79.49 8.69,71.2 8.43,70.95 7.23,70.95 6.92,70.64 6.92,69.57 6.72,69.37 6.26,69.37 6.17,69.46 5.97,69.62 5.73,69.68 5.71,69.68 5.64,69.71 5.61,69.78 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.61 13.42,83.77 15.04,83.77
GND on BOTTOM (solid shape): 10.91,121.63 11.91,121.63 12.67,120.87 12.67,116.6 13.77,115.96 14.27,114.78 15.37,113.67 15.37,112.7 14.62,111.94 14.18,111.94 14.15,111.95 14.11,111.96 13.87,112.08 13.6,112.12 13.49,112.12 13.38,112.1 13.3,112.11 13.26,112.19 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78 9.81,122.11 9.88,122.18 10.36,122.18
GND on BOTTOM (solid shape): outline of 117 points within 98.22,120.11 102.13,122.94
GND on BOTTOM (solid shape): 14.16,102.5 14.22,102.49 15.11,102.49 15.95,101.64 15.95,100.55 14.97,99.57 14.97,99.11 18.04,99.11 19.43,97.71 19.43,96.82 19.69,96.57 19.69,96.21 19.26,95.78 16.95,95.78 15.42,97.3 14.97,97.3 14.97,94.62 14.27,93.93 14.21,93.85 14.11,93.86 13.87,93.98 13.6,94.02 13.49,94.02 13.38,94 13.3,94.01 13.26,94.09 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.25 13.3,102.33 13.38,102.34 13.49,102.32 13.6,102.32 13.87,102.36 14.11,102.48
GND on BOTTOM (solid shape): 132.34,217.37 132.34,213.7 131.91,213.27 131.81,213.24 131.74,213.3 131.59,213.5 131.36,213.57 131.15,213.52 131,213.37 130.92,213.32 130.83,213.36 130.69,213.48 130.51,213.52 130.1,213.11 130.51,212.71 130.71,212.76 130.86,212.91 130.94,212.96 131.03,212.92 131.12,212.84 131.22,212.78 131.28,212.71 131.26,212.62 131.01,212.37 131.01,210.02 130.82,209.83 130.1,209.83 129.93,209.99 129.93,211.43 129.3,212.06 129.27,212.15 129.32,212.22 129.46,212.37 129.51,212.57 129.39,212.86 129.11,212.98 128.91,212.93 128.76,212.79 128.72,212.76 128.67,212.79 128.65,212.83 128.65,213.86 129.07,215.05 129.22,216.3 129.22,217.42 129.24,217.44 132.27,217.44
GND on BOTTOM (solid shape): 6.99,63.8 6.99,63.31 6.98,63.17 6.99,63.03 6.99,62.79 7.4,62.38 8.82,62.38 8.85,62.34 8.85,60.04 5.02,56.21 4.33,55.7 3.5,55.52 2.02,55.52 2.02,55.17 1.69,54.84 1.69,45.8 2.02,45.47 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.27 3.5,31.27 3.76,31.26 4.01,31.21 4.15,31.07 4.15,30.4 3.99,30.24 3.67,30.24 3.59,30.25 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.64 6.14,63.64 6.43,63.92 6.86,63.92
GND on BOTTOM (solid shape): 178.64,130.83 178.64,124.51 178.24,124.1 173.04,124.1 172.96,124.14 172.94,124.22 172.95,124.26 172.95,124.3 172.83,124.58 172.54,124.7 172.4,124.68 172.28,124.61 172.21,124.59 172.15,124.61 172.02,124.69 171.88,124.71 171.47,124.31 171.88,123.9 172.02,123.92 172.14,123.99 172.21,124.02 172.27,123.99 172.34,123.94 172.41,123.91 172.48,123.84 172.45,123.74 172.05,123.34 169.39,123.34 168.76,123.98 168.73,124.06 168.77,124.14 168.91,124.28 168.96,124.48 168.84,124.77 168.55,124.89 168.27,124.77 168.15,124.5 168.08,124.41 167.97,124.43 167.29,125.12 167.26,125.12 167.26,125.73 167.41,125.88 171.04,125.88 171.22,125.7 172.63,125.7 172.74,125.65 172.87,125.64 172.99,125.65 173.1,125.7 173.38,125.7 174.11,126.44 176.86,126.44 177.17,126.74 177.17,126.89 177.17,127.75 177.17,127.76 177.17,131.01 178.46,131.01
GND on BOTTOM (solid shape): outline of 146 points within 130.36,131.85 142.13,135.97
GND on BOTTOM (solid shape): outline of 158 points within 100.83,170.95 129.51,175.22
GND on BOTTOM (solid shape): 17.32,129.59 17.32,129.35 17.3,129.27 17.29,129.2 17.3,129.13 17.32,129.06 17.32,128.17 17.3,128.03 17.3,127.97 17.32,127.9 17.32,127.43 17.31,127.43 17.29,127.33 17.29,127.24 17.3,127.2 17.32,127.15 17.32,126.3 17.31,126.29 17.27,126.12 17.31,125.95 17.32,125.94 17.32,125.61 17.31,125.59 17.28,125.49 17.28,125.39 17.29,125.33 17.32,125.27 17.32,124.38 17.31,124.38 17.29,124.25 17.31,124.12 17.32,124.11 17.32,123.64 17.32,123.5 17.32,123.28 17.26,123.22 16.53,123.22 16.29,123.47 16.29,125.82 16.32,125.89 16.66,126.05 16.77,126.33 16.73,126.49 16.63,126.63 16.6,126.71 16.63,126.78 16.73,126.92 16.77,127.09 16.65,127.38 16.36,127.5 16.22,127.47 16.1,127.4 16.06,127.39 16.03,127.4 15.95,127.46 15.85,127.48 15.55,127.48 15.37,127.41 15.3,127.23 15.3,127.12 15.26,127.07 15.21,127.08 15.05,127.24 15.05,127.39 15,127.51 14.87,127.56 14.72,127.56 14.59,127.51 14.54,127.39 14.54,127.03 14.01,127.03 13.93,127.01 13.87,126.97 13.21,126.32 13.2,126.32 13.01,126.5 13.01,129.65 13.13,129.76 17.15,129.76
GND on BOTTOM (solid shape): outline of 146 points within 141.02,132.08 159.59,167.23
GND on BOTTOM (solid shape): outline of 113 points within 117.6,133.07 121.05,136.73
GND on BOTTOM (solid shape): outline of 264 points within 139.76,207.52 148.22,217.39
GND on BOTTOM (solid shape): outline of 115 points within 107.54,160.38 111.03,164.82
GND on BOTTOM (solid shape): outline of 348 points within 1.01,132.29 15.03,177.99
GND on BOTTOM (solid shape): outline of 309 points within 120.49,138.33 122.6,145.99
GND on BOTTOM (solid shape): outline of 450 points within 44.29,90.97 60.4,99.59
GND on BOTTOM (solid shape): outline of 167 points within 57.02,132.08 63.85,137.62
GND on BOTTOM (solid shape): outline of 153 points within 103.45,138.57 105.88,145.58
GND on BOTTOM (solid shape): outline of 391 points within 0.51,0.51 236.99,218.99
GND on BOTTOM (solid shape): outline of 2044 points within 100.32,134.15 106.07,159.06
GND on BOTTOM (solid shape): outline of 2914 points within 98.14,145.86 108.77,166.06
GND on BOTTOM (solid shape): outline of 14522 points within 42.99,105.04 68.12,175.66
GND on SGND (solid shape): outline of 3234 points within 0.51,0.51 236.99,218.99
GND on IN1 (solid shape): 30.12,62.15 30.12,59.3 29.87,59.05 28.85,59.05 28.75,59.15 28.75,60.2 28.85,60.32 28.89,60.48 28.86,60.63 28.77,60.75 28.75,60.77 28.75,60.86 28.77,60.87 28.86,60.99 28.89,61.14 28.85,61.3 28.75,61.43 28.75,61.96 29.06,62.27 30,62.27
GND on IN1 (solid shape): 15.49,83.32 15.49,80.82 14.37,79.7 12.31,79.7 11.57,79.81 10.92,80.2 9.4,80.2 8.69,79.49 8.69,71.2 8.43,70.95 7.23,70.95 6.92,70.64 6.92,69.57 6.72,69.37 6.26,69.37 6.17,69.46 5.97,69.62 5.73,69.68 5.71,69.68 5.64,69.71 5.61,69.78 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.61 13.42,83.77 15.04,83.77
GND on IN1 (solid shape): 13.42,192.77 13.42,191.78 13.42,191.7 13.42,190.7 12.41,190.7 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.81,194.89 9.5,195.69 10.5,195.69
GND on IN1 (solid shape): 14.16,102.5 14.22,102.49 15.11,102.49 15.95,101.64 15.95,100.55 14.97,99.57 14.97,94.62 14.27,93.93 14.21,93.85 14.11,93.86 13.87,93.98 13.6,94.02 13.49,94.02 13.38,94 13.3,94.01 13.26,94.09 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.25 13.3,102.33 13.38,102.34 13.49,102.32 13.6,102.32 13.87,102.36 14.11,102.48
GND on IN1 (solid shape): 9.81,122.57 9.88,122.66 10,122.62 10.23,122.4 10.62,122.32 10.7,122.34 12.16,122.34 12.67,121.82 12.67,116.6 13.77,115.96 14.27,114.78 15.37,113.67 15.37,112.7 14.62,111.94 14.18,111.94 14.15,111.95 14.11,111.96 13.87,112.08 13.6,112.12 13.49,112.12 13.38,112.1 13.3,112.11 13.26,112.19 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78
GND on IN1 (solid shape): 6.99,63.8 6.99,63.31 6.98,63.17 6.99,63.03 6.99,62.79 7.4,62.38 8.82,62.38 8.85,62.34 8.85,60.04 5.02,56.21 4.33,55.7 3.5,55.52 2.02,55.52 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.27 3.5,31.27 3.76,31.26 4.01,31.21 4.15,31.07 4.15,30.4 3.99,30.24 3.67,30.24 3.59,30.25 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.64 6.14,63.64 6.43,63.92 6.86,63.92
GND on IN1 (solid shape): outline of 348 points within 1.01,132.29 14.1,177.99
GND on IN1 (solid shape): outline of 1829 points within 0.51,0.51 236.99,218.99
GND on SVCC (solid shape): 3.26,15.12 3.26,14.35 3.28,14.25 3.34,14.17 3.59,13.92 3.67,13.86 3.77,13.85 8.31,13.85 8.41,13.86 8.49,13.92 8.66,14.09 10.91,14.09 10.91,14.09 11.79,14.09 11.99,14.3 12.65,14.3 12.65,14.2 12.3,14.09 11.59,13.74 10.88,13.18 10.54,12.84 10.16,12.21 9.92,11.71 9.73,11.01 9.67,10.3 9.67,5.43 6.87,5.93 4.61,4.21 3.94,4.52 3.2,4.63 2.53,4.63 2.53,15.24 3.15,15.24
GND on SVCC (solid shape): 103.94,204.75 103.96,204.65 104.01,204.57 110.18,198.4 103.73,198.4 103.38,198.7 103.03,198.4 99.97,198.4 99.86,198.63 99.62,198.73 99.37,198.62 99.26,198.37 99.27,198.28 99.31,198.19 93.85,192.73 93.8,192.65 93.78,192.55 93.78,191.03 86.82,191.03 84.71,188.92 84.66,188.84 84.64,188.74 84.64,184.28 81.48,181.12 46.9,181.12 45.77,182.25 45.77,183.66 45.76,183.76 45.7,183.84 44.18,185.37 44.09,185.42 44,185.44 43.83,185.44 43.46,185.71 43.1,185.44 39.87,185.44 39.87,189.51 42,189.51 42.34,189.31 42.67,189.51 48.06,189.51 48.35,189.56 48.6,189.73 52.44,193.57 61.27,193.57 61.56,193.63 61.81,193.8 63.58,195.57 63.75,195.82 63.81,196.11 63.81,205.72 97.74,205.72 98.71,205.91 99.53,206.46 100,206.93 100.08,207.01 103.94,210.87
GND on SVCC (solid shape): 226.17,130.8 226.91,129.01 228.7,128.27 235.47,128.27 235.47,106.44 235.43,106.36 235.35,106.34 234.33,105.5 235.35,104.66 235.43,104.63 235.47,104.56 235.47,87.37 235.18,86.69 234.5,86.4 231.5,86.4 230.82,86.69 230.53,87.37 230.53,87.87 229.79,89.66 228,90.4 226.88,90.4 226.88,103.83 226.92,103.83 227.16,103.96 227.26,104.21 227.19,104.44 227,104.57 226.94,104.63 226.93,104.7 226.95,104.76 226.95,104.82 226.93,104.94 226.88,105.05 226.88,112.7 226.88,115.13 226.88,115.14 226.88,122.04 224.18,124.74 214.79,124.74 212.4,127.13 212.4,131.52 214.29,131.92 216.17,132.43 223.75,138.57 226.17,138.57
GND on SVCC (solid shape): outline of 82 points within 131.12,170.46 167.97,217.47
GND on SVCC (solid shape): outline of 521 points within 2.53,14.33 35.57,79.78
GND on SVCC (solid shape): outline of 144 points within 42.98,109.5 110.04,173
GND on SVCC (solid shape): outline of 554 points within 124.51,112.29 201.98,176.55
GND on SVCC (solid shape): outline of 108 points within 2.53,73.43 16.56,175.51
GND on IN2 (solid shape): 105.62,116.53 105.62,114.91 102.07,114.91 102.07,116.53 102.17,116.64 105.51,116.64
GND on IN2 (solid shape): 15.49,83.32 15.49,82 13.19,79.7 12.31,79.7 11.57,79.81 10.92,80.2 9.4,80.2 8.69,79.49 8.69,71.2 8.43,70.95 7.23,70.95 6.92,70.64 6.92,69.57 6.72,69.37 6.26,69.37 6.17,69.46 5.97,69.62 5.73,69.68 5.71,69.68 5.64,69.71 5.61,69.78 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.61 13.42,83.77 15.04,83.77
GND on IN2 (solid shape): 13.42,192.77 13.42,191.78 13.42,191.7 13.42,190.7 12.41,190.7 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.81,194.89 9.5,195.69 10.5,195.69
GND on IN2 (solid shape): 14.16,102.5 14.22,102.49 15.11,102.49 15.95,101.64 15.95,100.55 14.97,99.57 14.97,94.62 14.27,93.93 14.21,93.85 14.11,93.86 13.87,93.98 13.6,94.02 13.49,94.02 13.38,94 13.3,94.01 13.26,94.09 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.25 13.3,102.33 13.38,102.34 13.49,102.32 13.6,102.32 13.87,102.36 14.11,102.48
GND on IN2 (solid shape): 6.99,63.8 6.99,62.79 7.4,62.38 8.82,62.38 8.85,62.34 8.85,60.04 5.02,56.21 4.33,55.7 3.5,55.52 2.02,55.52 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.27 3.5,31.27 3.76,31.26 4.01,31.21 4.15,31.07 4.15,30.4 3.99,30.24 3.67,30.24 3.59,30.25 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.64 6.14,63.64 6.43,63.92 6.86,63.92
GND on IN2 (solid shape): 9.81,122.57 9.88,122.66 10,122.62 10.23,122.4 10.62,122.32 10.7,122.34 12.16,122.34 12.67,121.82 12.67,116.6 13.77,115.96 14.27,114.78 15.37,113.67 15.37,112.7 14.62,111.94 14.18,111.94 14.15,111.95 14.11,111.96 13.87,112.08 13.6,112.12 13.49,112.12 13.38,112.1 13.3,112.11 13.26,112.19 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78
GND on IN2 (solid shape): outline of 344 points within 1.01,132.29 14.1,177.99
GND on IN2 (solid shape): outline of 1829 points within 0.51,0.51 236.99,218.99
GND on IN2 (solid shape): outline of 12410 points within 130.66,171.7 167.92,207.34
GND on IN2 (solid shape): outline of 18160 points within 45.14,104.39 110.04,180.28
GND on IN3 (solid shape): 15.49,83.32 15.49,80.82 14.37,79.7 12.31,79.7 11.57,79.81 10.92,80.2 9.4,80.2 8.69,79.49 8.69,71.2 8.43,70.95 7.23,70.95 6.92,70.64 6.92,69.57 6.72,69.37 6.26,69.37 6.17,69.46 5.97,69.62 5.73,69.68 5.71,69.68 5.64,69.71 5.61,69.78 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.61 13.42,83.77 15.04,83.77
GND on IN3 (solid shape): 13.42,192.77 13.42,191.78 13.42,191.7 13.42,190.7 12.41,190.7 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.81,194.89 9.5,195.69 10.5,195.69
GND on IN3 (solid shape): 14.16,102.5 14.22,102.49 15.11,102.49 15.95,101.64 15.95,100.55 14.97,99.57 14.97,94.62 14.27,93.93 14.21,93.85 14.11,93.86 13.87,93.98 13.6,94.02 13.49,94.02 13.38,94 13.3,94.01 13.26,94.09 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.25 13.3,102.33 13.38,102.34 13.49,102.32 13.6,102.32 13.87,102.36 14.11,102.48
GND on IN3 (solid shape): 9.81,122.57 9.88,122.66 10,122.62 10.23,122.4 10.62,122.32 10.7,122.34 12.16,122.34 12.67,121.82 12.67,116.6 13.77,115.96 14.27,114.78 15.37,113.67 15.37,112.7 14.62,111.94 14.18,111.94 14.15,111.95 14.11,111.96 13.87,112.08 13.6,112.12 13.49,112.12 13.38,112.1 13.3,112.11 13.26,112.19 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78
GND on IN3 (solid shape): 6.99,63.8 6.99,63.31 6.98,63.17 6.99,63.03 6.99,62.79 7.4,62.38 8.82,62.38 8.85,62.34 8.85,60.04 5.02,56.21 4.33,55.7 3.5,55.52 2.02,55.52 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.27 3.5,31.27 3.76,31.26 4.01,31.21 4.15,31.07 4.15,30.4 3.99,30.24 3.67,30.24 3.59,30.25 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.64 6.14,63.64 6.43,63.92 6.86,63.92
GND on IN3 (solid shape): outline of 339 points within 1.01,132.29 14.1,177.99
GND on IN3 (solid shape): outline of 1833 points within 0.51,0.51 236.99,218.99
GND on SGND1 (solid shape): outline of 3273 points within 0.51,0.51 236.99,218.99
GND on IN4 (solid shape): 105.62,115.06 105.47,114.91 102.07,114.91 102.07,116.51 105.62,116.51
GND on IN4 (solid shape): 13.42,192.77 13.42,191.78 13.42,191.7 13.42,190.7 12.41,190.7 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.81,194.89 9.5,195.69 10.5,195.69
GND on IN4 (solid shape): 15.49,83.32 15.49,82.38 12.81,79.7 12.31,79.7 11.57,79.81 10.92,80.2 9.4,80.2 8.69,79.49 8.69,76.29 8.06,75.66 8.06,72.02 8.63,71.46 8.63,71.14 8.43,70.95 7.23,70.95 6.92,70.64 6.92,69.57 6.72,69.37 6.26,69.37 6.17,69.46 5.97,69.62 5.73,69.68 5.71,69.68 5.64,69.71 5.61,69.78 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.61 13.42,83.77 15.04,83.77
GND on IN4 (solid shape): 14.16,102.5 14.22,102.49 15.11,102.49 15.95,101.64 15.95,100.55 14.97,99.57 14.97,94.62 14.27,93.93 14.21,93.85 14.11,93.86 13.87,93.98 13.6,94.02 13.49,94.02 13.38,94 13.3,94.01 13.26,94.09 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.25 13.3,102.33 13.38,102.34 13.49,102.32 13.6,102.32 13.87,102.36 14.11,102.48
GND on IN4 (solid shape): 6.99,63.8 6.99,62.79 7.4,62.38 8.82,62.38 8.85,62.34 8.85,60.04 5.02,56.21 4.33,55.7 3.5,55.52 2.02,55.52 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.27 3.5,31.27 3.76,31.26 4.01,31.21 4.15,31.07 4.15,30.4 3.99,30.24 3.67,30.24 3.59,30.25 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.64 6.14,63.64 6.43,63.92 6.86,63.92
GND on IN4 (solid shape): 9.81,122.57 9.88,122.66 10,122.62 10.23,122.4 10.62,122.32 10.7,122.34 12.16,122.34 12.67,121.82 12.67,116.6 13.77,115.96 14.27,114.78 15.37,113.67 15.37,112.7 14.62,111.94 14.18,111.94 14.15,111.95 14.11,111.96 13.87,112.08 13.6,112.12 13.49,112.12 13.38,112.1 13.3,112.11 13.26,112.19 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78
GND on IN4 (solid shape): outline of 339 points within 1.01,132.29 14.1,177.99
GND on IN4 (solid shape): outline of 1834 points within 0.51,0.51 236.99,218.99
GND on SGND2 (solid shape): outline of 3273 points within 0.51,0.51 236.99,218.99
V3A_BOOT on BOTTOM (solid shape): 177.96,134.31 177.96,133.73 177.6,133.37 177.07,133.37 176.48,132.79 176.48,131.95 176.3,131.77 175.97,131.77 175.97,133.35 177.09,134.46 177.8,134.46
V5P5A_BOOT on BOTTOM (solid shape): 55.9,179.84 55.71,179.65 54.94,179.65 54.84,179.75 54.84,180.59 55.35,181.1 55.35,181.73 55.6,181.99 55.9,181.99
VCC1_CORE on BOTTOM (solid shape): 152.66,162.1 152.66,161.34 153.32,160.68 153.37,160.68 153.37,160.4 152.45,160.4 152.25,160.6 151.01,160.6 150.92,160.69 150.92,160.99 151.01,161.08 151.62,161.08 151.97,161.44 151.97,162.15 152.61,162.15
VCC_GT on BOTTOM (solid shape): 156.37,164.54 156.57,164.33 156.57,163.9 156.52,163.85 156.01,163.85 155.96,163.9 155.96,164.39 155.45,164.89 155.45,165.2 156.37,165.2
VCC_SA on TOP (solid shape): 165.05,130.71 164.6,130.25 164.6,129.59 164.49,129.49 164.09,129.49 163.73,129.84 162.28,129.84 162.28,130.5 162.33,130.55 163.66,130.55 164.11,131.01 165.05,131.01
VCCAMPHYPLL_1P05 on TOP (solid shape): 125.81,131.86 125.81,131.46 126.09,131.18 126.09,130.62 126.06,130.58 125.65,130.58 125.07,131.16 123.87,131.16 123.7,131.32 123.7,131.68 123.92,131.9 125.77,131.9
VCCAPLL_1.05V on TOP (solid shape): outline of 593 points within 112.9,127.4 126.8,135.55
VCCDSW_GPIO on TOP (solid shape): 94,110.44 94.03,110.38 94.07,110.33 94.07,109.96 94.09,109.84 94.16,109.74 94.2,109.7 94.2,109.52 94.21,109.47 94.22,109.41 94.23,109.36 94.21,109.31 93.44,109.31 93.43,109.32 93.35,109.32 93.31,109.4 93.25,109.48 93.02,109.7 92.94,109.77 92.85,109.81 92.81,109.82 92.81,110.15 93.02,110.36 93.03,110.36 93.18,110.45 93.24,110.61 93.24,110.67 93.77,110.67
VCCDSW_GPIO on IN2 (solid shape): outline of 458 points within 101.37,130.46 108.4,132.98
VCCDUSB_1P05 on TOP (solid shape): 129.18,123.41 129.18,122.3 129.12,122.24 128.73,122.24 128.68,122.29 128.68,122.75 128.49,122.94 128.35,122.94 128.23,123.06 128.23,123.26 128.23,123.26 128.23,123.52 128.46,123.75 128.84,123.75
VCCDUSB_1P05 on IN2 (solid shape): outline of 680 points within 115.16,124.13 125.88,127.72
VCCHDA on TOP (solid shape): outline of 1055 points within 110.58,117.8 114.39,132.71
VCCK_V12 on TOP (solid shape): 34.32,152.84 34.8,152.84 35.04,152.6 35.04,152.03 34.83,151.82 33.79,151.82 33.22,152.38 31.99,152.38 31.95,152.42 31.95,152.53 31.99,152.57 33.29,152.57 33.75,153.03 34.13,153.03
VCCK_V12 on TOP (solid shape): 28.98,150.77 28.94,150.68 28.92,150.58 28.92,150.01 28.01,149.09 25.97,149.09 25.89,149.18 25.89,149.78 25.91,149.85 25.99,149.88 26.98,149.88 27.14,149.91 27.27,149.99 27.29,150.02 27.39,150.28 27.29,150.55 27.25,150.59 27.24,150.63 27.25,150.66 27.44,150.86 28.18,150.86 28.47,150.91 28.72,151.06 28.74,151.08 28.98,151.08
VCCMPHYGTAON_1P05 on TOP (solid shape): outline of 1285 points within 114.45,116.34 129.44,131.11
VCCMPHYGTAON_1P05 on BOTTOM (solid shape): 129.61,116.83 130.15,116.83 130.24,116.74 130.24,115.99 130.21,115.96 129.73,115.96 129.58,115.93 129.46,115.85 128.85,115.24 128.76,115.12 128.73,114.97 128.73,114.85 128.67,114.79 128.38,114.79 128.26,114.9 128.26,117.38 128.44,117.57 128.87,117.57
VCCMPHYGTAON_1P05 on BOTTOM (solid shape): 116.43,131.29 116.43,131.14 116.41,131.09 116.4,131.03 116.42,130.93 116.48,130.85 116.48,130.57 116.4,130.38 116.48,130.2 116.48,129.92 116.42,129.84 116.4,129.73 116.41,129.68 116.43,129.63 116.43,129.53 116.36,129.46 114.96,129.46 114.73,129.69 114.73,130.65 114.8,130.71 114.8,131.35 114.8,131.36 115.08,131.36 115.09,131.36 116.36,131.36
VCCPRIM_1P05 on BOTTOM (solid shape): 113.91,130.51 113.88,130.36 113.94,130.22 113.94,129.9 113.89,129.79 113.89,129.66 113.69,129.46 113.26,129.46 112.99,129.73 112.69,129.73 112.68,129.77 112.6,129.92 112.44,129.98 112.34,129.95 112.25,129.88 112.11,129.74 112.06,129.74 111.85,129.95 111.71,129.95 111.7,129.96 111.42,129.9 111.4,129.61 111.4,129.51 111.31,129.46 110.7,129.46 110.69,129.5 110.66,129.58 110.6,129.65 110.57,129.72 110.6,129.79 111.09,130.28 111.29,130.28 111.73,130.73 113.69,130.73
VCCPRIM_1P05 on BOTTOM (solid shape): 127.46,126.44 127.56,126.43 127.81,126.43 127.81,126.38 127.91,126.13 128.14,125.99 128.16,125.99 128.17,125.97 128.17,123.39 128.09,123.15 128.17,122.91 128.2,122.88 128.2,118.31 128.1,118.2 127.2,118.2 126.79,118.61 126.79,120.42 126.82,120.45 126.87,120.52 126.88,120.6 126.88,121.08 126.87,121.16 126.82,121.23 126.65,121.4 126.65,121.74 126.6,121.74 126.57,121.79 126.55,121.81 126.14,122.22 126.14,122.62 126.23,122.75 126.26,122.91 126.24,123.03 126.19,123.13 126.3,123.31 126.34,123.52 126.31,123.69 126.23,123.85 126.2,123.89 126.29,123.98 126.41,124.16 126.46,124.37 126.46,125.23 126.45,125.33 126.42,125.42 126.42,125.45 126.38,125.66 126.26,125.84 125.8,126.3 125.78,126.41 125.87,126.47 127.37,126.47
VCCPRIM_1P05 on IN2 (solid shape): outline of 2334 points within 109.35,124.25 127.41,134.67
VCCPRIM_1P8 on BOTTOM (solid shape): 122.45,119.1 122.45,118.12 122.45,118.08 122.45,117.78 122.45,117.71 122.23,117.49 122.23,116.56 122.24,116.56 122.24,116.19 122.15,115.95 122.24,115.7 122.24,115.64 122.23,115.64 122.23,114.88 122.07,114.72 121.45,114.72 121.06,115.1 121.06,119.06 121.24,119.24 121.32,119.23 121.36,119.22 121.46,119.24 121.54,119.28 121.62,119.25 121.69,119.24 121.81,119.26 121.91,119.32 122.22,119.32
VCCPRIM_1P8 on BOTTOM (solid shape): 114.18,127.96 114.23,127.89 114.29,127.84 114.29,126.75 114.12,126.58 112.51,126.58 112.4,126.63 112.27,126.63 112.26,126.63 111.62,126.63 111.33,126.92 111.33,127.2 111.42,127.32 111.45,127.46 111.42,127.59 111.34,127.7 111.33,127.71 111.33,127.79 111.5,127.96 111.77,127.96 111.79,127.96 111.82,127.94 111.93,127.83 112.08,127.79 112.23,127.83 112.35,127.93 112.36,127.94 112.4,127.96 112.63,127.96 112.69,127.9 112.76,127.85 113.1,127.51 113.46,127.51 113.77,127.82 113.79,127.82 113.9,127.86 113.99,127.93 114.01,127.97 114.06,127.99 114.17,127.99
VCCPRIM_1P8 on SVCC (solid shape): outline of 112 points within 104.96,118.64 122.99,131.85
VCCPRIM_3P3 on BOTTOM (solid shape): 112.86,119.32 112.89,119.29 112.93,119.27 112.93,117.31 112.93,117.08 112.93,116.97 112.72,116.77 112.72,116.76 112.54,116.58 112.54,114.85 112.46,114.77 112.15,114.77 111.88,115.04 110.34,115.04 110.21,115.17 110.21,116.29 110.53,116.61 110.6,116.7 110.63,116.81 110.63,116.83 111.11,117.32 111.11,119.08 111.16,119.17 111.18,119.27 111.18,119.31 111.17,119.35 111.21,119.4 111.28,119.43 111.34,119.47 111.67,119.81 112.37,119.81
VCCPRIM_3P3 on BOTTOM (solid shape): 109.66,133.8 109.66,132.01 109.62,131.97 109.62,130.12 109.66,130.08 109.66,130.01 109.68,129.99 109.68,129.82 109.67,129.78 109.67,129.74 109.67,129.7 109.68,129.65 109.68,129.16 109.67,129.12 109.67,129.08 109.71,128.95 109.81,128.86 110.08,128.59 110.08,128.21 110.07,128.2 110.08,128.05 110.16,127.91 110.16,127.07 109.98,126.89 109.09,126.89 108.94,127.04 108.94,128.51 109.02,128.61 109.06,128.73 109.06,128.75 109.14,128.84 109.15,128.84 109.29,128.93 109.34,129.08 109.28,129.24 109.14,129.33 109.13,129.34 109.08,129.39 109.21,129.51 109.21,129.51 109.3,129.61 109.34,129.73 109.3,129.87 109.2,129.96 109.17,129.98 109.17,130.09 108.97,130.3 108.97,130.41 109.02,130.48 109.05,130.55 109.06,130.57 109.33,130.83 109.33,130.95 109.34,131 109.34,131.03 109.34,131.07 109.33,131.12 109.33,131.6 109.34,131.65 109.34,131.68 109.34,131.72 109.33,131.77 109.33,132.25 109.34,132.3 109.34,132.33 109.34,132.37 109.33,132.42 109.33,132.9 109.34,132.95 109.34,132.98 109.28,133.14 109.14,133.23 109.12,133.24 109.06,133.3 109.06,133.32 109.02,133.46 108.94,133.57 108.94,133.83 109.01,133.9 109.56,133.9
VCCPRIM_3P3 on IN2 (solid shape): outline of 298 points within 108.43,118.58 113.72,128.23
VCCPRIM_3P33 on TOP (solid shape): 125.25,122.76 125.25,122.12 125.35,122.02 125.35,121.31 125.25,121.21 125.04,121.21 125.03,121.22 124.88,121.22 124.76,121.33 124.76,121.81 124.46,122.12 124.46,122.47 124.25,122.69 124.25,123.4 124.27,123.43 124.57,123.43
VCCPRIM_3P33 on IN2 (solid shape): outline of 936 points within 112.42,121.52 125.09,128.44
VCCSPI on TOP (solid shape): outline of 167 points within 108.48,126.48 110.44,130.98
VDDQ_PVIN on TOP (solid shape): 66.1,184.71 66.17,184.7 66.96,184.7 67.03,184.71 67.1,184.73 67.69,184.73 69.22,183.21 69.83,183.21 69.99,183.04 71.19,183.04 71.28,182.95 71.28,182.32 69.93,180.97 65.69,180.97 65.61,181.05 65.61,184.55 65.79,184.73 66.03,184.73
VDDQ_PVIN on BOTTOM (solid shape): 71.16,183.17 71.3,182.94 71.56,182.85 71.66,182.86 71.75,182.9 74.17,182.9 74.2,182.88 74.2,182.72 73.8,182.33 71.9,182.33 71.38,181.81 71.38,181.75 71.38,181.35 71.25,181.23 70.74,181.23 70.67,181.3 70.67,181.76 70.51,181.91 69.9,181.91 69.7,181.71 69.7,181.02 69.61,180.93 67.83,180.93 67.69,181.07 67.69,181.81 67.86,181.97 67.88,181.97 69.12,183.21 71.15,183.21
VDDQ_SW on BOTTOM (solid shape): 79,183.82 79,179.68 78.79,179.47 76.18,179.47 76,179.65 76,182.12 76.12,182.26 76.17,182.44 76.05,182.73 75.76,182.85 75.7,182.85 75.67,182.88 74.48,182.88 74.27,183.08 73.26,183.08 73.1,183.23 73.1,183.31 73.16,183.36 75.75,183.36 75.97,183.59 75.97,183.61 76.58,184.22 78.59,184.22
VDDQ_SW_VPP on BOTTOM (solid shape): 76.91,187.52 76.91,185.87 76.64,185.6 75.84,185.6 75.42,185.18 75.42,185.16 75.39,185.14 75.39,184.39 75.35,184.35 74.81,184.35 74.81,186.74 75.87,187.8 76.64,187.8
VDDQ_VCC on BOTTOM (solid shape): 74.29,188.12 75,188.12 75.11,188.01 75.11,187.6 74.55,187.04 74.55,184.96 74.54,184.96 74.54,184.35 74.29,184.35 74.29,184.96 74.04,184.96 74.04,184.35 73.79,184.35 73.79,185.22 73.81,185.3 73.82,185.37 73.81,185.45 73.79,185.53 73.79,185.77 73.71,185.85 73.71,188.03 73.82,188.13 74.27,188.13
VDDQ_VLDOIN on BOTTOM (solid shape): 75.62,181.89 75.62,181.05 75.42,180.84 75.11,180.84 74.78,181.17 74.78,181.56 74.79,181.56 74.79,182.17 75.34,182.17
VDDQ_VTT on BOTTOM (solid shape): 74.6,180.54 74.6,179.02 74.55,178.97 73.94,178.97 73.56,178.58 72.85,178.58 72.85,179.4 73.23,179.78 73.23,180.31 73.26,180.34 73.74,180.34 74.04,180.64 74.5,180.64
VDDQ_VTT_CNTL on BOTTOM (solid shape): 71.38,186.18 72.37,185.18 72.38,185.18 72.44,185.09 72.52,185.02 72.52,184.35 72.01,184.35 71.96,184.4 71.96,185.19 71.48,185.67 70.87,185.67 70.81,185.73 70.81,186.06 71.17,186.43 71.17,186.94 71.38,186.94
VDDQ_VTTREF on BOTTOM (solid shape): 72.52,181.58 72.09,181.58 72.01,181.51 72.01,180.36 71.86,180.21 70.62,180.21 70.55,180.27 70.55,180.53 70.56,180.66 70.62,180.72 71.1,180.72 71.53,181.15 71.53,181.68 72.01,182.17 72.52,182.17
5213LX_1.8V on TOP (solid shape): 36.15,140.03 36.15,139.14 36.15,139.14 36.15,138.79 36.31,138.63 36.46,138.63 36.55,138.57 36.66,138.55 37.6,138.55 37.68,138.51 37.7,138.44 37.7,138.4 37.73,138.25 37.81,138.12 37.96,137.97 38.36,137.97 38.48,137.84 38.48,137.33 38.21,137.06 34.05,137.06 33.58,137.53 33.58,138.56 33.69,138.67 35.47,138.67 35.84,139.04 35.84,139.14 35.85,139.14 35.85,140.01 35.88,140.04 36.14,140.04
8813BOOT1 on TOP (solid shape): 101.58,200.2 101.58,199.45 101.37,199.25 101.37,198.8 101.31,198.74 101.31,198.03 101.22,197.94 101.1,197.94 100.61,198.42 100.61,198.52 100.84,198.75 100.87,198.75 100.97,198.85 100.97,199.09 100.97,199.31 100.65,199.63 100.65,200.29 100.75,200.39 101.39,200.39
8813BOOT2 on TOP (solid shape): 105.87,195.3 105.25,195.3 104.21,195.3 104.19,195.3 103.98,195.08 103.43,195.63 103.43,195.7 103.72,196 105.87,196
8813PHASE1 on TOP (solid shape): 102.75,200.38 102.75,199.56 102.19,199.01 102.19,198.65 102.38,198.46 101.86,197.94 101.76,197.94 101.65,198.04 101.65,198.75 101.53,198.88 101.53,199.18 101.93,199.59 101.93,200.33 102.01,200.4 102.72,200.4
8813PHASE1 on BOTTOM (solid shape): 107.06,206.27 107.06,205.84 105.34,204.11 105.34,203.04 103.94,201.65 102.67,201.65 102.52,201.8 102.52,204.95 101.91,205.56 101.91,206.38 103.9,208.38 103.9,208.39 104.04,208.53 104.8,208.53
8813PHASE2 on TOP (solid shape): 105.87,196.29 105.74,196.16 103.53,196.16 103.43,196.26 103.43,196.36 103.98,196.91 104.1,196.78 104.17,196.72 104.24,196.64 104.44,196.64 104.7,196.64 104.91,196.85 104.91,197.15 105.08,197.33 105.87,197.33
8813PHASE2 on BOTTOM (solid shape): 112.98,198.85 112.98,197.15 112.86,197.02 111.46,197.02 111.15,196.72 111.15,195.81 111.01,195.67 107.99,195.67 107.09,196.57 106.83,196.57 106.78,196.57 106.73,196.58 105.9,196.58 105.85,196.57 105.8,196.57 105.06,196.57 104.98,196.64 104.98,197.2 104.99,197.21 104.99,198.05 105.21,198.27 108.36,198.27 109.6,199.51 112.32,199.51
8813UGATE2 on TOP (solid shape): 103.89,194.87 103.95,194.87 103.97,194.87 103.99,194.87 104.27,195.14 105.18,195.14 105.31,195.02 105.31,194.61 105.18,194.48 105.14,194.48 103.86,194.48 103.03,195.32 103.23,195.53
24780_BST on BOTTOM (solid shape): 155.12,119.71 155.38,119.45 155.89,119.45 155.89,119.45 156.65,119.45 156.7,119.4 156.7,119.33 156.62,119.25 155.89,119.25 155.4,119.25 155.29,119.14 155.24,119.1 154.66,119.1 154.61,119.15 154.61,119.58 154.74,119.71
24780_DH on BOTTOM (solid shape): 155.29,120.32 155.29,120.18 155.62,119.85 156.63,119.85 156.7,119.78 156.7,119.71 156.65,119.66 155.4,119.66 155.2,119.86 154.96,119.86 154.87,119.86 154.62,120.11 154.62,120.36 154.79,120.53 155.07,120.53
24780_DL on BOTTOM (solid shape): 155.89,118.65 156.67,118.65 156.67,118.46 155.81,118.46 155.73,118.39 155.73,118.06 155.55,117.88 155.26,117.88 155.1,118.04 155.1,118.31 155.3,118.51 155.33,118.54 155.46,118.67 155.89,118.67
24780_LX on BOTTOM (solid shape): 155.73,121 155.73,120.29 155.78,120.24 156.65,120.24 156.67,120.21 156.67,120.09 156.65,120.06 155.63,120.06 155.45,120.24 155.45,120.37 155.12,120.7 155.12,121.05 155.22,121.15 155.58,121.15
24780_LX on BOTTOM (solid shape): 151.16,118.87 151.16,118.02 150.71,117.57 150.71,114.75 150.4,114.44 149.91,114.44 149.11,113.65 149.11,113.19 148.87,112.95 148.2,112.95 148.11,112.98 148.03,112.99 147.95,112.98 147.86,112.95 147.81,112.95 147.55,112.7 144.9,112.7 144.77,112.83 144.77,117.48 145.17,117.88 147.63,117.88 147.78,118.03 149.03,118.03 149.3,118.31 149.3,118.89 149.41,119 151.03,119
24780_VCC on BOTTOM (solid shape): 156.7,124.43 156.7,122.74 156.66,122.73 156.42,122.36 156.66,121.98 156.7,121.97 156.7,120.55 156.65,120.49 156.65,120.45 155.88,120.45 155.88,120.83 155.88,120.87 155.88,121.08 155.64,121.32 155.06,121.32 154.99,121.38 154.99,122.27 155.03,122.3 155.05,122.31 155.32,122.43 155.43,122.71 155.4,122.86 155.32,122.99 155.32,124.36 155.5,124.53 156.59,124.53
+1.03_GFX on BOTTOM (solid shape): 141.66,211.84 141.66,211.57 142.04,211.18 142.76,211.18 143.07,210.88 143.07,209.41 142.92,209.26 142.45,209.26 142.41,209.29 141.22,209.29 141.09,209.42 141.09,211.87 141.18,211.95 141.55,211.95
+1.03_GFX on BOTTOM (solid shape): outline of 133 points within 92.92,195.24 96.88,199.4
+1.03_GFX on IN2 (solid shape): outline of 697 points within 134.73,197.99 144.3,211.02
+1.03_GFX on IN3 (solid shape): outline of 2335 points within 93.25,195.37 143.06,216.91
+601_VCC on TOP (solid shape): 234.06,117.96 235.23,117.96 235.41,117.78 235.41,114.02 235.36,113.97 234.96,113.97 234.96,114.4 234.91,114.46 234.9,114.5 234.9,114.86 234.91,114.9 234.96,114.96 234.96,115.33 234.9,115.39 234.9,116.13 234.91,116.17 234.96,116.23 234.96,116.6 234.44,117.13 233.31,117.13 232.82,116.64 232.82,116.58 230.97,116.58 230.89,116.66 230.89,117.22 231.7,118.03 233.99,118.03
+601_VCC on TOP (solid shape): 224.57,118.03 224.61,118 224.6,117.94 224.58,117.92 224.58,117.55 224.64,117.49 224.64,117.47 224.65,117.41 224.69,117.37 224.69,117.04 224.58,116.93 224.58,116.56 224.64,116.5 224.64,116.48 224.65,116.42 224.69,116.38 224.69,116.1 224.58,115.99 224.58,115.62 224.64,115.56 224.64,115.54 224.65,115.48 224.69,115.44 224.69,115.16 224.58,115.05 224.58,114.68 224.64,114.62 224.64,114.6 224.65,114.54 224.69,114.5 224.69,114.42 224.78,114.33 226.27,114.33 226.29,114.35 226.65,114.35 227.03,114.73 227.03,114.8 227.1,114.8 227.16,114.86 227.84,114.86 227.97,114.73 227.97,114.37 227.79,114.2 227.79,113.81 226.83,112.85 225.61,112.85 225.56,112.8 224.44,112.8 224.18,113.05 224.18,114.91 224.23,115.02 224.25,115.13 224.23,115.25 224.18,115.36 224.18,117.93 224.29,118.03
+601_VCC on IN2 (solid shape): outline of 218 points within 225.2,112.24 235.26,117.75
+AZA_VDD on BOTTOM (solid shape): 26.3,40.51 26.3,38.57 26.47,38.4 26.47,36.98 26.03,36.54 26.03,35.89 25.85,35.71 25.85,34.94 25.7,34.79 25.12,34.79 25.06,34.78 24.88,34.78 24.74,34.76 24.63,34.68 24.51,34.56 22.71,34.56 22.61,34.55 22.52,34.51 22.29,34.51 22.21,34.59 22.21,35.04 22.4,35.24 23.84,35.24 24.21,35.6 24.25,35.63 24.29,35.66 24.94,36.32 24.97,36.35 25,36.39 25.14,36.54 25.14,37.92 25.15,37.97 25.15,40.23 25.58,40.66 26.14,40.66
+CRT_VDDA33 on TOP (solid shape): 33.03,151.26 33.04,151.26 33.99,150.32 34.07,150.25 34.17,150.21 34.17,149.98 34.52,149.63 35.91,149.63 36.29,149.25 36.85,149.25 37.15,148.95 37.15,147.84 37.1,147.79 36.28,147.79 36.14,147.93 36.14,148.27 35.9,148.5 35.73,148.5 35.67,148.51 35.37,148.51 35.31,148.5 34.72,148.5 34.65,148.51 34.49,148.51 34.23,148.77 34.21,148.8 34.18,148.83 33.06,149.96 33.03,149.98 32.93,150.04 32.03,150.93 32.02,150.96 32.02,151.11 31.92,151.2 31.92,151.31 31.96,151.35 32.93,151.35
+FB_PLLAVDD on TOP (solid shape): 115.19,194.8 115.19,194.41 115.02,194.24 114.75,194.24 114.68,194.17 114.67,194.16 114.61,194.12 114.56,194.05 114.55,194.04 114.49,193.97 114.49,193.45 114.01,192.98 114.01,192.2 113.71,191.91 113.26,191.91 113.24,191.88 113.17,191.88 113,192.08 112.75,192.15 112.43,192.02 112.3,191.69 112.33,191.52 112.43,191.37 112.46,191.34 112.4,191.27 112.4,190.66 112.43,190.63 112.33,190.53 111.76,190.53 111.68,190.61 111.68,192.48 112.34,193.13 112.72,193.13 112.82,193.09 112.94,193.08 113.26,193.21 113.39,193.53 113.4,193.58 113.4,194.58 113.79,194.98 115.02,194.98
+FB_PLLAVDD on IN2 (solid shape): outline of 99 points within 132,186.81 137.88,188.38
+SMDDR_VREF_DIMM on TOP (solid shape): 46.24,129.34 46.24,129.19 45.87,128.83 45.87,128.37 45.84,128.35 45.74,128.35 45.54,128.15 45.54,127.98 45.53,127.96 45.08,127.96 45.05,127.99 45.05,128.82 45.7,129.47 46.1,129.47
+SMDDR_VREF_DQ1_M1 on TOP (solid shape): 55.2,128.87 56.39,128.87 56.44,128.83 56.44,127.58 56.38,127.52 55.85,127.52 54.68,128.68 54.68,128.9 54.82,129.03 55.05,129.03
+TS_PWR on TOP (solid shape): 71.3,192.2 71.3,191.67 71.17,191.54 71.1,191.54 71.06,191.5 71.05,191.5 70.99,191.46 70.95,191.4 70.95,191.39 70.89,191.33 70.89,190.98 70.46,190.55 69.66,190.55 69.66,191.2 69.94,191.48 70.02,191.6 70.04,191.74 70.04,192.53 70.97,192.53
+TS_PWR on BOTTOM (solid shape): 70.8,192.51 71,192.51 71,193.42 71.22,193.42 71.3,193.34 71.3,192.51 71.34,192.51 71.38,192.41 71.38,191.26 70.97,190.85 69.62,190.85 69.52,190.95 69.52,191.37 69.8,191.64 69.84,191.71 69.86,191.79 69.86,191.85 70.39,192.38 70.46,192.45 70.46,192.51 70.5,192.51 70.5,192.82 70.51,192.88 70.51,192.93 70.51,193.32 70.51,193.42 70.8,193.42
+USBPWR0 on BOTTOM (solid shape): outline of 103 points within 14.46,89.05 19.76,94.03
+USBPWR1 on TOP (solid shape): 17.96,111.3 17.96,109.77 17.84,109.64 15.36,109.64 14.47,110.53 14.47,111.23 14.75,111.52 17.75,111.52
+USBPWR1 on TOP (solid shape): 22.84,95.58 22.84,93.77 22.63,93.56 20.9,93.56 20.24,94.22 20.24,94.49 20.13,94.6 20,94.74 19.82,94.79 19.76,94.79 19.7,94.77 19.67,94.76 19.56,94.87 19.56,95.73 19.71,95.88 20.98,95.88 21.01,95.91 21.31,95.91 21.58,96.18 22.23,96.18
+USBPWR1 on BOTTOM (solid shape): outline of 425 points within 15.83,95.41 22.48,111.69
