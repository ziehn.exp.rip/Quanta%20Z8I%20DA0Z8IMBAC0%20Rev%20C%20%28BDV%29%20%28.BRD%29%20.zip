# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBON#: length 311.4
  TOP w0.114: v1(207.3,107.13) 207.3,107.14 v1(207.88,107.72) 208.85,108.69 208.85,112.17 211.49,114.81 211.49,120.54 213.05,122.09 215.19,122.09 215.5,122.39 215.5,122.45 v1(215.8,122.75) ; U37.99 164.56,112.03 164.63,112.1 164.83,112.1 165.32,112.58 166.74,112.58 168,113.85 169.55,113.85 169.74,113.66 169.74,113.18 170.27,112.65 174.38,112.65 174.76,113.03 175.22,113.03 176.77,114.58 176.77,115.27 178.05,116.55 178.05,117.95 177.17,118.84 177.17,122.01 v1(177.61,122.45)
  IN2 w0.102: v1(24.25,103.59) 24.68,103.59 25.85,102.42 27.48,102.42 28.7,101.21 28.7,100.98 28.93,100.75 29.43,100.75 29.66,100.97 34.21,100.97 34.49,100.69 35.44,100.69 35.91,100.23 36.47,100.23 39.3,97.39 45.06,97.39 45.75,96.71 57.02,96.71 58.88,98.57 66.39,98.57 67.57,99.75 68.04,99.75 68.4,99.39 69.4,99.39 70.09,100.08 71.18,100.08 73.43,102.33 77.49,102.33 77.7,102.55 80.49,102.55 80.72,102.78 84.26,102.78 85.18,101.86 85.48,101.86 86.72,103.1 87.56,103.1 87.93,103.47 92.6,103.47 92.88,103.76 95.53,103.76 96.1,103.18 96.69,103.18 97.21,103.7 99.82,103.7 102.09,105.97 104.8,105.97 106.17,107.34 111.83,107.34 112.39,106.78 117.92,106.78 118.09,106.96 120.6,106.96 121.12,106.44 127.74,106.44 129.91,104.28 133.45,104.28 134.32,103.41 143.71,103.41 144.98,102.15 146.23,102.15 146.8,102.71 152.92,102.71 153.23,103.02 159.21,103.02 159.76,103.57 159.76,104.1 161.3,105.64 166.23,105.64 167.43,106.84 169.63,106.84 170.81,108.02 171.91,108.02 175.15,111.26 183.59,111.26 187.2,107.65 193.51,107.65 194.22,106.94 197.22,106.94 197.43,106.73 202.77,106.73 203.47,107.42 207.01,107.42 v1(207.3,107.13)
  IN3 w0.102: v1(177.61,122.45) 178.28,121.77 180.75,121.77 181.21,121.31 188.11,121.31 188.38,121.05 190.32,121.05 190.58,121.31 197.09,121.31 201.73,125.95 206.35,125.95 207.16,125.14 210.84,125.14 211.75,126.05 212.87,126.05 v1(215.8,122.75)
  BOTTOM w0.114: U15.4 21.76,94.62 22.38,95.25 22.38,96.14 23.24,96.99 23.24,98.33 22.36,99.2 22.36,101.57 23.05,102.25 24.4,102.25 24.68,102.53 24.68,103.16 v1(24.25,103.59) ; U18.4 216.4,108.71 arc(216.4,108.7) 216.39,108.69 214.82,107.12 arc(214.81,107.11) 214.8,107.11 207.34,107.11 arc(207.33,107.11) 207.32,107.12 v1(207.3,107.13)
USBP1+: length 141.8
  TOP w0.102: v1(21.5,87.44) 21.17,87.77 21,87.77 20.75,88.02 20.62,88.02 20.38,87.79 R25518.2
  IN3 w0.102: v1(21.5,87.44) 21.5,87.45 21.82,87.77 22.12,87.77 22.33,87.98 22.33,89.48 21.89,89.92 21.89,92.67 22.33,93.12 22.33,94.56 23.08,95.31 23.08,96.08 24.57,97.56 24.57,100.35 25.92,101.7 29.55,101.7 29.93,101.32 31.92,101.32 32.16,101.08 34.2,101.08 35.2,100.09 36.83,100.09 37.1,100.36 49.4,100.36 50.98,98.77 53.88,98.77 54.12,99.02 57.37,99.02 57.71,98.68 65.25,98.68 66.38,99.81 67.89,99.81 68.44,99.26 69.13,99.26 69.55,99.67 69.55,99.93 72.9,103.27 77.27,103.27 77.94,102.61 80.45,102.61 80.75,102.92 84.35,102.92 84.6,103.17 88.26,103.17 88.57,103.48 94.79,103.48 95.79,102.47 97.4,102.47 97.51,102.58 99.8,102.58 103.29,106.07 104.43,106.07 104.77,106.41 104.77,106.88 105.86,107.97 107.34,107.97 108.22,108.86 108.22,109.85 108.57,110.2 108.57,111.21 109.1,111.73 109.1,112 109.85,112.75 109.85,113.84 111.36,115.35 111.79,115.35 111.98,115.16 115.85,115.16 116.63,115.94 118.29,115.94 118.68,116.34 118.68,116.65 118.91,116.87 118.91,117.37 119.93,118.39 119.93,119.78 119.42,120.29 119.42,120.69 119.76,121.03 120.03,121.03 121.11,122.1 121.11,123.55 120.99,123.66 120.99,124.36 121.38,124.76 121.38,125.41 122.72,126.75 123.49,126.75 123.59,126.65 123.59,126.51 v2(123.37,126.29)
  BOTTOM w0.079: v2(123.37,126.29) 123.58,126.49 123.58,126.65 123.53,126.69 123.22,126.69 123.08,126.55 122.82,126.55 122.71,126.58 122.7,126.58 122.55,126.64 122.37,126.58 122.19,126.55 122.15,126.56 122.04,126.59 121.88,126.66 121.88,126.66 121.46,126.7 U1.CE4
USBP1+_R: length 6.1
  TOP w0.102: R25518.1 19.6,87.8 19.33,88.07 18.89,88.07 18.65,88.31 18.39,88.31 18.38,88.3 18.38,88.3 18.3,88.22 D13099.2 17.82,87.95 16.48,87.95 16.15,88.28 16.15,88.64 16,88.79 15.26,88.79 15.1,88.63 CN2.3
USBP1-: length 141.8
  TOP w0.102: R25517.2 20.38,88.47 20.63,88.22 20.84,88.22 21.09,87.98 21.33,87.98 21.5,88.14 v1(21.5,88.21)
  IN3 w0.102: v1(21.5,88.21) 21.74,87.96 22.04,87.96 22.14,88.06 22.14,89.4 21.69,89.84 21.69,92.75 22.14,93.2 22.14,94.64 22.89,95.39 22.89,96.16 24.37,97.64 24.37,100.43 25.84,101.89 29.63,101.89 30.01,101.51 32,101.51 32.24,101.27 34.28,101.27 35.27,100.28 36.75,100.28 37.02,100.55 49.48,100.55 51.06,98.97 53.8,98.97 54.04,99.21 57.45,99.21 57.79,98.87 65.17,98.87 66.3,100 67.96,100 68.52,99.45 69.05,99.45 69.36,99.75 69.36,100.01 72.82,103.46 77.35,103.46 78.02,102.8 80.37,102.8 80.68,103.11 84.27,103.11 84.53,103.36 88.18,103.36 88.49,103.67 94.87,103.67 95.87,102.66 97.33,102.66 97.43,102.77 99.72,102.77 103.21,106.26 104.35,106.26 104.58,106.49 104.58,106.95 105.78,108.16 107.26,108.16 108.03,108.93 108.03,109.93 108.38,110.28 108.38,111.29 108.91,111.81 108.91,112.08 109.66,112.83 109.66,113.92 111.28,115.54 111.87,115.54 112.06,115.35 115.77,115.35 116.55,116.14 118.21,116.14 118.49,116.42 118.49,116.72 118.72,116.95 118.72,117.45 119.74,118.47 119.74,119.7 119.23,120.21 119.23,120.77 119.68,121.22 119.95,121.22 120.92,122.18 120.92,123.47 120.8,123.59 120.8,124.44 121.19,124.84 121.19,125.49 122.64,126.94 123.57,126.94 123.78,126.73 123.78,126.49 v2(123.98,126.29)
  BOTTOM w0.079: U1.CE3 121.59,126.98 121.95,126.81 122.1,126.74 122.19,126.72 122.2,126.72 122.32,126.74 122.55,126.82 122.6,126.79 122.75,126.73 122.75,126.73 122.84,126.71 123.01,126.71 123.15,126.85 123.6,126.85 123.73,126.71 123.73,126.42 123.86,126.29 v2(123.98,126.29)
USBP1-_R: length 6.2
  TOP w0.102: R25517.1 19.6,88.49 19.38,88.27 18.97,88.27 18.73,88.51 18.48,88.51 18.31,88.67 D13099.1 17.77,88.99 16.98,88.99 16.9,88.92 16.24,88.92 16.17,88.99 15.26,88.99 15.1,89.15 CN2.2
USBP2+: length 136.9
  TOP w0.102: U14.3 18.7,99.87 19.4,100.56 19.84,100.56 20.79,101.52 24.61,101.52 24.81,101.32 26.95,101.32 26.95,101.32 27.22,101.32 27.47,101.07 27.47,100.89 27.47,100.89 27.47,100.84 v1(27.67,100.63)
  IN3 w0.102: v2(124.83,125.37) 124.66,125.19 124.5,125.19 124.29,125.41 124.29,125.53 123.99,125.83 122.44,125.83 121.85,125.24 121.85,121.86 120.48,120.49 120.48,117.72 119.09,116.33 119.09,116.03 118.48,115.42 116.96,115.42 116.25,114.7 111.98,114.7 111.52,114.24 111.04,114.24 110.26,113.46 110.26,111.8 109.92,111.46 109.4,111.46 108.98,111.05 108.98,110.03 108.66,109.71 108.66,108.71 107.49,107.54 106.01,107.54 105.26,106.8 105.26,106.17 104.17,105.07 104.17,103.84 103.42,103.09 101.26,103.09 100.34,102.17 97.97,102.17 97.15,101.35 91.35,101.35 90.18,102.51 86.15,102.51 85.63,101.99 85.22,101.99 84.7,102.51 81.05,102.51 80.74,102.2 77.64,102.2 77.19,102.64 73.75,102.64 68.74,97.64 59.13,97.64 58.56,98.21 55.95,98.21 55.54,98.61 54.31,98.61 54.05,98.36 50.75,98.36 49.16,99.95 37.36,99.95 37.09,99.68 34.95,99.68 34.48,100.15 32.37,100.15 31.64,100.88 29.66,100.88 28.91,100.13 27.6,100.13 27.47,100.26 27.47,100.44 v1(27.67,100.63)
  BOTTOM w0.079: v2(124.83,125.37) 124.64,125.17 124.55,125.17 124.31,125.42 124.31,125.71 124.52,125.91 124.52,126.53 123.87,127.17 123.11,127.17 123.04,127.25 122.72,127.25 122.47,126.99 U1.CE2
USBP2+_C: length 26.5
  TOP w0.102: v1(19.82,93.77) 19.59,94 19.36,94 19.23,94.13 19.07,94.13 18.85,94.35 18.85,94.58 18.7,94.73 U14.10 ; v1(22.88,104.36) 22.64,104.12 22.64,103.89 22.34,103.59 21.02,103.59 20.91,103.48 D13100.2 20.47,103.22 19.25,103.22 18.8,103.68 18.79,103.67 18.44,103.67 18.29,103.82 18.06,103.82 R425.2
  IN4 w0.102: v1(19.82,93.77) 19.59,94 19.41,94 19.07,94.34 19.07,95.33 22.37,98.62 23.73,98.62 25.56,100.45 25.56,103.91 24.58,104.88 22.71,104.88 22.6,104.78 22.6,104.64 v1(22.88,104.36)
USBP2+_C_R: length 5.7
  TOP w0.102: R425.1 16.91,103.62 16.61,103.92 16.33,103.92 16.08,104.17 16.08,106.81 15.83,107.06 15.23,107.06 15.1,106.93 CN3.3
USBP2-: length 136.8
  TOP w0.102: v1(26.91,100.63) 27.05,100.63 27.26,100.84 27.26,100.99 27.14,101.11 24.72,101.11 24.52,101.31 20.88,101.31 19.92,100.36 19.48,100.36 18.9,99.78 18.9,99.38 18.95,99.34 19.14,99.34 19.2,99.27 U14.2
  IN3 w0.102: v1(26.91,100.63) 26.94,100.67 27.12,100.67 27.24,100.55 27.24,100.45 27.28,100.41 27.28,100.19 27.53,99.94 28.99,99.94 29.74,100.69 31.56,100.69 32.29,99.96 34.41,99.96 34.87,99.49 37.17,99.49 37.44,99.76 49.08,99.76 50.67,98.17 54.13,98.17 54.39,98.42 55.46,98.42 55.87,98.02 58.48,98.02 59.05,97.45 68.82,97.45 73.83,102.45 77.12,102.45 77.56,102.01 80.81,102.01 81.13,102.32 84.62,102.32 85.14,101.8 85.71,101.8 86.23,102.32 90.1,102.32 91.27,101.16 97.23,101.16 98.05,101.98 100.42,101.98 101.34,102.9 103.5,102.9 104.36,103.76 104.36,104.99 105.46,106.09 105.46,106.72 106.09,107.35 107.56,107.35 108.85,108.64 108.85,109.63 109.17,109.96 109.17,110.97 109.48,111.27 110,111.27 110.45,111.72 110.45,113.38 111.12,114.05 111.6,114.05 112.06,114.51 116.33,114.51 117.04,115.23 118.56,115.23 119.28,115.95 119.28,116.25 120.67,117.64 120.67,120.41 122.04,121.78 122.04,125.16 122.52,125.64 123.91,125.64 124.1,125.45 124.1,125.33 124.42,125 124.62,125 124.67,124.96 124.74,124.96 124.83,124.87 v2(124.83,124.68)
  BOTTOM w0.079: v2(124.83,124.68) 124.88,124.72 124.88,124.9 124.76,125.02 124.49,125.02 124.15,125.35 124.15,125.77 124.36,125.98 124.36,126.46 123.8,127.02 122.89,127.02 U1.CE1
USBP2-_C: length 26.4
  TOP w0.102: U14.11 19.2,94.73 19.05,94.58 19.05,94.43 19.15,94.33 19.32,94.33 19.44,94.21 19.59,94.21 v1(19.82,94.43) ; R426.2 17.69,104.24 17.91,104.03 18.38,104.03 18.53,103.87 18.71,103.87 19.03,104.19 20.46,104.19 D13100.1 20.89,103.93 21.03,103.79 22.26,103.79 22.44,103.97 22.44,104.22 22.3,104.36 v1(22.12,104.36)
  IN4 w0.102: v1(22.12,104.36) 22.4,104.64 22.4,104.87 22.62,105.09 24.66,105.09 25.76,103.99 25.76,100.37 23.81,98.42 22.46,98.42 19.28,95.24 19.28,94.42 19.49,94.21 19.59,94.21 v1(19.82,94.43)
USBP2-_C_R: length 5.7
  TOP w0.102: R426.1 16.52,104.12 16.41,104.12 16.28,104.25 16.28,106.89 15.91,107.26 15.26,107.26 15.1,107.42 CN3.2
USBP3+_TPC: length 177.4
  IN3 w0.102: v1(15.61,59.71) 15.88,59.98 19.68,59.98 24.29,64.59 24.29,66.52 23.77,67.04 23.77,70.93 22.02,72.67 19.87,72.67 18.48,74.06 17.77,74.06 17.35,74.48 17.35,76.71 18.11,77.47 19.5,77.47 21.53,79.5 21.53,82.72 22,83.19 22,86.69 22.93,87.61 22.93,90.03 22.48,90.47 22.48,92.43 22.93,92.87 22.93,94.32 23.68,95.07 23.68,95.83 26.47,98.63 31.72,98.63 32.32,99.22 34.09,99.22 34.42,98.89 37.45,98.89 38.57,97.78 50.19,97.78 50.76,97.21 58.29,97.21 58.66,96.85 69.17,96.85 69.65,97.32 71,97.32 73.51,99.83 80.47,99.83 80.58,99.94 84.75,99.94 85.42,100.61 88.99,100.61 89.6,100 97.78,100 98.02,100.24 103.66,100.24 104.75,101.32 104.75,102.25 106.39,103.89 106.79,103.89 107.22,104.32 107.22,105.26 114.45,112.49 115.55,112.49 117.28,114.23 118.95,114.23 119.85,115.13 120.35,115.13 120.84,115.63 120.84,116.77 122.75,118.68 122.75,119 122.85,119.11 122.85,124.29 123.35,124.78 123.35,124.95 v2(123.62,125.22)
  BOTTOM w0.079: U1.CG4 121.11,125.8 121.31,125.93 121.61,125.95 121.76,125.95 122.03,126.09 122.14,126.12 122.33,126.12 122.46,126.05 122.51,126.05 122.75,126.1 122.75,126.1 123.07,126.1 123.43,125.74 123.43,125.41 v2(123.62,125.22)
  BOTTOM w0.102: v1(15.61,59.71) 15.34,59.98 14.51,59.98 13.07,61.42 12.8,61.42 12.64,61.26 R25292.1
USBP3-_TPC: length 177.4
  IN3 w0.102: v2(123.04,125.22) 123.16,125.09 123.16,124.86 122.66,124.37 122.66,119.19 122.56,119.08 122.56,118.76 120.65,116.85 120.65,115.71 120.27,115.32 119.77,115.32 118.87,114.42 117.2,114.42 115.47,112.68 114.37,112.68 107.03,105.34 107.03,104.4 106.71,104.08 106.31,104.08 104.55,102.33 104.55,101.4 103.58,100.43 97.94,100.43 97.7,100.19 89.68,100.19 89.07,100.8 85.34,100.8 84.67,100.13 80.5,100.13 80.39,100.02 73.43,100.02 70.92,97.51 69.57,97.51 69.1,97.04 58.73,97.04 58.37,97.4 50.83,97.4 50.27,97.97 38.65,97.97 37.53,99.08 34.5,99.08 34.17,99.41 32.24,99.41 31.64,98.82 26.39,98.82 23.49,95.91 23.49,95.15 22.74,94.4 22.74,92.95 22.29,92.51 22.29,90.39 22.74,89.95 22.74,87.69 21.81,86.77 21.81,83.27 21.34,82.8 21.34,79.58 19.42,77.66 18.03,77.66 17.16,76.79 17.16,74.4 17.69,73.87 18.4,73.87 19.79,72.48 21.94,72.48 23.58,70.85 23.58,66.96 24.1,66.44 24.1,64.67 19.6,60.17 15.92,60.17 v1(15.61,60.47)
  BOTTOM w0.079: v2(123.04,125.22) 123.15,125.22 123.27,125.34 123.27,125.67 123.01,125.94 122.83,125.94 122.78,125.93 122.53,125.88 122.41,125.88 122.28,125.96 122.17,125.96 122.1,125.93 121.93,125.85 121.89,125.81 121.89,125.5 121.79,125.4 121.31,125.4 121.22,125.48 121.22,125.61 121.29,125.68 U1.CG3
  BOTTOM w0.102: v1(15.61,60.47) 15.33,60.19 14.6,60.19 13.16,61.63 12.75,61.63 12.64,61.74 R67470.1
USBP4+_DB: length 142.8
  TOP w0.102: R67499.2 223.81,122.05 223.6,122.05 223.49,121.95 223.49,120.2 v1(223.75,119.94)
  IN1 w0.102: v1(223.75,119.94) 223.53,120.16 223.53,120.5 223.26,120.77 222.58,120.77 220.82,119.01 217.24,119.01 215.39,117.17 215.29,117.07 213.11,117.07 211.69,118.49 208.18,118.49 207.67,117.98 207.67,117.69 v1(207.38,117.4) 207.62,117.16 207.62,110.39 206.98,109.75 204.92,109.75 204.28,109.11 202.91,109.11 202.18,108.38 197.2,108.38 196.45,109.13 194.35,109.13 193.5,109.97 186.74,109.97 185.97,110.74 185.03,110.74 184.66,111.11 174.9,111.11 172.34,108.56 167.41,108.56 166.68,107.82 164.69,107.82 164.18,107.31 155.81,107.31 154.75,106.25 151.31,106.25 150.72,105.66 148.78,105.66 148.58,105.86 145.94,105.86 145.87,105.79 141.79,105.79 140.74,106.83 138.66,106.83 138.29,107.21 133.54,107.21 132.76,107.98 130.55,107.98 128.19,110.35 125.83,110.35 124.4,111.77 124.4,115.36 125.95,116.92 125.95,118.58 127.1,119.73 127.1,121.39 126.53,121.96 126.53,123.63 125.43,124.73 125.43,125.66 124.66,126.43 124.66,126.66 124.24,127.09 123.16,127.09 123.06,127.19 123.06,127.36 v2(123.26,127.56)
  BOTTOM w0.079: v2(123.26,127.56) 123.12,127.42 122.65,127.42 122.48,127.25 121.7,127.25 U1.CD4
  BOTTOM w0.102: v1(207.38,117.4) 207.67,117.12 207.67,116.67 R67462.2
USBP4+_DB_RS232: length 4.3
  TOP w0.114: R67499.1 225.43,122.1 225.6,122.1 225.71,121.98 225.71,121.85 226.12,121.45 226.79,121.45 226.92,121.57 227.15,121.57 v1(227.33,121.39)
  BOTTOM w0.114: CN55.8 227.91,121.46 227.79,121.58 227.52,121.58 v1(227.33,121.39)
USBP4+_DB_USB: length 2.5
  BOTTOM w0.102: R67462.1 207.67,115.1 207.67,114.71 207.6,114.63 207.6,114.07 207.45,113.92 CN48.10
USBP4-_DB: length 142.6
  TOP w0.102: R67498.2 223.67,122.25 223.51,122.25 223.29,122.03 223.29,120.04 223.2,119.94 v1(222.99,119.94)
  IN1 w0.102: v1(222.99,119.94) 223.18,119.94 223.33,120.09 223.33,120.42 223.17,120.57 222.66,120.57 220.9,118.81 217.32,118.81 215.48,116.97 215.37,116.86 213.03,116.86 211.6,118.28 208.27,118.28 207.88,117.9 207.88,117.69 207.98,117.59 207.98,117.57 v1(208.15,117.4) 207.83,117.08 207.83,110.3 207.07,109.54 205,109.54 204.37,108.91 202.99,108.91 202.26,108.18 197.11,108.18 196.37,108.92 194.26,108.92 193.42,109.76 186.66,109.76 185.89,110.54 184.95,110.54 184.57,110.91 174.99,110.91 172.43,108.35 167.5,108.35 166.76,107.62 164.77,107.62 164.26,107.1 155.89,107.1 154.84,106.05 151.39,106.05 150.8,105.46 148.69,105.46 148.49,105.66 146.03,105.66 145.95,105.58 141.7,105.58 140.66,106.63 138.58,106.63 138.2,107 133.46,107 132.68,107.78 130.47,107.78 128.1,110.14 125.74,110.14 124.2,111.69 124.2,115.45 125.75,117 125.75,118.66 126.9,119.81 126.9,121.3 126.33,121.88 126.33,123.55 125.23,124.64 125.23,125.57 124.46,126.35 124.46,126.58 124.15,126.88 123.08,126.88 122.86,127.1 122.86,127.6 122.76,127.7 122.41,127.7 v2(122.37,127.66)
  BOTTOM w0.079: v2(122.37,127.66) 122.43,127.61 122.43,127.48 122.35,127.41 122.04,127.41 U1.CD3
  BOTTOM w0.102: v1(208.15,117.4) 207.87,117.12 207.87,116.68 R67461.2
USBP4-_DB_RS232: length 4.4
  TOP w0.114: v1(227.33,122.05) 227.12,121.84 226.81,121.84 226.68,121.71 226.23,121.71 225.98,121.96 225.98,122.09 225.71,122.36 225.42,122.36 R67498.1
  BOTTOM w0.114: v1(227.33,122.05) 227.53,121.85 227.79,121.85 227.9,121.96 CN55.7
USBP4-_DB_USB: length 2.5
  BOTTOM w0.102: R67461.1 207.88,115.1 207.88,114.62 207.8,114.55 207.8,114.07 207.95,113.92 CN48.9
USBP5+_CAM: length 128.6
  IN4 w0.089: 117.21,126.31 117.21,126.2 117.58,125.83 119.35,125.83 119.42,125.76 119.42,125.54 119.32,125.45 v2(119.19,125.45) ; 115.15,126.84 116.22,126.84 116.31,126.93 116.32,126.93 116.4,127.01 116.43,127.01
  IN4 w0.102: 116.43,127.01 116.68,127.01 117.21,126.48 117.21,126.31 ; 115.15,126.84 115.13,126.84 114.6,127.36 114.26,127.36 113.71,127.92 113.71,130.95 113.2,131.45 113.2,132.58 113.04,132.73 113.04,133.56 113.33,133.84 113.33,134.07 113.04,134.37 113.04,135.55 112.28,136.31 112.28,154.43 111.71,155 111.71,166.25 111.25,166.7 111.25,171.39 110.86,171.78 110.86,172.87 112.52,174.53 112.52,183.92 110.49,185.95 100.75,185.95 97.35,189.34 95.88,189.34 94.71,190.51 88.43,190.51 85.01,187.09 79.85,187.09 78.66,188.29 74.76,188.29 74.57,188.47 72.75,188.47 71.55,189.68 70.19,189.68 68.99,188.48 66.05,188.48 65.59,188.01 64.13,188.01 63.35,188.79 62.69,188.79 62.56,188.66 62.56,188.4 62.68,188.29 v1(62.89,188.29)
  BOTTOM w0.079: U1.CG6 119.52,125.77 v2(119.19,125.45)
  BOTTOM w0.102: R25289.1 59.61,190.39 59.47,190.25 59.47,189.22 59.72,188.97 62.39,188.97 62.58,188.78 62.58,188.4 62.7,188.29 v1(62.89,188.29)
USBP5+_CAM_C: length 2
  BOTTOM w0.102: R25289.2 59.55,191.62 59.55,192.21 59.65,192.31 CN29.8
USBP5-_CAM: length 128.6
  IN4 w0.089: v2(119.77,125.42) 119.59,125.6 119.59,125.83 119.42,126.01 117.66,126.01 117.4,126.26 117.4,126.31 ; 113.24,134.43 113.24,134.79
  IN4 w0.102: v1(62.13,188.29) 62.35,188.51 62.35,188.75 62.61,189 63.43,189 64.22,188.22 65.5,188.22 65.97,188.68 68.9,188.68 70.1,189.88 71.63,189.88 72.83,188.68 74.66,188.68 74.85,188.49 78.74,188.49 79.94,187.3 84.93,187.3 88.34,190.71 94.79,190.71 95.96,189.55 97.44,189.55 100.83,186.15 110.57,186.15 112.72,184 112.72,174.45 111.06,172.79 111.06,171.87 111.46,171.47 111.46,166.79 111.91,166.33 111.91,155.09 112.49,154.51 112.49,136.39 113.24,135.64 113.24,134.79 ; 113.24,134.43 113.52,134.15 113.52,133.76 113.23,133.48 113.23,132.81 113.39,132.66 113.39,131.53 113.9,131.03 113.9,128 114.34,127.55 114.68,127.55 115.21,127.03 116.14,127.03 116.31,127.2 116.76,127.2 117.4,126.56 117.4,126.31
  BOTTOM w0.079: v2(119.77,125.42) 120.17,125.82 U1.CG5
  BOTTOM w0.102: R25288.1 59.27,190.1 59.27,189.14 59.63,188.77 62.31,188.77 62.38,188.7 62.38,188.53 v1(62.13,188.29)
USBP5-_CAM_C: length 2
  BOTTOM w0.102: CN29.7 59.15,192.34 59.35,192.14 59.35,191.53 R25288.2
USBP6+_CR: length 144.9
  IN1 w0.102: v1(27.06,65.07) 27.28,64.85 27.74,64.85 32.35,69.45 32.35,76.96 35.21,79.83 35.21,88.07 38.2,91.06 55.78,91.06 57.04,92.32 57.46,92.32 58.61,93.47 68.74,93.47 69.04,93.77 69.62,93.77 73.86,98.01 74.26,98.01 74.73,98.48 74.73,101.43 76.45,103.15 76.76,103.15 78.82,105.21 79.35,105.21 80.64,106.5 81.4,106.5 83.1,108.2 88.54,108.2 90.36,110.02 92.94,110.02 94.52,111.6 100.19,111.6 102.7,114.11 105.91,114.11 106.95,115.15 108.42,115.15 110.69,117.42 114.02,117.42 114.69,118.08 119.37,118.08 119.71,118.42 119.71,119.63 121.1,121.02 122.62,121.02 123.29,121.69 124.46,121.69 125.27,122.5 125.27,123.29 v2(125.04,123.52)
  BOTTOM w0.079: U1.CC2 122.45,128.12 122.7,127.86 123.01,127.86 123.08,127.94 123.42,127.94 124.68,126.67 124.68,126.42 125.72,125.38 125.72,125.27 125.69,125.25 125.69,125.23
  BOTTOM w0.102: 125.69,125.23 125.69,124.46 125.27,124.03 125.27,123.74 v2(125.04,123.52) ; U40.3 28.76,64.08 28.61,64.23 28.61,64.54 28.36,64.79 27.34,64.79 v1(27.06,65.07)
USBP6-_CR: length 144.8
  IN1 w0.102: v2(125.78,123.52) 125.55,123.52 125.48,123.44 125.48,122.41 124.55,121.48 123.37,121.48 122.7,120.82 121.19,120.82 119.91,119.54 119.91,118.33 119.46,117.88 114.77,117.88 114.11,117.21 110.77,117.21 108.51,114.95 107.03,114.95 106,113.91 102.78,113.91 100.27,111.4 94.6,111.4 93.02,109.82 90.45,109.82 88.62,107.99 83.19,107.99 81.49,106.3 80.73,106.3 79.44,105.01 78.91,105.01 76.85,102.95 76.53,102.95 74.93,101.34 74.93,98.4 74.34,97.81 73.94,97.81 69.7,93.56 69.12,93.56 68.82,93.26 58.69,93.26 57.55,92.12 57.12,92.12 55.86,90.86 38.29,90.86 35.42,87.99 35.42,79.75 32.55,76.88 32.55,69.37 27.83,64.64 27.19,64.64 27.06,64.51 v1(27.06,64.31)
  BOTTOM w0.079: 125.9,125.23 125.9,125.25 125.87,125.27 125.87,125.45 124.84,126.48 124.84,126.74 123.48,128.09 122.89,128.09 U1.CC1
  BOTTOM w0.102: 125.9,125.23 125.9,124.37 125.47,123.95 125.47,123.59 125.55,123.52 v2(125.78,123.52) ; v1(27.06,64.31) 27.34,64.58 28.28,64.58 28.41,64.45 28.41,64.16 28.26,64.01 U40.2
USBP7+_FP: length 76.7
  IN3 w0.102: v2(117.82,125.39) 117.86,125.39 118.11,125.14 118.11,122.16 117.21,121.26 117.21,118.83 117.1,118.71 115.93,118.71 115.74,118.91 115.74,120.26 115.45,120.55 114.88,120.55 114.35,120.02 113.21,120.02 112.98,119.78 112.98,119.41 113.18,119.2 114.09,119.2 114.24,119.05 114.24,118.75 113.71,118.21 112.86,118.21 112.58,117.93 112.58,117.04 112.47,116.94 112.07,116.94 111.98,117.04 111.98,117.99 111.76,118.21 111.27,118.21 110.7,118.78 110.31,118.78 109.51,117.98 109.51,117.61 110.34,116.78 110.34,116.59 110.15,116.4 109.89,116.4 109.24,117.05 108.87,117.05 108.64,116.82 108.64,116.26 109.19,115.72 109.19,115.48 108.84,115.14 108.05,115.14 105.93,113.02 105.93,112.71 106.61,112.03 106.61,111.69 106.98,111.32 106.98,110.98 106.83,110.84 106.64,110.84 105.4,112.08 104.99,112.08 104.71,111.79 104.71,111.02 105.07,110.65 105.57,110.65 106.36,109.86 106.36,109.68 106.2,109.53 105.44,109.53 103.71,111.25 103.32,111.25 103.02,110.95 103.02,110.59 104.56,109.05 104.56,108.84 104.37,108.65 104.17,108.65 102.91,109.91 102.51,109.91 102.24,109.65 102.24,108.8 102.64,108.39 102.64,108.26 102.47,108.08 102.29,108.08 101.89,108.48 101.56,108.48 100.64,107.57 100.64,106.72 100.08,106.16 100.08,105.05 99.67,104.64 99.5,104.64 99.38,104.76 99.38,104.99 99.16,105.22 98.73,105.22 98.51,104.99 98.51,104.25 98.38,104.12 98.08,104.12 97.98,104.23 97.98,105.05 97.75,105.27 97.27,105.27 97.02,105.03 97.02,104.48 96.92,104.38 96.64,104.38 v1(96.37,104.64)
  BOTTOM w0.079: U1.CG9 117.82,125.62 v2(117.82,125.39)
  BOTTOM w0.102: R67492.1 94.14,100.98 94.14,102.3 94.44,102.6 95.26,102.6 95.66,102.2 95.66,100.41 95.77,100.3 96.14,100.3 96.23,100.4 96.23,102.77 95.69,103.32 95.69,104.14 95.9,104.36 96.08,104.36 v1(96.37,104.64)
USBP7+_FP_P2: length 29.1
  BOTTOM w0.114: CN14.7 73.95,100.28 74.14,100.47 74.14,101.2 74.61,101.67 76.47,101.67 78.29,99.85 82.49,99.85 83.61,100.97 83.61,102.02 84.95,103.37 87.38,103.37 88.39,102.36 90.77,102.36 91.95,101.19 91.95,99.97 92.07,99.84 EC7.2 91.94,99.32 91.94,99.18 92.1,99.01 94.01,99.01 94.1,99.1 94.1,99.32 R67492.2
USBP7+_FP_P4: length 128.2
  TOP w0.102: v1(207.51,99.79) 207.27,99.55 207.27,99.22 207.43,99.05 EC16.2 207.26,98.67 207.26,96.86 v1(207.63,96.49)
  IN1 w0.102: v1(207.63,96.49) 207.39,96.74 207.39,96.99 207.14,97.25 206.15,97.25 205.14,96.24 183.67,96.24 182.65,97.25 182.01,97.25 181.21,96.45 178.73,96.45 177.93,97.25 177.35,97.25 177.22,97.13 170.01,97.13 169.8,97.33 165.61,97.33 165.26,96.97 161.37,96.97 160.91,97.43 156.96,97.43 154.56,99.83 152.16,99.83 151.44,99.11 145.34,99.11 145.11,99.33 142.32,99.33 141.68,98.7 139.86,98.7 139.19,99.38 138.58,99.38 138.06,99.89 136.1,99.89 135.24,100.75 131.48,100.75 130.77,101.47 123.13,101.47 122.55,100.9 119.78,100.9 119.26,101.41 119.26,101.45 116.88,103.84 105.72,103.84 105.55,103.66 104.15,103.66 103.45,104.37 98.8,104.37 97.3,102.87 94.17,102.87 93.96,102.65 93.96,102.26 v1(93.68,101.98)
  BOTTOM w0.102: v1(207.51,99.79) 207.26,100.04 207.26,100.18 207.35,100.27 CN52.7 ; R67497.1 v1(93.68,101.98)
USBP7-_FP: length 76.8
  IN3 w0.102: v2(118.41,125.4) 118.3,125.28 118.3,122.08 117.4,121.18 117.4,118.75 117.18,118.52 115.85,118.52 115.55,118.83 115.55,120.18 115.37,120.36 114.96,120.36 114.43,119.83 113.29,119.83 113.17,119.71 113.17,119.49 113.26,119.39 114.17,119.39 114.43,119.13 114.43,118.67 113.79,118.02 112.94,118.02 112.77,117.85 112.77,116.96 112.55,116.75 112,116.75 111.79,116.96 111.79,117.91 111.68,118.02 111.2,118.02 110.62,118.59 110.39,118.59 109.7,117.9 109.7,117.69 110.53,116.86 110.53,116.52 110.22,116.21 109.81,116.21 109.16,116.86 108.94,116.86 108.83,116.74 108.83,116.34 109.38,115.8 109.38,115.41 108.92,114.95 108.13,114.95 106.12,112.94 106.12,112.79 106.8,112.11 106.8,111.77 107.17,111.4 107.17,110.9 106.91,110.65 106.56,110.65 105.32,111.89 105.07,111.89 104.9,111.72 104.9,111.09 105.15,110.84 105.65,110.84 106.55,109.94 106.55,109.6 106.28,109.33 105.36,109.33 103.63,111.06 103.39,111.06 103.21,110.88 103.21,110.67 104.75,109.12 104.75,108.77 104.45,108.46 104.09,108.46 102.83,109.72 102.59,109.72 102.43,109.57 102.43,108.88 102.83,108.47 102.83,108.18 102.54,107.89 102.21,107.89 101.81,108.29 101.64,108.29 100.83,107.49 100.83,106.64 100.27,106.08 100.27,104.97 99.75,104.45 99.42,104.45 99.19,104.68 99.19,104.91 99.08,105.03 98.81,105.03 98.7,104.91 98.7,104.17 98.46,103.93 98,103.93 97.78,104.15 97.78,104.97 97.67,105.08 97.35,105.08 97.21,104.95 97.21,104.4 96.99,104.19 96.72,104.19 v1(96.37,103.84)
  BOTTOM w0.079: U1.CG8 118.41,125.67 v2(118.41,125.4)
  BOTTOM w0.102: v1(96.37,103.84) 96.37,104.04 96.26,104.16 95.98,104.16 95.89,104.06 95.89,103.4 96.44,102.85 96.44,100.32 96.22,100.1 95.69,100.1 95.46,100.33 95.46,102.11 95.18,102.4 94.52,102.4 94.34,102.21 94.34,100.97 R67496.2
USBP7-_FP_P2: length 29.1
  BOTTOM w0.114: R67493.2 94.37,99.31 94.37,98.99 94.12,98.74 91.99,98.74 91.67,99.07 91.67,99.31 EC8.1 91.55,99.85 91.68,99.97 91.68,101.08 90.66,102.1 88.28,102.1 87.27,103.1 85.06,103.1 83.88,101.91 83.88,100.86 82.6,99.58 78.18,99.58 76.36,101.4 74.72,101.4 74.41,101.09 74.41,100.32 74.45,100.28 CN14.6
USBP7-_FP_P4: length 128.2
  TOP w0.102: v1(206.85,99.79) 207.06,99.57 207.06,99.22 206.9,99.05 EC17.1 207.06,98.64 207.06,96.68 v1(206.87,96.49)
  IN1 w0.102: v1(94.8,101.96) 94.25,101.96 94.16,102.04 94.16,102.57 94.25,102.66 97.38,102.66 98.88,104.16 103.36,104.16 104.07,103.46 105.63,103.46 105.81,103.64 116.79,103.64 119.06,101.37 119.06,101.33 119.69,100.69 122.64,100.69 123.21,101.27 130.68,101.27 131.4,100.55 135.15,100.55 136.01,99.69 137.98,99.69 138.49,99.18 139.1,99.18 139.78,98.5 141.77,98.5 142.4,99.13 145.03,99.13 145.25,98.9 151.52,98.9 152.24,99.63 154.48,99.63 156.87,97.23 160.83,97.23 161.29,96.77 165.34,96.77 165.7,97.13 169.72,97.13 169.92,96.92 177.31,96.92 177.44,97.05 177.84,97.05 178.65,96.25 181.29,96.25 182.09,97.05 182.57,97.05 183.59,96.03 205.22,96.03 206.23,97.05 207.05,97.05 207.19,96.91 207.19,96.55 207.12,96.49 v1(206.87,96.49)
  BOTTOM w0.102: CN52.8 206.85,100.35 207.06,100.14 207.06,100 v1(206.85,99.79) ; R67496.1 v1(94.8,101.96)
USBP8+_LTE: length 135.9
  IN1 w0.102: v2(117.25,128.21) 117.64,128.59 117.99,128.59 118.36,128.97 118.36,129.35 118.76,129.75 120.65,129.75 122.9,132.01 125.04,132.01 127.3,129.74 127.3,126.24 127.99,125.56 127.99,122.49 128.49,121.99 128.49,115.15 128.75,114.89 128.75,113.85 129.63,112.98 130.98,112.98 131.86,112.1 131.86,111.45 134.69,108.62 139.07,108.62 139.47,108.22 141.55,108.22 142.29,108.96 144.4,108.96 144.98,108.39 150.65,108.39 150.99,108.05 153.26,108.05 153.67,108.46 153.67,109.01 154.03,109.37 154.99,109.37 155.65,110.03 163.6,110.03 163.86,110.28 167.06,110.28 167.69,110.92 171.28,110.92 173.49,113.13 178.52,113.13 179.29,113.89 181.04,113.89 181.72,113.21 185.64,113.21 185.96,112.89 197.55,112.89 201.62,116.96 205.33,116.96 207.48,119.1 211.93,119.1 213.36,117.67 215.03,117.67 217.96,120.6 219.51,120.6 219.77,120.34 219.77,120.12 v1(220.02,119.87)
  BOTTOM w0.079: v2(117.25,128.21) 117.57,128.52 U1.CB9
  BOTTOM w0.102: CN49.19 221.45,118.75 221.3,118.6 220.26,118.6 219.74,119.12 219.74,119.59 v1(220.02,119.87)
USBP8-_LTE: length 135.9
  IN1 w0.102: v2(117.89,128.21) 118.56,128.88 118.56,129.27 118.84,129.55 120.73,129.55 122.99,131.8 124.95,131.8 127.1,129.66 127.1,126.16 127.79,125.47 127.79,122.41 128.29,121.91 128.29,115.07 128.55,114.8 128.55,113.77 129.54,112.78 130.89,112.78 131.66,112.01 131.66,111.36 134.61,108.42 138.99,108.42 139.39,108.01 141.63,108.01 142.38,108.76 144.31,108.76 144.89,108.18 150.57,108.18 150.9,107.85 153.34,107.85 153.88,108.38 153.88,108.93 154.11,109.17 155.08,109.17 155.74,109.83 163.69,109.83 163.94,110.08 167.14,110.08 167.78,110.72 171.36,110.72 173.57,112.93 178.61,112.93 179.37,113.69 180.95,113.69 181.63,113 185.56,113 185.88,112.69 197.64,112.69 201.71,116.76 205.42,116.76 207.56,118.9 211.85,118.9 213.28,117.47 215.12,117.47 218.04,120.39 219.42,120.39 219.56,120.25 219.56,120.04 219.39,119.87 v1(219.26,119.87)
  BOTTOM w0.079: U1.CB8 118.41,128.45 118.41,128.13 118.34,128.06 118.04,128.06 v2(117.89,128.21)
  BOTTOM w0.102: v1(219.26,119.87) 219.54,119.59 219.54,119.04 220.18,118.4 221.3,118.4 221.45,118.25 CN49.20
USBP9+_HUB: length 134.8
  TOP w0.102: R25560.1 224.5,96.64 224.63,96.64 v1(224.93,96.94)
  IN3 w0.102: v1(197.13,119.14) 197.41,118.85 204.02,118.85 208.9,113.97 208.9,111.69 214.13,106.46 214.13,105.54 223.02,96.65 224.64,96.65 v1(224.93,96.94)
  IN4 w0.102: v2(119.28,124.46) 119.81,124.99 120.23,124.99 120.9,124.32 120.9,123.78 122.94,121.74 124.19,121.74 124.97,120.96 124.97,120.37 127.23,118.1 127.23,117.6 128.75,116.07 131.37,116.07 131.91,115.53 132.29,115.53 133.37,114.46 133.37,110.82 133.99,110.2 133.99,109.51 135.65,107.85 144.58,107.85 145.31,107.11 147.24,107.11 147.42,107.29 153.39,107.29 154.28,108.18 154.94,108.18 155.06,108.3 160.21,108.3 160.94,109.04 166.84,109.04 168.87,111.07 169.55,111.07 170.83,112.35 171.16,112.35 173.17,114.36 175.03,114.36 176.87,116.2 180.93,116.2 182.54,117.8 191.58,117.8 192.74,118.97 196.52,118.97 196.56,118.93 196.92,118.93 v1(197.13,119.14)
  BOTTOM w0.079: U1.CH6 119.28,124.71 v2(119.28,124.46)
USBP9+_TS: length 4
  BOTTOM w0.102: CN29.5 58.15,192.51 57.61,191.97 57.06,191.97 56.59,191.5 56.59,191.3 56.73,191.17 R67414.2 R67411.2
USBP9-_HUB: length 134.8
  TOP w0.102: R25559.1 224.5,96.44 224.66,96.44 v1(224.93,96.17)
  IN3 w0.102: v1(224.93,96.17) 224.64,96.46 222.94,96.46 213.94,105.46 213.94,106.38 208.71,111.61 208.71,113.89 203.94,118.66 197.41,118.66 v1(197.13,118.38)
  IN4 w0.102: v1(197.13,118.38) 197.13,118.61 197.01,118.73 196.48,118.73 196.44,118.77 192.83,118.77 191.66,117.6 182.62,117.6 181.01,115.99 176.95,115.99 175.12,114.16 173.26,114.16 171.25,112.15 170.91,112.15 169.63,110.87 168.95,110.87 166.92,108.84 161.03,108.84 160.29,108.1 155.15,108.1 155.02,107.97 154.36,107.97 153.48,107.08 147.5,107.08 147.32,106.91 145.23,106.91 144.49,107.64 135.56,107.64 133.78,109.42 133.78,110.12 133.16,110.74 133.16,114.37 132.21,115.33 131.83,115.33 131.29,115.87 128.67,115.87 127.03,117.51 127.03,118.02 124.77,120.28 124.77,120.88 124.11,121.53 122.86,121.53 120.69,123.7 120.69,124.24 120.15,124.78 119.96,124.78 119.87,124.69 v2(119.87,124.48)
  BOTTOM w0.079: v2(119.87,124.48) 119.8,124.55 119.8,125 119.86,125.07 120.05,125.07 U1.CH5
USBP9-_TS: length 4
  BOTTOM w0.102: R67412.2 R67415.2 56.29,191.17 56.39,191.27 56.39,191.59 56.98,192.17 57.52,192.17 57.65,192.3 CN29.4
USBP10+_BT: length 83.4
  IN1 w0.102: v2(131.68,127.83) 131.95,127.56 132.45,127.56 132.85,127.16 132.85,119.35 133.74,118.46 133.74,116.67 137.65,112.77 138.42,112.77 139.42,111.76 148.12,111.76 150,113.64 153.22,113.64 154.78,115.2 162.36,115.2 162.69,114.87 164.59,114.87 165.85,116.13 165.85,117.7 168.12,119.97 169.71,119.97 170.09,119.59 177.82,119.59 178.44,120.22 178.44,120.34 v1(178.17,120.62)
  BOTTOM w0.079: 127.56,127.2 127.54,127.2 127.52,127.17 124.93,127.17 123.68,128.42 123.17,128.42 123.07,128.53 122.7,128.53 122.66,128.52 122.4,128.52 122.31,128.56 122.14,128.56 122.09,128.54 121.81,128.46 121.75,128.44 121.61,128.4 121.46,128.4 121.29,128.31 121.24,128.28 U1.CC4
  BOTTOM w0.102: CN17.3 183.08,123.15 182.93,123 182.26,123 182.11,123.15 181.15,123.15 179.58,121.58 178.79,121.58 178.45,121.25 178.45,120.91 v1(178.17,120.62) ; 127.56,127.2 128.36,127.2 128.76,127.59 131.44,127.59 v2(131.68,127.83)
USBP10+_R: length 2.9
  TOP w0.102: R25560.2 222.92,96.66 221.66,96.66 221.43,96.88 U6509.9
USBP10-_BT: length 83.4
  IN1 w0.102: v2(131.68,127.16) 131.88,127.36 132.36,127.36 132.65,127.07 132.65,119.27 133.54,118.38 133.54,116.59 137.56,112.56 138.34,112.56 139.34,111.56 148.2,111.56 150.08,113.44 153.3,113.44 154.86,115 162.27,115 162.61,114.66 164.67,114.66 166.05,116.04 166.05,117.62 168.2,119.77 169.63,119.77 170.01,119.39 177.9,119.39 178.65,120.13 178.65,120.34 v1(178.93,120.62)
  BOTTOM w0.079: U1.CC3 121.48,128.04 121.48,127.87 121.55,127.81 121.76,127.81 121.87,127.91 121.87,128.22 121.95,128.3 122.1,128.37 122.17,128.4 122.27,128.4 122.36,128.35 122.68,128.35 122.76,128.37 123,128.37 123.11,128.27 123.62,128.27 124.87,127.02 127.52,127.02 127.54,126.99 127.56,126.99
  BOTTOM w0.102: v1(178.93,120.62) 178.66,120.89 178.66,121.16 178.87,121.38 179.67,121.38 181.23,122.95 182.03,122.95 182.17,122.8 182.89,122.8 183.04,122.65 CN17.5 ; v2(131.68,127.16) 131.45,127.39 128.84,127.39 128.45,126.99 127.56,126.99
USBP10-_R: length 2.9
  TOP w0.102: R25559.2 222.89,96.46 221.64,96.46 221.42,96.23 U6509.8
USBP_TYPC+_C: length 20.3
  IN1 w0.102: CN10.B6 7.79,67.02 8.64,67.87 8.64,68.33 9.14,68.83 9.73,68.83 10.82,67.74 10.82,66.74 10.29,66.21 v1(9.5,66.21) 9.5,66.27 9.33,66.43 9.13,66.43 8.99,66.3 8.99,64.77 9.72,64.05 9.72,63.31 10.54,62.48 10.54,61.64 10.29,61.39 10.06,61.39 v1(9.5,60.83)
  BOTTOM w0.102: CN10.A6 8.08,66.37 8.21,66.49 9.23,66.49 9.5,66.22 v1(9.5,66.21) ; v1(9.5,60.83) 10.2,60.83 RV1.1 10.89,61.3 11,61.41 11.46,61.41 R25292.2
USBP_TYPC-_C: length 20.3
  IN1 w0.102: v1(9.48,62.2) 10.09,61.59 10.21,61.59 10.34,61.73 10.34,62.4 9.51,63.23 9.51,63.96 8.79,64.68 8.79,66.38 9.05,66.64 9.27,66.64 v1(9.5,66.87) 9.73,66.87 9.79,66.8 9.79,66.5 9.88,66.41 10.21,66.41 10.62,66.82 10.62,67.65 9.65,68.63 9.22,68.63 8.84,68.25 8.84,67.79 7.87,66.82 7.13,66.82 6.91,66.6 6.91,66.5 6.63,66.22 CN10.B7
  BOTTOM w0.102: CN10.A7 8.03,66.87 8.21,66.7 9.35,66.7 9.5,66.85 v1(9.5,66.87) ; v1(9.48,62.2) 10.21,62.2 RV1.2 10.87,61.75 11.01,61.61 11.43,61.61 R67470.2
USIM_DET: length 91.5
  TOP w0.114: U37.68 167.78,98.34 168.53,97.58 168.53,97.17 168.88,96.83 171.4,96.83 171.91,96.32 173.53,96.32 174.8,95.04 196.22,95.04 197.2,96.02 197.55,96.02 v1(197.67,96.14) 198.26,96.73 v1(198.42,96.73)
  IN1 w0.089: v1(225.1,125.35) 225.1,124.74 226.64,123.19 227.02,123.19 227.94,122.28 227.94,113.56 225.36,110.98 225.36,105.45 222.5,102.59 215.28,102.59 211.2,98.51 206.74,98.51 204.96,96.73 v1(198.42,96.73)
  BOTTOM w0.114: v1(225.1,125.35) 225.16,125.29 225.16,124.23 223.67,122.75 CN49.11
VA2: length 141.6
  IN1 w0.381: v1(160.98,124.42) 160.98,124.05 160.5,123.56 156.92,123.56 155.55,124.93 151.49,124.93 150.17,126.26 150.17,128.23 146.71,131.69 143.36,131.69 142.39,130.72 v1(142.29,130.72)
  IN3 w0.381: v1(71.63,198.5) 73.05,198.5 74.47,197.08 76.71,197.08 78.61,198.98 88.78,198.98 90.24,197.52 90.24,192.66 93.72,189.19 93.72,187.12 94.23,186.61 96.42,186.61 98.08,184.95 102.08,184.95 104.96,182.07 107.13,182.07 109.09,180.11 111.03,180.11 118.23,172.91 118.23,170.96 124.01,165.18 124.01,164.36 125.95,162.42 125.95,157.99 130.15,153.78 130.15,152.35 137.74,144.77 139.2,144.77 139.83,144.14 139.83,132.41 141.52,130.72 v1(142.29,130.72)
  BOTTOM w0.381: PR28.1 160.8,123.95 160.98,124.14 v1(160.98,124.42)
  vias: v1(70.31,196.26)
VADJ1: length 7.8
  BOTTOM w0.114: R441.2 66.77,188.1 R442.1 C558.1 68.53,188.61 68.53,188.82 68.94,189.23 68.94,189.71 68.76,189.89 v1(68.76,191.28) 68.76,191.33 69.15,191.72 CN29.27
VCONN_5V_P1: length 7.1
  BOTTOM w0.114: U6511.8 23.02,53.46 23.24,53.69 23.24,56.31 22.95,56.6 22.71,56.6 22.49,56.82 U6510.6 23.07,57.05 v1(23.3,57.27) 23.3,57.4 23.14,57.55 U6510.5
VCORE_SENSE: length 28.5
  TOP w0.114: PR7044.1 140.04,153.38 139.52,153.9 PR7043.1 138.66,153.9 138.46,153.7 137.78,153.7 v1(137.35,154.13)
  IN4 w0.089: v1(137.35,154.13) 137.35,153.82 137.15,153.62 131.79,153.62 129.39,151.21 129.39,147.45 128.3,146.36 v1(127.78,146.36)
  BOTTOM w0.102: U1.AN6 119.88,146.56 120.33,146.56 120.6,146.82 121.05,146.82 121.09,146.78 121.37,146.78 121.39,146.8 122.99,146.8 123.42,146.37 123.88,146.37 125.35,144.9 126.09,144.9
  BOTTOM w0.114: 126.09,144.9 126.2,144.9 127.66,146.36 v1(127.78,146.36)
VCORESS_SENSE: length 27.5
  TOP w0.114: PR7045.1 139.59,156.12 138.81,155.34 PR7046.1 138.81,154.91 v1(138.07,154.16)
  IN4 w0.089: v1(127.67,145.71) 127.88,145.91 128.35,145.91 129.72,147.29 129.72,150.9 132.06,153.23 137.57,153.23 138.07,153.74 v1(138.07,154.16)
  BOTTOM w0.102: U1.AN5 123.81,146.19 125.34,144.65 126.09,144.65
  BOTTOM w0.114: v1(127.67,145.71) 127.47,145.71 126.42,144.65 126.09,144.65
VGA_DDC_CLK_RT: length 29.5
  TOP w0.114: U67.15 29.28,155.52 28.53,156.27 28.53,156.6 28.66,156.73 28.66,157.03 v1(28.91,157.27) 28.91,157.61 v1(29.23,157.94) ; CN21.15 7.8,161.59 8.73,160.66 R25529.2 9.39,160.53 ESD4.6 ESD4.5 12.09,160.53 C20006.2 13.41,160.78 14.25,160.78 v1(14.35,160.88)
  IN1 w0.089: v1(29.23,157.94) 28.76,158.42 27.61,158.42 27.16,158.87 25.07,158.87 24.11,157.91 16.4,157.91 15.38,158.93 15.38,159.85 v1(14.35,160.88)
VGA_DDC_DAT_RT: length 29.6
  TOP w0.114: U67.16 28.88,155.39 27.93,156.33 v1(27.93,157) 27.51,157.42 v1(27.51,157.58) ; v1(13.59,158.04) 13.63,158 C20004.1 13.21,156.96 R25528.2 12.18,156.96 11.29,157.85 ESD4.1 ESD4.10 9.99,158.53 9.85,158.67 8.94,158.67 8.54,158.27 8.54,157.53 7.8,156.79 CN21.12
  IN1 w0.089: v1(27.93,157) 27.29,157.64 27.29,158.21 26.84,158.66 25.16,158.66 24.2,157.69 16.32,157.69 15.92,158.09 13.95,158.09 13.9,158.04 v1(13.59,158.04)
VGA_DDI2_AUXN_C: length 3.2
  TOP w0.102: U67.3 32.9,152.08 33.01,151.97 33.23,151.97 34.38,150.82 34.59,150.82 34.8,151.03 C20014.2
VGA_DDI2_AUXP_C: length 3.2
  TOP w0.102: C20015.2 34.8,150.41 34.59,150.62 34.29,150.62 33.15,151.77 33.01,151.77 32.92,151.68 U67.2
VGA_DDI2_TXN0_C: length 2.9
  TOP w0.102: U67.6 32.87,153.28 32.97,153.17 33.13,153.17 33.83,153.88 34.39,153.88 C20017.2
VGA_DDI2_TXN1_C: length 3.8
  TOP w0.102: C20019.2 34.04,155.87 33.86,155.87 33.23,155.24 33.23,154.07 33.13,153.97 32.99,153.97 32.88,154.08 U67.8
VGA_DDI2_TXP0_C: length 2.9
  TOP w0.102: U67.5 32.88,152.88 32.97,152.97 33.21,152.97 33.92,153.68 34.4,153.68 C20016.2
VGA_DDI2_TXP1_C: length 3.7
  TOP w0.102: U67.7 32.9,153.68 32.99,153.77 33.22,153.77 33.44,153.99 33.44,155.15 33.95,155.67 34.06,155.67 C20018.2
VGA_OVT#: length 27.1
  BOTTOM w0.102: U8.A6 123.92,182.13 123.19,181.39 121.41,181.39 120.82,180.8
  BOTTOM w0.114: 120.82,180.8 118.33,180.8 116.53,179.01 116.53,178.83 R395.1 116.11,177.13 115.7,176.72 108.3,176.72 v1(107.47,177.54) 107.47,178.36 105.95,179.88 105.52,179.88 104.7,180.7 104.7,182.32 Q15.1
VGA_RST#: length 13.3
  TOP w0.102: v2(124.32,201.05) 124.13,201.23
  TOP w0.114: v1(118.83,205.12) 118.83,204.91 122.26,201.48 123.89,201.48 124.13,201.23
  BOTTOM w0.114: v1(118.29,208.86) 117.85,208.42 R296.1 117.53,208.03 C364.1 116.76,207.19 v1(118.83,205.12)
  BOTTOM w0.127: U8.AC7 v2(124.32,201.05)
VGA_SDA: length 3.4
  TOP w0.114: R25530.1 R458.2 30.61,149.18 30.61,149.64 30.48,149.77 U67.29
VGA_SLK: length 6.7
  TOP w0.114: R25533.2 33.07,146.33 32.82,146.59 32.82,148.27 33.04,148.49 R25531.1 32.71,149.12 31.43,149.12 v1(31.22,149.32) 30.88,149.66 U67.30
VGA_VCCSENSE: length 30.6
  TOP w0.114: v1(98.27,191.34) 98.41,191.48 PR9028.2
  IN3 w0.102: v1(116.47,188.36) 116.2,188.63 114.79,188.63 114.02,187.87 114.02,187.08 112.88,185.93 110.92,185.93 110.19,186.66 105.95,186.66 105.18,187.43 103.34,187.43 100.21,190.56 99.46,190.56 98.68,191.34 v1(98.27,191.34)
  BOTTOM w0.102: U8.F2 120.51,186.55 120.1,186.14 119.58,186.14 118.99,186.73 118.99,187.77
  BOTTOM w0.114: PR9026.2 115.93,188.36 v1(116.47,188.36) 116.56,188.28 117.27,188.28 117.43,188.11 117.43,187.77 117.55,187.65 117.88,187.65 117.98,187.75 117.98,188.12 118.14,188.28 118.52,188.28 118.99,187.81 118.99,187.77
VGA_VSSSENSE: length 30.6
  TOP w0.114: PR9029.2 98.59,191.9 98.12,191.9 v1(97.58,191.36)
  IN3 w0.102: v1(97.58,191.36) 98.06,191.84 98.47,191.84 99.54,190.77 100.29,190.77 103.42,187.64 105.26,187.64 106.02,186.88 110.31,186.88 111.05,186.14 112.8,186.14 113.82,187.16 113.82,187.95 114.7,188.84 116.27,188.84 v1(116.47,189.04)
  BOTTOM w0.102: 119.21,187.77 119.21,187.16 U8.F1
  BOTTOM w0.114: PR9031.2 116.29,189.22 v1(116.47,189.04) 117.02,188.49 118.67,188.49 119.21,187.95 119.21,187.77
VL: length 264.8
  TOP w0.114: v1(29.5,105.57) 29.57,105.64 PR8050.2
  IN3 w0.102: v1(52.56,178.89) 52.56,178.22 52.18,177.84 45.05,177.84 39.1,171.9 39.1,158.7 v1(38.51,158.11)
  IN4 w0.089: v1(23.06,156.58) 23.06,153.82 23.87,153.01 23.87,149.77 25.47,148.17 25.47,147.27 24.95,146.76 24.95,142.34 27.74,139.56 27.74,134.9 27.19,134.35 27.19,129.79 28.21,128.77 28.21,124.17 27.29,123.26 27.29,119.25 26.68,118.63 26.68,116.45 27.83,115.3 29.58,115.3 30.19,114.69 30.19,109.93 29.97,109.71 29.97,106.68 29.5,106.21 v1(29.5,105.57) 29.5,104.31 34,99.81 34.9,99.81 37.86,96.85 45.32,96.85 45.74,96.43 48.63,96.43 50.71,94.34 50.71,92.86 51.36,92.2 68.35,92.2 68.51,92.05 74.12,92.05 76.17,94.1 78.4,94.1 79.19,94.88 92.83,94.88 93.34,95.39 97.46,95.39 98.47,94.38 114.58,94.38 v1(116.27,96.06)
  BOTTOM w0.114: v1(23.06,156.58) 23.06,156.4 23.57,155.89 27.75,155.89 28.05,155.6 33.86,155.6 36.37,158.11 v1(38.51,158.11) ; v1(133.28,111.76) 132.47,111.76 131.98,111.27 ; PR6025.1 59.43,177.95 58.44,176.96 52.97,176.96 52.42,177.5 52.42,178.09 52.56,178.22 v1(52.56,178.89) ; 131.98,111.27 128.53,111.27 128.2,111.6 128.2,112.07 128.43,112.3 128.43,112.78 PR3020.1 ; 131.98,111.27 133.59,111.27 134.38,110.48 134.7,110.48 135.47,109.71 139.74,109.71 139.97,109.48 139.97,107.27 140.83,106.4 140.83,105.88 140.88,105.83 140.88,103.7 137.8,100.61 137.8,97.18 136.48,95.86 120.42,95.86 119.69,95.12 117.21,95.12 v1(116.27,96.06)
VMA_CLK0: length 40.3
  IN1 w0.114: v2(139.22,185.29) 139.65,184.86 140.85,184.86 141.51,185.51 149.37,185.51 149.69,185.83 149.69,186.36 149.83,186.5 150.27,186.5 150.43,186.35 150.43,185.51 150.72,185.22 151.62,185.22 151.87,185.47 151.87,186.72 151.99,186.84 152.43,186.84 152.55,186.72 152.55,185.47 152.79,185.22 153.43,185.22 153.68,185.47 153.68,186.72 153.79,186.84 154.23,186.84 154.35,186.72 154.35,185.47 154.6,185.22 155.23,185.22 155.48,185.47 155.48,186.52 155.56,186.6 156.07,186.6 156.15,186.52 156.15,185.47 156.4,185.22 157.57,185.22 158.76,184.02 158.76,182.16 158.62,182.02 v2(158.5,182.02)
  BOTTOM w0.079: 159.69,184.45 159.69,184.43 159.73,184.39 159.73,184.18 159.22,183.67 159.22,181.43 159.09,181.3 158.98,181.3 158.9,181.37 VRAM1.J12 158.9,181.63 v2(158.5,182.02)
  BOTTOM w0.102: U8.D24 139.19,184.85 139.29,184.95 139.29,185.21 v2(139.22,185.29)
  BOTTOM w0.127: R25488.2 160.18,186.58 160.18,185.73 159.69,185.24 159.69,184.45
VMA_CLK0#: length 40.5
  IN1 w0.114: v2(158.5,181.22) 158.99,181.71 158.99,184.12 157.67,185.45 156.49,185.45 156.38,185.56 156.38,186.61 156.17,186.83 155.47,186.83 155.25,186.61 155.25,185.56 155.14,185.45 154.69,185.45 154.58,185.56 154.58,186.82 154.33,187.07 153.69,187.07 153.45,186.82 153.45,185.56 153.33,185.45 152.89,185.45 152.77,185.56 152.77,186.82 152.53,187.07 151.89,187.07 151.64,186.82 151.64,185.56 151.53,185.45 150.81,185.45 150.66,185.6 150.66,186.44 150.37,186.73 149.74,186.73 149.47,186.46 149.47,185.93 149.28,185.74 141.41,185.74 140.76,185.09 140.18,185.09 v2(140,185.26)
  BOTTOM w0.079: 159.93,184.45 159.93,184.43 159.89,184.39 159.89,184.12 159.38,183.61 159.38,181.36 159.16,181.14 158.98,181.14 158.9,181.06 VRAM1.J11 158.5,181.21 v2(158.5,181.22)
  BOTTOM w0.102: v2(140,185.26) 139.62,184.88 U8.D25
  BOTTOM w0.127: 159.93,184.45 159.93,185.14 160.43,185.63 160.43,186.59 R25488.1
VMA_CLK1: length 42.5
  IN1 w0.114: v2(158.5,197.22) 158.75,196.97 158.75,196.7 158.52,196.46 152.44,196.46 149.12,193.14 149.12,191.74 149.56,191.3 152.46,191.3 152.72,191.03 152.72,190.51 152.51,190.29 142.57,190.29 141.91,190.95 138.37,190.95 137.6,191.72 v2(137.6,191.91)
  BOTTOM w0.079: v2(158.5,197.22) 158.5,196.5 158.56,196.44 158.83,196.44 158.9,196.51 VRAM2.J12 158.9,196.99 159.06,197.15 159.14,197.15 159.22,197.07 159.22,196.54 159.42,196.34 159.92,196.34 160.05,196.21 160.05,194.08 160,194.04 160,194.02
  BOTTOM w0.127: v2(137.6,191.91) 137.42,191.91 137.18,192.15 U8.N22 ; 160,194.02 160,193.46 159.55,193 159.55,192.08 159.44,191.97 R25489.2
VMA_CLK1#: length 42.7
  IN1 w0.114: v2(137.6,191.09) 137.91,191.09 138.28,190.72 141.82,190.72 142.47,190.07 152.61,190.07 152.95,190.41 152.95,191.13 152.55,191.53 149.65,191.53 149.35,191.84 149.35,193.05 152.53,196.24 158.62,196.24 158.98,196.6 158.98,197.37 158.5,197.85 v2(158.5,198.04)
  BOTTOM w0.079: v2(158.5,198.04) 158.9,197.64 158.9,197.63 ; VRAM2.J11 158.9,197.43 159.03,197.3 159.21,197.3 159.38,197.13 159.38,196.61 159.49,196.49 159.98,196.49 160.2,196.27 160.2,194.08 160.25,194.04 160.25,194.02
  BOTTOM w0.102: 158.9,197.63 VRAM2.J11
  BOTTOM w0.127: 160.25,194.02 160.25,193.36 159.8,192.9 159.8,192.13 159.89,192.03 R25489.1 ; U8.M22 v2(137.6,191.09)
VMA_DQ0: length 39.7
  IN1 w0.127: v2(133.41,186.08) 133.93,185.55 133.93,184.93 133.82,184.82 133.82,184.25 134.93,183.14 134.93,181.75 136.77,179.91 138.09,179.91 139.35,178.65 148.91,178.65 151.04,176.52 151.04,174.26 152.28,173.01 155.07,173.01 156.54,171.55 160.79,171.55 161.3,172.07 161.3,172.82 v2(161.7,173.22)
  BOTTOM w0.165: VRAM1.E2 162.1,173.62 v2(161.7,173.22) ; v2(133.41,186.08) U8.E18
VMA_DQ1: length 37.5
  IN1 w0.127: v2(160.9,173.22) 160.9,173.06 160.51,172.67 160.51,172.17 160.32,171.99 156.72,171.99 155.26,173.45 152.46,173.45 151.47,174.43 151.47,176.7 149.09,179.08 139.53,179.08 138.27,180.34 137.24,180.34 135.83,181.76 135.83,182.15 135.18,182.79 135.18,183.42 134.89,183.71 134.89,184.53 134.43,184.99 134.43,185.84 v2(134.21,186.05)
  BOTTOM w0.165: v2(160.9,173.22) 161.3,173.62 VRAM1.F2 ; U8.F18 133.84,186.42 v2(134.21,186.05)
VMA_DQ2: length 47.2
  IN1 w0.127: v2(165.7,173.22) 165.7,172.67 163.73,170.69 152.03,170.69 150.17,172.55 150.17,176.16 148.55,177.78 138.76,177.78 138.28,178.25 135.79,178.25 132.99,181.05 132.99,181.99 132.09,182.89 132.09,184.64 132.21,184.76 132.21,185.67 v2(132.58,186.04)
  BOTTOM w0.102: U8.E16 132.17,185.65 v2(132.58,186.04)
  BOTTOM w0.165: v2(165.7,173.22) 165.31,173.62 VRAM1.A2
VMA_DQ3: length 45.5
  IN1 w0.127: v2(164.9,173.22) 164.51,172.83 164.51,172.27 163.36,171.12 152.21,171.12 150.6,172.73 150.6,176.34 148.73,178.21 138.94,178.21 138.46,178.69 137.13,178.69 134.08,181.74 134.08,182.39 133.85,182.63 133.85,183.74 133.01,184.58 133.01,186.54 v2(133.41,186.94)
  BOTTOM w0.165: v2(133.41,186.94) 133.41,186.86 133.03,186.49 U8.F17 ; v2(164.9,173.22) 164.51,173.62 VRAM1.B2
VMA_DQ4: length 30.9
  IN1 w0.127: v2(160.9,175.62) 160.5,176.02 160.5,176.63 159.83,177.3 158.4,177.3 158.11,177.01 155.76,177.01 155.47,177.3 152.7,177.3 149.63,180.37 140.07,180.37 137.84,182.6 136.84,182.6 136.02,183.43 136.02,184.25 v2(135.87,184.4)
  BOTTOM w0.165: U8.D20 135.87,184.46 v2(135.87,184.4) ; VRAM1.F4 161.3,175.22 v2(160.9,175.62)
VMA_DQ5: length 34.1
  IN1 w0.127: v2(164.9,174.82) 164.51,175.22 164.51,176.03 163.22,177.32 161.64,177.32 160.5,178.46 152.76,178.46 149.98,181.24 140.42,181.24 138.2,183.46 137.17,183.46 136.72,183.92 v2(136.72,184.45)
  BOTTOM w0.165: VRAM1.B4 164.51,175.22 v2(164.9,174.82) ; v2(136.72,184.45) U8.D21
VMA_DQ6: length 32.8
  IN1 w0.127: v2(135.92,186.02) 136.3,185.64 136.3,183.73 136.99,183.03 138.02,183.03 140.25,180.81 149.81,180.81 152.75,177.86 160.11,177.86 161.3,176.67 161.3,176.03 161.7,175.63 v2(161.7,175.62)
  BOTTOM w0.165: U8.F20 135.48,186.45 v2(135.92,186.02) ; v2(161.7,175.62) 162.1,175.22 VRAM1.E4
VMA_DQ7: length 35.2
  IN1 w0.127: v2(165.7,174.82) 165.3,175.22 165.3,175.85 163.4,177.75 161.82,177.75 160.57,179 152.83,179 150.16,181.67 140.6,181.67 138.38,183.9 137.35,183.9 137.12,184.13 137.12,184.85 v2(136.72,185.25)
  BOTTOM w0.165: VRAM1.A4 165.31,175.22 v2(165.7,174.82) ; U8.E21 136.32,185.65 v2(136.72,185.25)
VMA_DQ8: length 43
  IN4 w0.127: v2(131.76,186.04) 131.76,187.23 132.61,188.08 133.08,188.08 133.79,187.37 140.62,187.37 141,187.75 142.53,187.75 143.34,188.57 161.86,188.57 164.03,186.39 164.03,182.74 164.5,182.27 164.5,180.82 v2(164.9,180.42)
  BOTTOM w0.165: VRAM1.B11 164.51,180.82 v2(164.9,180.42) ; U8.E15 131.38,185.65 131.76,186.02 v2(131.76,186.04)
VMA_DQ9: length 35.2
  IN4 w0.127: v2(131.77,185.25) 131.98,185.25 132.37,185.65 135.4,185.65 135.44,185.61 136.5,185.61 136.54,185.65 138.24,185.65 138.27,185.68 140.36,185.68 141.06,186.38 145.8,186.38 146.97,187.55 157.49,187.55 159.89,185.15 160.75,185.15 162.1,183.8 162.1,183.22 v2(161.7,182.82)
  BOTTOM w0.165: v2(161.7,182.82) 162.1,182.42 VRAM1.E13
  BOTTOM w0.178: U8.D15 131.39,184.85 131.77,185.22 v2(131.77,185.25)
VMA_DQ10: length 45.6
  IN4 w0.127: v2(130.86,186.89) 130.68,187.06 130.68,188.46 131.14,188.92 132.27,188.92 132.42,189.07 132.42,189.58 132.81,189.96 134.32,189.96 135.26,189.02 139.83,189.02 139.89,189.07 142.56,189.07 142.96,189.48 144.82,189.48 145.28,189.94 146.33,189.94 146.4,189.86 152.76,189.86 153.06,189.56 162.16,189.56 166.13,185.59 166.13,182.46 v2(165.7,182.02)
  BOTTOM w0.165: U8.F15 131.25,186.49 v2(130.86,186.89) ; VRAM1.A13 165.31,182.42 v2(165.7,182.02)
VMA_DQ11: length 49.3
  IN4 w0.127: v2(165.7,180.42) 166.59,181.31 166.59,185.77 161.87,190.5 160.55,190.5 160.38,190.32 146.59,190.32 146.52,190.39 145.09,190.39 144.63,189.94 142.6,189.94 142.49,189.83 135.05,189.83 134.53,190.36 132.17,190.36 129.72,187.91 129.72,186.47 v2(129.3,186.05)
  BOTTOM w0.165: v2(165.7,180.42) 165.31,180.82 VRAM1.A11 ; U8.F13 129.68,186.43 v2(129.3,186.05)
VMA_DQ12: length 37.7
  IN4 w0.127: v2(162.5,181.22) 162.11,181.62 161.48,181.62 161.3,181.8 161.3,182.18 161.06,182.42 159.87,182.42 159.54,182.75 159.54,183.42 156.88,186.08 147.51,186.08 146.35,184.91 144.04,184.91 142.9,183.76 139.67,183.76 139.39,184.04 138.73,184.04 138.34,183.65 134.08,183.65 133.71,184.02 133.1,184.02 132.85,183.76 130.25,183.76 v2(130.14,183.65)
  BOTTOM w0.165: v2(162.5,181.22) 162.1,180.82 VRAM1.E11 ; U8.C13 129.75,184.05 v2(130.14,183.65)
