# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A0: length 72.2
  IN4 w0.102: v1(45.91,136.35) 45.91,133.72 45.77,133.59 45.47,133.59 45.26,133.79 45.26,136.95 46.55,138.23 47.94,138.23 48.23,137.95 55.58,137.95 57.4,139.76 59.92,139.76 61.22,141.07 63.13,141.07 63.86,140.34 69.63,140.34 81.55,152.25 90.72,152.25 91.01,152.54 95.44,152.54 95.44,152.55 96.61,152.55 96.95,152.88 96.95,153.14 v2(96.52,153.56)
  BOTTOM w0.079: v2(96.52,153.56) 97.02,153.07 98.63,153.07 98.77,152.93 100.15,152.93 U1.AC37
  BOTTOM w0.14: v1(45.91,136.35) 45.91,136.11 45.62,135.82 JDIM1.144
M_A_A1: length 73.8
  IN4 w0.102: v1(48.66,138.79) 48.41,138.79 48.32,138.7 48.32,138.43 48.4,138.35 55.36,138.35 57.18,140.17 58.72,140.17 58.87,140.33 58.87,140.55 59.25,140.92 59.57,140.92 59.94,140.55 60.13,140.55 60.3,140.71 60.3,141.28 60.49,141.47 63.29,141.47 64.03,140.74 69.46,140.74 78.32,149.6 78.32,149.75 77.75,150.32 77.75,150.46 77.9,150.61 78.04,150.61 78.61,150.03 78.76,150.03 78.9,150.18 78.9,150.32 78.33,150.89 78.33,151.04 78.47,151.18 78.62,151.18 79.19,150.61 79.33,150.61 79.48,150.75 79.48,150.9 78.9,151.47 78.9,151.61 79.05,151.76 79.19,151.76 79.76,151.18 79.91,151.18 81.38,152.66 90.62,152.66 90.78,152.82 94.44,152.82 94.76,153.14 95.23,153.14 95.54,152.82 96.31,152.82 96.42,152.93 96.42,153.13 96.29,153.26 95.89,153.26 95.81,153.34 v2(95.81,153.56)
  BOTTOM w0.079: U1.AC36 100.7,152.65 100.48,152.65 100.35,152.58 100.09,152.58 99.91,152.77 98.69,152.77 98.56,152.9 96.81,152.9 96.7,153.01 95.52,153.01 95.45,153.08 95.45,153.2 v2(95.81,153.56)
  BOTTOM w0.14: v1(48.66,138.79) 48.66,138.74 49.08,138.33 50.32,138.33 50.57,138.57 JDIM1.133
M_A_A2: length 72.6
  IN4 w0.102: v2(97.76,153.58) 97.76,153.8 97.56,154 95.16,154 94.92,154.25 92.46,154.25 92.33,154.12 91.54,154.12 91.38,154.29 79.28,154.29 75.85,150.85 75.85,149.42 68.79,142.37 64.73,142.37 63.96,143.15 61.44,143.15 61.11,143.47 60.53,143.47 60.21,143.15 59.93,143.15 59.54,143.53 59.22,143.53 58.94,143.25 58.71,143.25 58.59,143.37 58.59,143.98 58.52,144.05 58.33,144.05 58.11,143.84 58.11,143.37 58.03,143.29 57.61,143.29 55.76,141.43 54.25,141.43 54.13,141.32 54.13,140.62 54.03,140.52 53.79,140.52 53.69,140.62 53.69,141.33 53.58,141.43 53.36,141.43 53.13,141.2 53.13,140.59 52.97,140.43 52.36,140.43 52.33,140.46 50.24,140.46 49.97,140.18 49.97,139.85 49.72,139.61 47.55,139.61 47.41,139.74 47.41,139.91 47.53,140.03 48.12,140.03 v1(48.22,140.13)
  BOTTOM w0.079: v2(97.76,153.58) 97.76,153.3 97.82,153.23 98.7,153.23 98.84,153.09 100.37,153.09 100.44,153.07 100.69,153.07 100.78,153.09 101.93,153.09 U1.AC34
  BOTTOM w0.14: v1(48.22,140.13) 46.91,138.82 JDIM1.132
M_A_A3: length 74.6
  IN4 w0.102: v1(50.07,138.79) 53.21,138.79 53.72,139.3 55.73,139.3 57.01,140.58 58.33,140.58 58.61,140.85 58.61,141.33 58.71,141.43 59.67,141.43 60.13,141.89 63.46,141.89 64.19,141.15 69.3,141.15 77.72,149.57 77.72,149.78 77.23,150.27 77.23,150.51 79.02,152.3 79.22,152.3 79.78,151.75 79.89,151.75 80.1,151.95 80.1,152.1 79.56,152.64 79.56,152.74 79.76,152.94 79.88,152.94 80.43,152.39 80.54,152.39 80.73,152.58 80.73,152.76 80.66,152.83 80.66,152.96 80.76,153.07 94.04,153.07 v2(94.55,153.57)
  BOTTOM w0.079: 95.56,152.62 95.87,152.62 95.98,152.73 98.49,152.73 98.61,152.61 99.83,152.61 100.02,152.41 100.4,152.41 100.52,152.49 101.18,152.49 U1.AC35
  BOTTOM w0.14: v1(50.07,138.79) 50.35,139.07 JDIM1.131 ; 95.56,152.62 90.33,152.62 90.2,152.75 90.2,152.99 90.46,153.25 94.22,153.25 v2(94.55,153.57)
M_A_A4: length 72.6
  IN4 w0.102: v1(47.19,140.91) 46.64,140.35 46.64,140.11 46.73,140.02 46.94,140.02 47.36,140.44 47.53,140.44 47.84,140.74 48.05,140.74 48.23,140.56 48.44,140.56 48.54,140.66 48.54,141.2 48.62,141.28 52.06,141.28 53.06,142.29 53.24,142.29 53.37,142.42 53.37,142.77 53.48,142.87 53.82,142.87 53.92,142.77 53.92,142.38 54.02,142.29 55.35,142.29 58.07,145 62.4,145 62.58,144.82 62.58,144.3 62.92,143.96 63.7,143.96 64.24,144.49 67.25,144.49 67.43,144.32 67.87,144.32 68.04,144.49 68.53,144.49 68.64,144.39 68.64,144.19 68.24,143.8 68.24,143.42 68.36,143.3 68.57,143.3 75.03,149.76 75.03,151.19 78.94,155.1 91.77,155.1 v2(91.9,154.97)
  BOTTOM w0.079: v2(91.9,154.97) 92.25,154.62 93.94,154.62 94.24,154.33 98.91,154.33 99.35,153.88 100.35,153.88 100.42,153.91 100.72,153.91 100.8,153.88 101.01,153.88 101.06,153.91 101.31,153.91 U1.AA35
  BOTTOM w0.14: v1(47.19,140.91) 47.19,140.53 46.75,140.09 46.75,139.51 46.54,139.3 46.24,139.3 46.1,139.44 46.1,139.68 45.96,139.82 JDIM1.128
M_A_A5: length 73.6
  IN4 w0.102: v1(45.99,140.42) 45.84,140.42 45.72,140.54 45.72,141.39 45.65,141.46 45.35,141.46 45.24,141.35 45.24,139.37 45.42,139.2 45.59,139.2 45.67,139.11 45.67,138.76 45.74,138.69 46.01,138.69 46.11,138.79 46.11,139.54 46.2,139.62 46.52,139.62 46.6,139.55 46.6,138.73 46.69,138.64 46.89,138.64 47,138.75 47,139.1 47.1,139.2 47.31,139.2 47.41,139.1 47.41,138.73 47.5,138.64 47.7,138.64 47.81,138.75 47.81,139.1 47.92,139.2 53.04,139.2 53.55,139.71 55.29,139.71 57.42,141.84 59.5,141.84 60,142.33 63.62,142.33 64.4,141.56 69.13,141.56 77.08,149.51 77.08,149.84 76.66,150.26 76.66,150.52 79.62,153.47 92.32,153.47 92.43,153.36 93.88,153.36 93.97,153.44 v2(93.97,153.75)
  BOTTOM w0.079: U1.AB35 101.21,153.31 101.16,153.26 100.75,153.26 100.66,153.23 100.47,153.23 100.4,153.26 98.96,153.26 98.82,153.4 98.37,153.4 98.29,153.48 98.29,153.93 98.23,153.99 94.2,153.99 v2(93.97,153.75)
  BOTTOM w0.14: v1(45.99,140.42) 45.9,140.32 JDIM1.126
M_A_A6: length 73.2
  IN4 w0.102: v2(94.41,154.97) 93.97,154.52 91.57,154.52 91.4,154.69 79.11,154.69 75.44,151.02 75.44,149.59 68.62,142.77 67.94,142.77 67.83,142.88 67.83,143.81 67.73,143.91 67.53,143.91 67.43,143.81 67.43,142.88 67.33,142.77 67.12,142.77 67.02,142.88 67.02,143.98 66.92,144.09 66.71,144.09 66.61,143.99 66.61,142.88 66.51,142.77 65.83,142.77 65.67,142.93 65.67,143.99 65.57,144.09 65.28,144.09 65.21,144.01 65.21,142.9 65.08,142.77 64.9,142.77 64.72,142.96 64.72,143.94 64.64,144.03 64.39,144.03 64.29,143.93 64.29,143.76 64.08,143.55 62.75,143.55 61.71,144.59 58.29,144.59 55.58,141.88 53.23,141.88 52.4,141.05 52.23,140.88 49.07,140.88 48.95,140.76 48.95,140.58 49.11,140.41 49.42,140.41 49.53,140.29 v1(49.53,140.13)
  BOTTOM w0.079: v2(94.41,154.97) 94.23,154.78 94.23,154.61 94.33,154.51 98.96,154.51 99.42,154.05 100.15,154.05 U1.AA37
  BOTTOM w0.14: JDIM1.127 51.94,140.07 51.46,139.6 50.07,139.6 v1(49.53,140.13)
M_A_A7: length 73.6
  IN4 w0.102: v1(48.47,142.74) 48.47,143.01 48.55,143.1 48.82,143.1 49.05,142.87 49.25,142.87 49.49,143.1 51.31,143.1 53.11,144.9 55.44,144.9 57.17,146.63 63.53,146.63 63.87,146.97 68.52,146.97 73.52,151.97 73.52,152.12 73.12,152.51 73.12,152.66 73.26,152.8 73.4,152.8 73.8,152.4 73.95,152.4 74.09,152.55 74.09,152.69 73.69,153.09 73.69,153.23 73.83,153.38 73.98,153.38 74.38,152.98 74.52,152.98 74.67,153.12 74.67,153.27 74.27,153.66 74.27,153.81 74.41,153.95 74.55,153.95 74.95,153.55 75.1,153.55 75.24,153.7 75.24,153.84 74.84,154.24 74.84,154.38 74.98,154.53 75.13,154.53 75.53,154.13 75.67,154.13 75.82,154.27 75.82,154.42 75.42,154.82 75.42,154.96 75.56,155.1 75.7,155.1 76.1,154.7 76.25,154.7 76.39,154.85 76.39,154.99 75.99,155.39 75.99,155.53 76.13,155.68 76.28,155.68 76.68,155.28 76.82,155.28 76.97,155.42 76.97,155.57 76.57,155.97 76.57,156.11 76.71,156.25 76.85,156.25 77.25,155.85 77.4,155.85 78.27,156.72 90.67,156.72 90.94,156.46 93.04,156.46 93.6,155.9 95,155.9 95.48,155.41 96.1,155.41 v2(96.5,155.01)
  BOTTOM w0.079: v2(96.5,155.01) 96.83,154.68 99.03,154.68 99.48,154.22 99.92,154.22 100.09,154.39 100.32,154.39 100.52,154.31 100.71,154.31 U1.AA36
  BOTTOM w0.14: v1(48.47,142.74) 48.47,142.14 47.76,141.43 46.55,141.43 46.44,141.32 JDIM1.122
M_A_A8: length 72.9
  IN4 w0.102: v1(51.13,140.03) 53.21,140.03 53.3,140.11 55.07,140.11 57.2,142.24 59.34,142.24 59.83,142.74 63.79,142.74 64.57,141.96 68.96,141.96 76.25,149.25 76.25,150.68 79.45,153.88 91.26,153.88 91.34,153.8 v2(92.75,153.8)
  BOTTOM w0.079: U1.AB34 101.6,153.74 101.1,153.74 101.05,153.72 100.77,153.72 100.69,153.74 100.45,153.74 100.39,153.72 99.28,153.72 98.84,154.16 93.99,154.16
  BOTTOM w0.14: v1(51.13,140.03) 51.68,140.57 JDIM1.125 ; 93.99,154.16 93.76,154.38 91.51,154.38 91.35,154.55 91.35,156.39 91.48,156.53 92.49,156.53 92.67,156.72 92.67,157.09 92.5,157.27 90.8,157.27 90.62,157.08 90.62,154.14 90.99,153.76 92.71,153.76 v2(92.75,153.8)
M_A_A9: length 72.6
  IN4 w0.102: v1(95.2,154.94) 95.2,155.27 94.82,155.64 93.47,155.64 92.99,156.12 90.91,156.12 90.72,156.32 78.44,156.32 69.28,147.17 69.28,146.79 69.72,146.35 69.72,146.17 69.32,145.78 68.98,145.78 68.88,145.88 68.88,146.43 68.75,146.56 68.46,146.56 68.4,146.51 68.4,145.91 68.27,145.78 68.09,145.78 67.99,145.88 67.99,146.42 67.85,146.56 67.64,146.56 67.55,146.48 67.55,145.9 67.43,145.78 67.23,145.78 67.15,145.86 67.15,146.48 67.06,146.56 65.79,146.56 65.68,146.46 65.68,146.32 65.58,146.22 65.38,146.22 65.28,146.32 65.28,146.46 65.18,146.56 64.97,146.56 64.87,146.46 64.87,146.33 64.76,146.22 64.56,146.22 64.46,146.31 64.46,146.46 64.36,146.56 64.04,146.56 63.7,146.22 57.39,146.22 55.66,144.5 53.28,144.5 51.47,142.69 49.65,142.69 49.54,142.58 49.54,142.5 v1(49.89,142.15)
  BOTTOM w0.079: 96.28,155.6 98.49,155.6 98.81,155.27 99.92,155.27 100.09,155.1 100.34,155.1 100.51,155.17 100.7,155.17 U1.W36
  BOTTOM w0.14: 96.28,155.6 95.86,156.02 93.81,156.02 93.68,155.88 93.68,155.57 93.83,155.42 95.09,155.42 95.2,155.31 v1(95.2,154.94) ; v1(49.89,142.15) 49.89,141.93 49.63,141.67 49.63,141.48 49.78,141.33 51.34,141.33 51.59,141.57 JDIM1.121
M_A_A10: length 71.4
  IN4 w0.102: v2(103.61,154.74) 103.21,155.14 102.75,155.14 102.36,154.75 102.36,154.52 100.47,152.62 100.47,150.84 99.61,149.98 98.37,149.98 98.19,150.16 94.06,150.16 93.45,149.55 89.92,149.55 89.55,149.18 82.79,149.18 68.42,134.82 63.31,134.82 63.2,134.92 63.2,135.09 63.08,135.21 62.88,135.21 62.8,135.13 62.8,134.92 62.7,134.82 62.49,134.82 62.39,134.92 62.39,135.15 62.28,135.26 62.08,135.26 61.98,135.16 61.98,134.92 61.88,134.82 60.62,134.82 60.49,134.68 58,134.68 57.79,134.9 51.97,134.9 51.49,134.41 47.73,134.41 v1(47.45,134.13)
  BOTTOM w0.102: v2(103.61,154.74) 103.61,154.63 U1.Y31
  BOTTOM w0.14: v1(47.45,134.13) 46.43,134.13 45.62,133.32 JDIM1.146
M_A_A11: length 69.7
  IN4 w0.102: v1(45.91,141.94) 45.91,142.36 46.18,142.64 46.61,142.64 46.72,142.74 46.72,142.93 46.6,143.05 45.55,143.05 45.45,143.15 45.45,143.38 45.58,143.51 51.14,143.51 52.94,145.31 55.27,145.31 57.65,147.68 62.56,147.68 62.76,147.88 65.7,147.88 66.04,148.22 67.43,148.22 67.91,147.73 68.7,147.73 72.84,151.87 72.84,152.02 72.44,152.42 72.44,152.56 76.54,156.66 77.63,156.66 78.1,157.13 90.8,157.13 91.14,156.79 93.35,156.79 93.98,156.15 95.12,156.15 95.56,155.72 96.45,155.72 97.11,155.06 v2(97.11,155.04)
  BOTTOM w0.079: v2(97.11,155.04) 97.11,155.06 97.47,155.42 98.43,155.42 98.74,155.11 99.85,155.11 100.02,154.93 100.37,154.93 100.54,155 100.94,155 101.04,155.1 101.93,155.1 U1.W34
  BOTTOM w0.14: v1(45.91,141.94) 45.79,141.82 JDIM1.120
M_A_A12: length 72.2
  IN4 w0.102: v1(51.21,142.15) 51.5,142.15 53.44,144.09 55.89,144.09 57.61,145.81 65.61,145.81 66.06,145.37 69.49,145.37 70.37,146.24 70.37,146.42 69.81,146.98 69.81,147.12 69.96,147.26 70.1,147.26 70.65,146.71 70.8,146.71 70.94,146.85 70.94,147 70.39,147.55 70.39,147.7 70.53,147.84 70.68,147.84 71.23,147.29 71.37,147.29 71.52,147.43 71.52,147.57 70.96,148.13 70.96,148.27 71.11,148.41 71.25,148.41 71.8,147.86 71.95,147.86 72.09,148 72.09,148.15 71.54,148.7 71.54,148.85 71.68,148.99 71.83,148.99 72.38,148.44 72.52,148.44 72.67,148.58 72.67,148.72 72.11,149.28 72.11,149.42 72.26,149.56 72.4,149.56 72.95,149.01 73.1,149.01 73.24,149.15 73.24,149.3 72.69,149.85 72.69,150 73.03,150.34 73.38,150.34 74.22,151.18 74.22,151.53 78.61,155.91 90.72,155.91 90.84,155.79 92.81,155.79 93.22,155.39 94.59,155.39 94.79,155.19 94.79,154.66 94.97,154.49 95.36,154.49 95.52,154.33 96.5,154.33 96.71,154.54 97.46,154.54 98.13,153.87 98.26,153.87 98.5,154.11 98.5,154.24 98.07,154.68 98.07,154.77 v2(98.33,155.03)
  BOTTOM w0.079: v2(98.33,155.03) 98.51,154.84 99.1,154.84 99.55,154.39 99.85,154.39 100.02,154.56 100.4,154.56 100.59,154.48 101.22,154.48 101.29,154.4 101.68,154.4 101.94,154.14 U1.AA34
  BOTTOM w0.14: v1(51.21,142.15) 51.29,142.07 JDIM1.119
M_A_A13: length 73
  IN4 w0.102: v1(46.75,130.32) 46.89,130.32 48.2,131.63 54.88,131.63 55.18,131.93 56.55,131.93 56.85,131.63 59.15,131.63 59.26,131.52 59.85,131.52 59.95,131.41 59.95,131.09 60.05,130.98 60.25,130.98 60.36,131.09 60.36,131.41 60.46,131.52 60.66,131.52 60.76,131.41 60.76,131.09 60.86,130.98 61.07,130.98 61.17,131.09 61.17,131.41 61.27,131.52 63.66,131.52 63.76,131.41 63.76,131.23 63.86,131.13 64.06,131.13 64.17,131.23 64.17,131.41 64.27,131.52 64.47,131.52 64.57,131.41 64.57,131.23 64.67,131.13 64.88,131.13 64.98,131.23 64.98,131.41 65.08,131.52 65.81,131.52 66.21,131.92 68.41,131.92 83.63,147.15 88.17,147.15 88.38,147.35 90.26,147.35 91.06,148.15 97.84,148.15 98.07,148.38 98.58,148.38 99.04,148.84 99.95,148.84 101.86,150.75 101.86,151.31 102.49,151.93 102.49,152.49 102.77,152.77 103.05,152.77 103.6,152.22 v2(103.6,152.07)
  BOTTOM w0.102: v2(103.6,152.07) 103.23,152.44 U1.AC32
  BOTTOM w0.14: v1(46.75,130.32) JDIM1.158
M_A_ACT#: length 72.1
  IN4 w0.102: v2(99.25,156.2) 99.31,156.26 99.31,156.82 98.9,157.24 95.05,157.24 94.18,158.11 91.9,158.11 91.25,158.76 76.34,158.76 67.96,150.38 67.79,150.38 67.65,150.52 67.65,150.99 67.55,151.09 67.32,151.09 67.22,150.99 67.22,150.5 67.09,150.38 65.32,150.38 65.22,150.48 65.22,150.98 65.11,151.09 64.91,151.09 64.81,150.99 64.81,150.48 64.71,150.38 64.13,150.38 63.77,150.02 59.87,150.02 59.42,149.57 59.19,149.57 58.79,149.97 57.64,149.97 57.34,149.67 57.15,149.67 56.8,150.02 56.51,150.02 56.37,149.88 56.37,149.73 56.81,149.29 56.81,149.14 56.66,148.99 56.51,148.99 55.94,149.56 55.83,149.56 55.63,149.36 55.63,149.22 56.18,148.67 56.18,148.51 55.97,148.31 55.81,148.31 55.31,148.81 53.89,148.81 53.49,148.42 53.49,147.54 53.41,147.46 53.15,147.46 53.07,147.54 53.07,147.94 52.91,148.1 52.33,148.1 51.96,147.73 50.77,147.73 v1(48.05,145.01)
  BOTTOM w0.079: v2(99.25,156.2) 99.56,156.51 99.98,156.51 100.21,156.28 100.94,156.28 U1.V35
  BOTTOM w0.14: v1(48.05,145.01) 45.69,143.32 JDIM1.114
M_A_ALERT#: length 69
  IN4 w0.102: v2(93.15,154.99) 93.12,154.99 92.6,155.51 78.77,155.51 74.63,151.36 74.63,149.93 74.34,149.64 74.19,149.64 73.81,150.03 73.64,150.03 73.5,149.88 73.5,149.76 73.91,149.35 73.91,149.21 69.29,144.6 69.1,144.6 68.8,144.9 64.75,144.9 64.65,145 64.65,145.18 64.55,145.28 64.35,145.28 64.25,145.18 64.25,145 64.14,144.9 63.8,144.9 63.67,144.77 63.67,144.5 63.54,144.36 63.09,144.36 62.99,144.47 62.99,145.27 62.85,145.41 57.87,145.41 55.74,143.28 53.21,143.28 51.62,141.69 48.57,141.69 48.42,141.84 48.42,142.15 48.3,142.26 48.1,142.26 48,142.16 48,141.74 47.94,141.69 47.78,141.69 v1(47.23,142.24)
  BOTTOM w0.079: U1.W37 100.15,155.44 98.88,155.44 98.56,155.77 96.58,155.77 95.91,156.44 93.47,156.44 93.15,156.11 v2(93.15,154.99)
  BOTTOM w0.14: JDIM1.116 46.65,142.82 v1(47.23,142.24)
M_A_BG#0: length 72.3
  IN4 w0.102: v2(97.07,156.39) 97.45,156.02 98.71,156.02 99.51,155.21 99.51,155.1 99.32,154.91 99.16,154.91 98.56,155.51 97.12,155.51 96.62,156.02 95.64,156.02 95.25,156.4 94.23,156.4 93.52,157.12 91.3,157.12 90.88,157.54 77.56,157.54 77.46,157.43 77.46,157.12 77.4,157.07 77.12,157.07 77.04,157.15 77.04,157.34 76.92,157.45 76.76,157.45 72.04,152.73 72.04,152.25 72.27,152.02 72.27,151.87 68.53,148.14 68.08,148.14 67.49,148.74 65.98,148.74 65.53,148.29 62.59,148.29 62.4,148.09 57.48,148.09 55.76,146.36 55.3,146.36 55.11,146.56 54.23,146.56 53.39,145.71 52.77,145.71 52.12,145.06 51.98,145.06 51.84,145.2 51.7,145.2 51.55,145.06 51.55,144.91 51.69,144.78 51.69,144.63 51.46,144.41 51.32,144.41 51.17,144.55 51.02,144.55 50.88,144.41 50.88,143.97 50.83,143.91 v1(49.23,143.91)
  BOTTOM w0.079: v2(97.07,156.39) 97.36,156.1 98.7,156.1 98.76,156.04 99.02,155.78 100.36,155.78 100.45,155.75 100.67,155.75 100.77,155.78 101.02,155.78 101.14,155.75 101.6,155.75 U1.V34
  BOTTOM w0.14: v1(49.23,143.91) 50.07,143.07 JDIM1.115
M_A_BG#1: length 72.5
  IN4 w0.102: v2(96.47,156.44) 96.25,156.66 96.01,156.66 95.79,156.44 95.6,156.44 95.35,156.68 94.49,156.68 93.73,157.45 91.48,157.45 90.99,157.94 76.68,157.94 71.3,152.57 71.3,152.41 71.67,152.04 71.67,151.85 71.38,151.57 71.24,151.57 70.84,151.97 70.7,151.97 70.55,151.82 70.55,151.68 70.95,151.28 70.95,151.14 70.81,150.99 70.67,150.99 70.27,151.39 70.12,151.39 69.98,151.25 69.98,151.1 70.38,150.7 70.38,150.56 70.23,150.42 70.09,150.42 69.69,150.82 69.55,150.82 69.4,150.67 69.4,150.53 69.8,150.13 69.8,149.98 68.37,148.55 68.25,148.55 67.23,149.56 65.95,149.56 65.08,148.69 62.42,148.69 62.23,148.5 57.31,148.5 55.78,146.97 54.07,146.97 53.22,146.12 52.6,146.12 52.5,146.22 52.5,146.57 52.42,146.65 52.11,146.65 52.03,146.56 52.03,145.87 51.91,145.75 51,145.75 50.87,145.62 50.6,145.62 50.24,145.98 49.59,145.98 49.11,145.5 49.11,145.22 49.23,145.1 49.23,144.94 49.04,144.75 49.04,144.63 49.2,144.47 49.39,144.47 49.7,144.79 49.7,145.38 49.82,145.49 49.99,145.49 50.58,144.91 v1(50.58,144.73)
  BOTTOM w0.079: U1.W35 101.31,155.58 101.12,155.58 101,155.61 100.8,155.61 100.69,155.58 100.42,155.58 100.33,155.61 98.95,155.61 98.64,155.92 98.63,155.93 96.74,155.93 96.47,156.2 v2(96.47,156.44)
  BOTTOM w0.14: v1(50.58,144.73) 51.73,143.57 JDIM1.113
M_A_BS#0: length 70.4
  IN4 w0.102: v2(102.85,155.66) 101.84,155.12 101.59,154.88 101.59,154.03 100.25,152.7 100.25,150.93 99.51,150.19 98.5,150.19 98.25,150.44 93.93,150.44 93.32,149.83 89.69,149.83 89.45,149.59 82.62,149.59 68.74,135.71 59.96,135.71 58.76,135.09 58.17,135.09 57.95,135.3 51.8,135.3 51.32,134.82 47.45,134.82 46.68,134.05 v1(46.18,133.17)
  BOTTOM w0.102: U1.W32 103.23,155.29 v2(102.85,155.66)
  BOTTOM w0.14: JDIM1.150 45.54,132.32 45.68,132.47 v1(46.18,133.17)
M_A_BS#1: length 73.2
  IN4 w0.102: v2(103.63,153.92) 103.63,154.21 103.54,154.3 102.75,154.3 100.95,152.5 100.95,150.7 99.8,149.55 98.74,149.55 98.22,149.03 97.58,149.03 97.54,148.99 90.37,148.99 89.75,148.37 83.12,148.37 67.9,133.14 65.91,133.14 65.79,133.26 65.79,133.9 65.72,133.97 65.37,133.97 65.25,133.86 65.25,132.88 65.11,132.74 64.82,132.74 64.71,132.85 64.71,133.86 64.59,133.97 64.36,133.97 64.28,133.89 64.28,132.88 64.14,132.74 63.93,132.74 63.72,132.95 63.72,133.92 63.64,134 63.28,134 63.2,133.93 63.2,133.45 63.1,133.35 59.49,133.35 58.97,133.87 57.44,133.87 57.17,133.6 51.76,133.6 51.72,133.56 v1(50.13,133.56)
  BOTTOM w0.102: U1.AB31 103.88,153.67 v2(103.63,153.92)
  BOTTOM w0.14: v1(50.13,133.56) 50.41,133.84 51.67,133.84 51.93,133.57 JDIM1.145
M_A_CAS#: length 72.2
  IN4 w0.102: v1(46.66,131.73) 47.14,132.21 47.14,132.39 47.24,132.5 47.48,132.5 47.58,132.4 47.58,132.14 47.68,132.04 49.6,132.04 50.72,133.15 55.78,133.15 55.88,133.05 55.88,132.84 55.99,132.74 56.19,132.74 56.29,132.84 56.29,133.05 56.39,133.15 56.6,133.15 56.7,133.05 56.7,132.84 56.8,132.74 57,132.74 57.1,132.84 57.1,133.05 57.21,133.15 57.57,133.15 57.78,132.94 63.15,132.94 63.76,132.33 65.47,132.33 65.88,132.74 68.07,132.74 83.29,147.96 89.85,147.96 90.6,148.71 97.72,148.71 97.82,148.81 98.33,148.81 98.84,149.32 99.86,149.32 101.2,150.66 101.2,152.32 102.8,153.92 v2(102.95,153.92)
  BOTTOM w0.102: v2(102.95,153.92) 103.23,153.64 U1.AB32
  BOTTOM w0.14: JDIM1.156 46.15,130.82 46.66,131.34 v1(46.66,131.73)
M_A_CB0: length 1.9
  TOP w0.114: R233.2 45.95,149.02 v1(45.91,149.06)
  BOTTOM w0.114: v1(45.91,149.06) 45.67,148.82 JDIM1.92
M_A_CB1: length 3.6
  TOP w0.114: v1(50.23,149.53) 49.79,149.97 R234.2
  BOTTOM w0.114: JDIM1.91 50.68,149.07 v1(50.23,149.53)
M_A_CB2: length 2
  TOP w0.114: R235.2 51.58,146.6 v1(51.55,146.57)
  BOTTOM w0.114: JDIM1.101 v1(51.55,146.57)
M_A_CB3: length 3.4
  TOP w0.114: R236.2 50.96,145.85 v1(50.68,146.12)
  BOTTOM w0.114: v1(50.68,146.12) 50.71,146.09 51.3,146.09 51.83,145.57 JDIM1.105
M_A_CB4: length 1.8
  TOP w0.114: v1(45.91,149.82) 45.95,149.78 R237.2
  BOTTOM w0.114: JDIM1.88 v1(45.91,149.82)
M_A_CB5: length 3.8
  TOP w0.114: R238.2 49.84,149.03 50.5,149.03 50.89,149.42 v1(50.89,149.59)
  BOTTOM w0.114: v1(50.89,149.59) 51.38,150.07 JDIM1.87
M_A_CB6: length 2.4
  TOP w0.114: R239.2 46.49,146.79 v1(46.46,146.82)
  BOTTOM w0.114: JDIM1.100 v1(46.46,146.82)
M_A_CB7: length 2.4
  TOP w0.114: R240.2 46.48,145.99 v1(46.46,145.98)
  BOTTOM w0.114: v1(46.46,145.98) 45.78,145.98 45.63,145.82 JDIM1.104
M_A_CKE0: length 71.7
  IN4 w0.102: v2(98.05,156.55) 97.64,156.96 94.79,156.96 93.98,157.78 91.67,157.78 91.09,158.35 76.51,158.35 68.89,150.74 68.89,150.46 69.23,150.13 69.23,149.98 69,149.76 68.91,149.76 68.49,150.18 68.33,150.18 68.18,150.02 68.18,149.86 68.51,149.53 68.51,149.35 68.37,149.22 68.16,149.22 67.4,149.97 65.2,149.97 64.99,149.77 64.99,149.18 64.91,149.1 64.51,149.1 64.4,149.2 64.4,149.65 64.29,149.76 64.09,149.76 64,149.67 64,149.2 63.9,149.1 63.69,149.1 63.59,149.2 63.59,149.51 63.49,149.62 63.29,149.62 63.19,149.51 63.19,149.2 63.08,149.1 62.88,149.1 62.78,149.2 62.78,149.51 62.68,149.62 62.47,149.62 62.37,149.51 62.37,149.2 62.27,149.1 62.07,149.1 61.97,149.2 61.97,149.51 61.86,149.62 61.66,149.62 61.56,149.51 61.56,148.97 61.49,148.9 61.23,148.9 61.15,148.98 61.15,149.51 61.05,149.62 60.85,149.62 60.75,149.51 60.75,148.97 60.68,148.9 60.43,148.9 60.34,149 60.34,149.51 60.24,149.62 60.04,149.62 59.93,149.51 59.93,149.01 59.83,148.9 59.29,148.9 59.19,149 58.63,149.56 57.8,149.56 56.01,147.77 55.78,147.77 55.14,148.41 54.06,148.41 53.9,148.25 53.9,147.37 53.58,147.05 50.72,147.05 v1(50.06,146.39)
  BOTTOM w0.079: U1.U36 100.63,156.91 100.33,156.91 99.98,157.26 99.95,157.29 99.57,157.29 99.23,156.96 98.29,156.96 98.05,156.72 v2(98.05,156.55)
  BOTTOM w0.14: JDIM1.109 51.62,144.57 51.43,144.77 51.22,144.77 50.06,145.93 v1(50.06,146.39)
M_A_CKE1: length 70.9
  IN4 w0.102: v1(46.65,144.86) 47.32,144.86 48.27,145.81 48.27,146.25 48.17,146.35 47.15,146.35 47.03,146.48 47.03,146.78 47.15,146.91 49.29,146.91 49.44,147.05 49.44,147.35 49.31,147.48 47.11,147.48 46.98,147.61 46.98,147.81 47.12,147.94 50.4,147.94 50.6,148.14 51.79,148.14 52.16,148.51 52.87,148.51 54.48,150.12 56.03,150.12 56.34,150.43 63.6,150.43 64.67,151.49 68.5,151.49 76.17,159.16 91.37,159.16 92.1,158.44 94.37,158.44 95.28,157.52 99.19,157.52 v2(99.77,156.94)
  BOTTOM w0.079: v2(99.77,156.94) 99.95,156.94 U1.U37
  BOTTOM w0.14: v1(46.65,144.86) 46.12,144.32 JDIM1.110
M_A_CLKN0: length 71.3
  IN4 w0.102: v2(102.8,156.5) 103.07,156.5 103.17,156.6 103.17,156.81 103.05,156.94 102.51,156.94 101.09,155.52 101.09,154.37 99.26,152.54 99.26,151.74 98.53,151 93.55,151 93.15,150.6 82.2,150.6 70.28,138.68 63.41,138.68 62.95,138.46 60.92,138.46 60.02,137.56 58.57,137.56 56.21,136.32 49.43,136.32 49.3,136.2 49.3,135.83 49.37,135.75 v1(49.8,135.75)
  BOTTOM w0.102: U1.V32 103.23,156.32 103.05,156.5 v2(102.8,156.5) ; v1(49.8,135.75) 49.31,135.75 49.11,135.96 49.11,136.84 49.64,137.37 51.66,137.37 51.95,137.07 JDIM1.139
M_A_CLKN1: length 70.1
  IN4 w0.102: v2(102.94,157.52) 103.1,157.69 103.1,157.78 102.98,157.91 101.99,157.91 101.54,157.46 100.51,155.68 100.51,154.57 98.78,152.84 98.78,151.95 98.27,151.44 81.89,151.44 69.97,139.52 61.17,139.52 60.47,139.16 59.73,138.43 58.48,138.43 55.98,137.2 55.67,137.14 48.36,137.14 48.24,137.02 47.67,137.02 47.26,136.61 v1(47.26,136.35)
  BOTTOM w0.102: U1.T32 103.23,157.23 v2(102.94,157.52) ; JDIM1.140 45.62,136.82 45.73,136.94 46.96,136.94 47.26,136.63 v1(47.26,136.35)
M_A_CLKP0: length 71.3
  IN4 w0.102: v1(48.53,135.75) 48.57,135.75 49.34,136.53 56.16,136.53 58.52,137.77 59.94,137.77 60.83,138.66 62.91,138.66 63.37,138.88 70.19,138.88 82.11,150.8 93.07,150.8 93.47,151.2 98.44,151.2 99.06,151.82 99.06,152.63 100.89,154.46 100.89,155.6 102.43,157.14 103.13,157.14 103.37,156.9 103.37,156.73 v2(103.55,156.55)
  BOTTOM w0.102: JDIM1.137 49.56,137.57 48.91,136.92 48.91,135.93 48.73,135.75 v1(48.53,135.75) ; U1.V31 103.88,156.22 v2(103.55,156.55)
M_A_CLKP1: length 70.1
  IN4 w0.102: v2(103.58,157.52) 103.52,157.52 103.3,157.73 103.3,157.87 103.06,158.11 101.9,158.11 101.38,157.58 100.31,155.73 100.31,154.65 98.57,152.92 98.57,152.03 98.19,151.64 81.8,151.64 69.89,139.73 61.12,139.73 60.35,139.33 59.65,138.63 58.43,138.63 55.91,137.4 55.65,137.34 48.27,137.34 48.15,137.22 47.67,137.22 v1(47.26,137.62)
  BOTTOM w0.102: v1(47.26,137.62) 46.78,137.14 45.76,137.14 45.57,137.32 JDIM1.138 ; U1.T31 103.88,157.22 v2(103.58,157.52)
M_A_CS#0: length 73.8
  IN4 w0.102: v2(102.97,151.12) 102.81,151.12 101.53,149.84 101.53,148.93 101.04,148.43 101.04,145.45 100.96,145.38 100.47,145.38 100.29,145.55 100.29,146.43 99.42,147.3 98.93,147.3 98.61,146.98 90.91,146.98 90.58,146.66 88.59,146.66 88.27,146.33 83.97,146.33 67.95,130.32 65.29,130.32 65.15,130.17 53.86,130.17 53.22,130.82 50.38,130.82 50.2,130.64 49.14,130.64 v1(48.67,131.1)
  BOTTOM w0.102: v2(102.97,151.12) 103.23,151.39 U1.AE32
  BOTTOM w0.14: v1(48.67,131.1) 48.67,131.28 50.47,133.08 51.38,133.08 51.89,132.57 JDIM1.149
M_A_CS#1: length 73.5
  IN4 w0.102: v1(51.39,129.97) 52.91,129.97 53.52,129.36 55.52,129.36 56.13,128.75 64.87,128.75 65.63,129.51 68.29,129.51 84.3,145.52 88.64,145.52 89.16,146.05 91.14,146.05 91.46,146.36 97.8,146.36 98.15,146.01 99.07,146.01 99.45,145.63 99.45,143.18 99.57,143.06 99.85,143.06 99.94,143.14 99.94,143.66 100.05,143.77 100.25,143.77 100.34,143.67 100.34,143.17 100.46,143.06 100.66,143.06 100.75,143.14 100.75,143.66 100.86,143.77 101.06,143.77 101.16,143.67 101.16,143.27 101.29,143.14 102.27,143.14 102.39,143.26 102.39,148.62 102.53,148.76 102.53,149.83 v2(102.9,150.2)
  BOTTOM w0.102: v2(102.9,150.2) 102.9,150.24 103.23,150.57 U1.AF32
  BOTTOM w0.14: v1(51.39,129.97) 51.39,130.17 51.79,130.57 JDIM1.157
M_A_DIM0_ODT0: length 73.6
  IN4 w0.102: v2(104.27,151.12) 104.27,151.52 104.19,151.6 102.48,151.6 102.17,151.28 102.17,150.77 101.23,149.83 101.23,149.69 100.69,149.16 100.69,147.2 100.52,147.02 100.3,147.02 100.14,147.18 100.14,148.27 100.04,148.38 99.72,148.38 99.62,148.27 99.62,147.84 99.51,147.74 98.96,147.74 98.51,147.29 91.54,147.29 91.24,147.59 91.01,147.59 90.49,147.07 88.57,147.07 88.24,146.74 83.8,146.74 67.78,130.73 65.13,130.73 64.98,130.58 57.11,130.58 57.01,130.68 57.01,131.04 56.91,131.14 56.71,131.14 56.6,131.03 56.6,130.7 56.48,130.58 56.28,130.58 56.19,130.66 56.19,131.42 56.09,131.52 55.89,131.52 55.79,131.42 55.79,130.68 55.68,130.58 54.03,130.58 53.38,131.22 50.21,131.22 v1(50.03,131.04)
  BOTTOM w0.102: U1.AE31 104.1,151.62 104.27,151.45 v2(104.27,151.12)
  BOTTOM w0.14: JDIM1.155 50.06,131.07 v1(50.03,131.04)
M_A_DIM0_ODT1: length 73.6
  IN4 w0.102: v1(49.97,129.87) 50.02,129.87 50.56,130.41 53.05,130.41 53.69,129.77 55.69,129.77 56.3,129.16 64.7,129.16 65.46,129.91 68.12,129.91 84.13,145.93 88.54,145.93 88.96,146.35 90.78,146.35 91.11,146.68 98.12,146.68 98.41,146.39 99.38,146.39 99.85,145.92 99.85,144.32 100.02,144.14 101.23,144.14 101.42,144.33 101.42,145.67 101.56,145.81 101.7,145.81 101.81,145.91 101.81,146.21 101.71,146.31 101.54,146.31 101.42,146.43 101.42,148.29 102.32,149.2 102.32,150.22 102.71,150.61 103.11,150.61 v2(103.62,151.12)
  BOTTOM w0.102: v2(103.62,151.12) 103.88,150.87 U1.AF31
  BOTTOM w0.14: v1(49.97,129.87) 50.41,129.44 51.72,129.44 51.86,129.57 JDIM1.161
M_A_DQ0: length 70.8
  IN4 w0.089: v2(106.55,167.24) 106.04,167.24 102.67,170.61 102.67,171.09 101.79,171.97 95.83,171.97 93.96,173.84 65.44,173.84 65.35,173.75 65.35,172.93 65.26,172.84 65,172.84 64.9,172.94 64.9,173.75 64.82,173.84 64.55,173.84 64.46,173.75 64.46,172.8 64.37,172.71 64.1,172.71 64.02,172.8 64.02,173.75 63.93,173.84 63.66,173.84 63.57,173.75 63.57,172.76 63.48,172.67 63.22,172.67 63.13,172.76 63.13,173.75 63.04,173.84 62.77,173.84 62.68,173.75 62.68,173.53 62.59,173.44 62.33,173.44 62.24,173.53 62.24,173.75 62.15,173.84 60.21,173.84 58.82,172.46 57.42,172.46 56.87,171.91 53.8,171.91 52.82,170.93 52.47,170.93 52.19,170.66 51.88,170.66 51.61,170.93 51.11,170.93 50.96,170.79 v1(50.96,170.55)
  BOTTOM w0.079: U1.A26 107.24,165.82 107.24,166.6 106.59,167.24 v2(106.55,167.24)
  BOTTOM w0.114: JDIM1.7 51.44,170.07 v1(50.96,170.55)
M_A_DQ1: length 71.9
  IN4 w0.089: v1(47.11,170.35) 47.8,170.35 48.12,170.03 48.34,170.03 48.86,170.55 49,170.55 50.06,171.62 51.44,171.62 52.42,172.59 56.59,172.59 57.14,173.14 58.54,173.14 59.93,174.53 94.24,174.53 96.11,172.66 102.07,172.66 105.36,169.37 v2(105.36,169.16)
  BOTTOM w0.079: v2(105.36,169.16) 105.56,168.96 105.56,168.19 105.77,167.98 105.77,166.68 105.98,166.47 105.98,166.24 106.27,165.95 106.27,165.6 106.24,165.52 106.24,165.28 106.27,165.21 106.27,164.99 106.24,164.83 106.24,164.39 106.22,164.36 106.22,163.94 106.33,163.83 107.11,163.83 U1.D26
  BOTTOM w0.114: v1(47.11,170.35) 46.58,169.82 JDIM1.8
M_A_DQ2: length 73.6
  IN4 w0.089: v2(92.23,171.8) 92.09,171.95 70.73,171.95 70.64,171.86 70.64,171.39 70.55,171.31 70.28,171.31 70.2,171.39 70.2,171.86 70.11,171.95 69.84,171.95 69.75,171.86 69.75,170.51 69.66,170.42 69.4,170.42 69.31,170.51 69.31,171.86 69.22,171.95 68.95,171.95 68.86,171.86 68.86,169.8 68.77,169.71 68.51,169.71 68.42,169.8 68.42,171.61 68.33,171.7 68.06,171.7 67.97,171.61 67.97,169.8 67.88,169.71 61.52,169.71 60.98,169.17 57.39,169.17 57.12,168.9 53.57,168.9 52.37,167.7 52.24,167.7 52.24,167.7 51.19,167.7 v1(50.76,167.27)
  BOTTOM w0.079: U1.D28 105.85,163.94 105.58,164.2 105.58,164.94 105.52,165.01 105.52,165.35 105.1,166.4 105.1,167.54 104.29,168.34
  BOTTOM w0.114: v2(92.23,171.8) 92.23,171.22 93.86,169.59 98.37,169.59 99.3,168.66 103.98,168.66 104.29,168.34 ; JDIM1.17 51.84,167.57 51.7,167.71 51.2,167.71 v1(50.76,167.27)
M_A_DQ3: length 73.1
  IN4 w0.089: v1(46.59,167.34) 47.63,168.39 52.08,168.39 53.76,170.07 57.4,170.07 57.96,170.62 60.21,170.62 60.44,170.39 65.32,170.39 65.44,170.52 65.44,171.28 65.54,171.38 65.83,171.38 65.91,171.3 65.91,170.5 66.01,170.39 66.26,170.39 66.37,170.5 66.37,172.24 66.52,172.39 66.71,172.39 66.85,172.26 66.85,172.04 66.95,171.94 67.17,171.94 67.29,172.05 67.29,172.52 67.41,172.64 93.46,172.64 v2(94.46,171.63)
  BOTTOM w0.079: U1.C28 106.08,164.66 106.08,164.85 106.1,165 106.1,165.18 106.08,165.25 106.08,165.55 106.1,165.63 106.1,165.88 105.81,166.17 105.81,166.4 105.6,166.61 105.6,167.9 105.34,168.16 105.34,168.61 105.22,168.73
  BOTTOM w0.114: v2(94.46,171.63) 95.8,171.63 96.66,170.78 99.04,170.78 99.95,169.87 104.08,169.87 105.22,168.73 ; JDIM1.16 46.11,167.82 v1(46.59,167.34)
M_A_DQ4: length 69.5
  IN4 w0.089: v2(107.19,167.31) 106.94,167.56 106.94,167.88 106.6,168.22 105.6,168.22 103.01,170.81 103.01,171.23 101.93,172.32 95.97,172.32 94.1,174.19 60.07,174.19 58.68,172.8 57.28,172.8 56.73,172.25 52.96,172.25 52.8,172.09 52.8,171.4 52.68,171.28 52.49,171.28 52.4,171.36 52.4,171.66 52.31,171.75 52.06,171.75 51.98,171.66 51.98,171.39 51.86,171.28 50.21,171.28 49.67,170.73 v1(49.67,170.52)
  BOTTOM w0.079: U1.B26 107.33,165.27 107.33,165.47 107.4,165.62 107.4,167.09 v2(107.19,167.31)
  BOTTOM w0.114: v1(49.67,170.52) 49.67,170.72 50.02,171.07 JDIM1.3
M_A_DQ5: length 71.3
  IN4 w0.089: v1(48.4,170.75) 48.66,171.02 48.97,171.02 49.92,171.96 50.38,171.96 51.19,172.42 51.71,172.94 56.45,172.94 57,173.49 58.4,173.49 59.78,174.87 94.38,174.87 96.25,173 102.22,173 106,169.22 106.58,169.22 107.03,168.76 v2(107.03,168.32)
  BOTTOM w0.079: U1.C26 107.36,164.65 107.36,164.82 107.5,164.96 107.5,165.43 107.57,165.58 107.57,167.78 v2(107.03,168.32)
  BOTTOM w0.114: v1(48.4,170.75) 48.33,170.82 JDIM1.4
M_A_DQ6: length 72.3
  IN4 w0.089: v1(47.91,167.35) 47.91,167.14 47.54,166.77 46.97,166.77 46.87,166.66 46.87,166.35 46.96,166.26 47.79,166.26 48.31,166.79 51.94,166.79 53.71,168.56 57.26,168.56 57.53,168.83 61.13,168.83 61.66,169.36 62.44,169.36 62.58,169.23 62.58,168.64 62.66,168.56 62.93,168.56 63.02,168.64 63.02,169.25 63.14,169.36 63.47,169.36 63.55,169.28 63.55,169.06 63.64,168.98 63.91,168.98 64.01,169.07 64.01,169.27 64.1,169.36 69.09,169.36 71.34,171.61 91.88,171.61 92.1,171.39 v2(92.68,171.39)
  BOTTOM w0.079: 104.78,168.34 104.78,168.22 105.27,167.73 105.27,166.43 105.68,165.39 105.68,165.25 U1.B28
  BOTTOM w0.114: 104.78,168.34 104.01,169.11 99.39,169.11 98.4,170.1 93.92,170.1 92.68,171.34 v2(92.68,171.39) ; v1(47.91,167.35) 47.39,166.82 JDIM1.20
M_A_DQ7: length 71.7
  IN4 w0.089: v2(93.9,171.4) 93.9,171.71 93.31,172.29 67.74,172.29 67.63,172.18 67.63,170.18 67.5,170.05 67.3,170.05 67.19,170.16 67.19,171.34 67.05,171.49 66.83,171.49 66.72,171.37 66.72,170.13 66.63,170.05 61,170.05 60.83,169.88 60.83,169.61 60.74,169.52 60.44,169.52 60.3,169.65 60.3,170.05 60.07,170.28 58.1,170.28 57.54,169.72 56.47,169.72 56.33,169.59 56.33,169.33 56.24,169.24 55.93,169.24 55.84,169.34 55.84,169.61 55.73,169.72 53.91,169.72 52.23,168.04 50.21,168.04 v1(49.44,167.27)
  BOTTOM w0.079: U1.A28 105.64,165.94 105.64,166.33 105.43,166.54 105.43,167.81 105.17,168.07 105.17,168.32 104.9,168.6
  BOTTOM w0.114: JDIM1.21 50.14,166.57 v1(49.44,167.27) ; v2(93.9,171.4) 94.87,170.42 98.74,170.42 99.65,169.51 103.99,169.51 104.9,168.6
M_A_DQ8: length 68.3
  IN4 w0.089: v2(102.15,168.13) 101.74,168.54 95.87,168.54 94.65,169.76 91.43,169.76 91.21,169.98 72.01,169.98 69.77,167.74 69.43,167.74 69.34,167.65 69.34,167.31 69.25,167.22 68.98,167.22 68.89,167.31 68.89,167.65 68.8,167.74 68.54,167.74 68.45,167.65 68.45,167 68.36,166.91 68.09,166.91 68,167 68,167.65 67.91,167.74 67.65,167.74 67.56,167.65 67.56,167 67.47,166.91 67.2,166.91 67.11,167 67.11,167.65 67.03,167.74 66.76,167.74 66.67,167.65 66.67,167 66.58,166.91 66.31,166.91 66.22,167 66.22,167.65 66.14,167.74 65.87,167.74 65.78,167.65 65.78,167 65.69,166.91 57.49,166.91 56.87,166.29 53.75,166.29 52.61,165.16 52.02,165.16 51.91,165.06 51.91,164.67 51.78,164.54 50.88,164.54 50.77,164.64 v1(50.77,165.06)
  BOTTOM w0.079: U1.B30 104.82,165.27 104.82,165.43 104.89,165.65 104.89,165.89 104.71,166.07 104.71,167.45 104.41,167.75 103.36,167.75 103.28,167.83
  BOTTOM w0.114: 103.28,167.83 102.45,167.83 v2(102.15,168.13) ; JDIM1.25 51.29,165.57 v1(50.77,165.06)
M_A_DQ9: length 69.3
  IN4 w0.089: v2(103.89,168.16) 103.89,168.38 102.69,169.57 96.3,169.57 95.08,170.79 91.86,170.79 91.64,171.01 71.59,171.01 69.34,168.77 64.79,168.77 64.68,168.65 64.68,168.1 64.54,167.96 64.3,167.96 64.22,168.03 64.22,168.29 64.14,168.38 63.84,168.38 63.75,168.29 63.75,168.05 63.66,167.96 53.96,167.96 52.19,166.19 48.56,166.19 v1(47.95,165.58)
  BOTTOM w0.079: U1.D30 104.63,163.93 104.91,164.2 104.91,165.1 104.99,165.18 104.99,165.4 105.06,165.63 105.06,165.96 104.88,166.14 104.88,167.52 104.43,167.96 104.09,167.96 v2(103.89,168.16)
  BOTTOM w0.114: JDIM1.24 45.59,165.82 45.83,166.06 47.47,166.06 v1(47.95,165.58)
M_A_DQ10: length 68.5
  IN4 w0.089: v2(99.82,166.97) 99.23,166.38 96.84,166.38 96.63,166.58 95.16,166.58 93.87,167.87 90.64,167.87 90.43,168.09 72.8,168.09 68.79,164.08 64.14,164.08 64.05,164.17 64.05,164.41 63.96,164.5 63.69,164.5 63.6,164.41 63.6,164.17 63.51,164.08 63.25,164.08 63.16,164.17 63.16,164.41 63.07,164.5 62.8,164.5 62.71,164.41 62.71,164.17 62.62,164.08 62.36,164.08 62.27,164.17 62.27,164.41 62.18,164.5 61.91,164.5 61.82,164.41 61.82,164.17 61.74,164.08 61.47,164.08 61.38,164.17 61.38,164.41 61.29,164.5 61.02,164.5 60.94,164.41 60.94,164.08 60.85,164 60.58,164 60.49,164.09 60.49,164.41 60.4,164.5 57.75,164.5 57.27,164.03 54.23,164.03 52.05,161.85 48.63,161.85 48.51,161.72 48.51,160.46 48.56,160.41 48.88,160.41 49.01,160.53 49.01,161.32 v1(49.1,161.41)
  BOTTOM w0.079: U1.B33 102.44,165.63 102.44,165.7 102.13,166.01 101.75,166.01 101.52,166.23 101.16,166.23
  BOTTOM w0.114: 101.16,166.23 100.43,166.97 v2(99.82,166.97) ; JDIM1.41 51.34,161.57 50.75,160.98 49.53,160.98 v1(49.1,161.41)
M_A_DQ11: length 68.5
  IN4 w0.089: v1(50.52,161.41) 50.52,161.08 50.62,160.98 50.84,160.98 51.3,161.43 52.12,161.43 54.37,163.68 55.02,163.68 55.26,163.45 60.99,163.45 61.27,163.74 68.93,163.74 72.94,167.75 90.28,167.75 90.5,167.53 93.73,167.53 95.05,166.21 96.15,166.21 96.51,165.85 v2(96.56,165.85)
  BOTTOM w0.079: 102.54,167.48 103.2,166.82 103.97,166.82 104.21,166.58 104.21,165.57 104.24,165.5 104.24,165.3 104.21,165.23 104.21,164.92 104.24,164.88 104.24,164.43 104.29,164.39 104.29,163.98 104.09,163.79 U1.D32
  BOTTOM w0.114: JDIM1.37 51.22,162.57 50.52,161.88 v1(50.52,161.41) ; v2(96.56,165.85) 96.56,168.49 97.18,169.11 97.7,169.11 98.9,167.91 100.62,167.91 101.04,167.48 102.54,167.48
M_A_DQ12: length 67.5
  IN4 w0.089: v2(104.37,167.3) 103.9,167.76 103.48,167.76 103.41,167.84 103.15,167.84 102.86,168.13 102.86,168.82 102.45,169.23 96.16,169.23 94.94,170.45 91.71,170.45 91.5,170.67 71.73,170.67 69.48,168.42 65.49,168.42 64.68,167.62 56.49,167.62 56.38,167.51 56.38,167.06 56.3,166.98 55.92,166.98 55.83,167.07 55.83,167.51 55.72,167.62 54.1,167.62 52.33,165.85 48.7,165.85 48.48,165.62 48.48,165.16 48.59,165.06 v1(49.19,165.06)
  BOTTOM w0.079: v2(104.37,167.3) 104.55,166.89 104.55,166 104.63,165.91 U1.A30
  BOTTOM w0.114: JDIM1.29 49.68,164.57 v1(49.19,165.06)
M_A_DQ13: length 68.1
  IN4 w0.089: v1(46.63,165.56) 46.63,164.76 46.77,164.61 50.09,164.61 50.3,164.82 50.3,165.25 50.55,165.5 52.47,165.5 53.61,166.64 56.73,166.64 57.35,167.26 65.34,167.26 65.44,167.35 65.44,167.89 65.63,168.08 69.63,168.08 71.87,170.32 91.35,170.32 91.57,170.11 94.8,170.11 96.02,168.89 102.14,168.89 102.54,168.49 102.54,167.99 v2(103.07,167.47)
  BOTTOM w0.079: v2(103.07,167.47) 103.07,167.36 103.42,167 104.02,167 104.38,166.65 104.38,165.6 104.41,165.53 104.41,165.26 104.38,165.2 104.38,164.97 104.41,164.92 104.41,164.66 U1.C30
  BOTTOM w0.114: v1(46.63,165.56) 45.89,164.82 JDIM1.28
M_A_DQ14: length 67.3
  IN4 w0.089: v1(47.86,161.8) 48.25,162.19 51.9,162.19 54.09,164.37 57.13,164.37 57.61,164.85 64.39,164.85 64.48,164.76 64.48,164.51 64.57,164.42 64.83,164.42 64.92,164.51 64.92,164.76 65.01,164.85 65.28,164.85 65.37,164.76 65.37,164.51 65.46,164.42 65.72,164.42 65.81,164.51 65.81,164.76 65.9,164.85 66.17,164.85 66.26,164.76 66.26,164.51 66.35,164.42 68.65,164.42 72.65,168.43 90.57,168.43 90.79,168.21 94.01,168.21 95.26,166.97 v2(97.33,166.97)
  BOTTOM w0.079: U1.B32 102.99,165.43 102.99,165.51 102.69,165.8 102.59,165.8 102.21,166.18 101.85,166.18 101.59,166.44
  BOTTOM w0.114: 101.59,166.44 101.39,166.44 100.32,167.5 98.77,167.5 97.75,168.52 97.49,168.52 97.34,168.36 97.34,168.08 97.75,167.66 97.75,167.39 v2(97.33,166.97) ; JDIM1.42 47.38,161.32 v1(47.86,161.8)
M_A_DQ15: length 67.1
  IN4 w0.089: v2(98.6,166.97) 98.23,167.35 95.37,167.35 94.15,168.56 90.93,168.56 90.71,168.78 72.51,168.78 69.45,165.71 68.55,165.71 68.41,165.57 68.41,164.86 68.33,164.77 68.06,164.77 67.97,164.86 67.97,165.62 67.89,165.71 67.62,165.71 67.53,165.62 67.53,164.86 67.44,164.77 67.17,164.77 67.08,164.86 67.08,165.61 66.98,165.71 66.7,165.71 66.58,165.6 66.58,165.32 66.46,165.19 57.46,165.19 56.99,164.71 53.94,164.71 51.76,162.53 47,162.53 v1(46.59,162.12)
  BOTTOM w0.079: U1.C32 103.33,164.6 102.87,165.06 102.61,165.06 102.28,165.4 101.88,165.4 101.68,165.6 101.68,165.85 101.51,166.02 101.09,166.02 100.57,166.54
  BOTTOM w0.114: v1(46.59,162.12) 46.39,162.32 JDIM1.38 ; v2(98.6,166.97) 99.04,166.54 100.57,166.54
M_A_DQ16: length 63.8
  IN4 w0.089: v1(46.51,160.14) 46.51,159.44 46.38,159.3 45.95,159.3 45.86,159.21 45.86,158.84 45.95,158.75 47.24,158.75 47.5,158.49 51.7,158.49 54.21,161 60.2,161 60.45,161.25 63.51,161.25 63.92,160.85 68.34,160.85 73.4,165.9 92.92,165.9 94.11,164.71 94.96,164.71 95.83,163.84 v2(95.83,163.73)
  BOTTOM w0.079: U1.H37 100.15,161.78 99.39,161.78 98.88,162.29 98.88,162.71 98.45,163.14
  BOTTOM w0.102: 98.45,163.14 96.43,163.14 v2(95.83,163.73)
  BOTTOM w0.114: v1(46.51,160.14) 46.33,160.32 JDIM1.46
M_A_DQ17: length 65.4
  IN4 w0.089: v2(97.66,163.77) 97.31,164.12 96.24,164.54 95.49,165.29 94.56,165.29 93.27,166.59 73.11,166.59 68.68,162.16 65.55,162.16 65.42,162.04 65.42,161.62 65.34,161.53 65.03,161.53 64.93,161.63 64.93,162.07 64.85,162.16 64.59,162.16 64.48,162.05 64.48,161.74 64.36,161.62 64.11,161.62 63.79,161.94 60.64,161.94 60.07,162.51 57.43,162.51 57.23,162.3 54.33,162.3 51.21,159.18 49.63,159.18 v1(48.99,159.82)
  BOTTOM w0.079: v2(97.66,163.77) 98.04,164.15 98.98,164.15 99.31,163.83 99.31,163.25 99.56,162.99 99.7,162.99 99.96,162.73 99.96,162.66 100.12,162.5 100.4,162.5 100.5,162.59 101.46,162.59 102.18,161.86 U1.H34
  BOTTOM w0.114: v1(48.99,159.82) 49.74,160.57 JDIM1.45
M_A_DQ18: length 66.5
  IN4 w0.089: v1(97.92,162.16) 97.92,162.14 97.52,161.74 93.6,161.74 93.22,162.12 93.22,162.26 91.81,163.67 74.32,163.67 68.05,157.4 54.5,157.4 52.53,155.44 49.28,155.44 49.1,155.26 49.1,154.78 49.01,154.69 48.64,154.69 48.56,154.78 48.56,155.5 48.42,155.64 46.08,155.64 45.94,155.78 45.94,156.47 46.04,156.56 v1(46.58,156.56)
  BOTTOM w0.079: U1.K34 102.07,160.39 101.69,160.76 100.52,160.76 100.39,160.81 100.02,160.81 99.93,160.72 99.48,160.72 99.13,161.07 99.13,161.32 98.32,162.14 97.95,162.14 v1(97.92,162.16)
  BOTTOM w0.114: JDIM1.62 46.34,156.32 v1(46.58,156.56)
M_A_DQ19: length 66.3
  IN4 w0.089: v1(93.75,162.17) 93.75,162.21 91.95,164.01 74.18,164.01 67.91,157.74 67.57,157.74 67.48,157.83 67.48,158.33 67.39,158.42 67.13,158.42 67.04,158.33 67.04,157.83 66.95,157.74 66.68,157.74 66.59,157.83 66.59,158.33 66.5,158.42 66.24,158.42 66.15,158.33 66.15,157.83 66.06,157.74 65.79,157.74 65.7,157.83 65.7,158.33 65.61,158.42 65.35,158.42 65.26,158.33 65.26,157.83 65.17,157.74 64.9,157.74 64.81,157.83 64.81,158.33 64.73,158.42 64.46,158.42 64.37,158.33 64.37,157.83 64.28,157.74 54.36,157.74 52.39,155.78 49.58,155.78 49.49,155.87 v1(49.49,156.19)
  BOTTOM w0.079: U1.K35 101.29,160.39 101.03,160.13 100.09,160.13 100,160.22 99.27,160.22 98.26,161.23
  BOTTOM w0.114: v1(49.49,156.19) 50.37,157.07 JDIM1.59 ; 98.26,161.23 93.87,161.23 93.75,161.34
  BOTTOM w0.127: v1(93.75,162.17) 93.75,161.34
M_A_DQ20: length 64.4
  IN4 w0.089: v2(96.44,163.73) 95.14,165.04 94.29,165.04 93.09,166.25 73.25,166.25 68.72,161.71 68.48,161.71 68.38,161.82 68.18,161.82 68.09,161.73 68.09,161.28 68,161.19 67.7,161.19 67.6,161.29 67.6,161.74 67.52,161.82 67.24,161.82 67.14,161.72 67.14,161.28 67.06,161.19 66.76,161.19 66.68,161.27 66.68,161.75 66.61,161.82 65.84,161.82 65.77,161.75 65.77,161.31 65.65,161.19 64.06,161.19 63.65,161.6 60.31,161.6 60.05,161.34 54.06,161.34 51.56,158.84 47.72,158.84 v1(47.45,159.1)
  BOTTOM w0.079: 98.47,163.36 99.06,162.78 99.06,162.35 99.46,161.95 100.33,161.95 100.54,161.87 100.7,161.87 U1.H36
  BOTTOM w0.102: 98.47,163.36 96.81,163.36 v2(96.44,163.73)
  BOTTOM w0.114: v1(47.45,159.1) 46.53,159.1 46.31,159.32 JDIM1.50
M_A_DQ21: length 65.1
  IN4 w0.089: v2(98.88,163.76) 97.73,164.91 96.14,164.91 95.38,165.68 94.74,165.68 93.48,166.93 72.97,166.93 69.18,163.14 68.23,163.14 68.14,163.05 68.14,162.6 68.04,162.5 67.78,162.5 67.69,162.58 67.69,163.05 67.6,163.14 67.34,163.14 67.25,163.05 67.25,162.59 67.16,162.5 66.89,162.5 66.8,162.59 66.8,163.05 66.72,163.14 65.91,163.14 65.82,163.05 65.82,162.59 65.73,162.5 65.47,162.5 65.38,162.59 65.38,163.05 65.29,163.14 65.02,163.14 64.93,163.05 64.93,162.59 64.84,162.5 64.58,162.5 64.49,162.59 64.49,163.05 64.4,163.14 64.13,163.14 64.04,163.05 64.04,162.45 63.96,162.37 63.69,162.37 63.6,162.46 63.6,163.05 63.51,163.14 61.52,163.14 61.23,162.85 57.29,162.85 57.08,162.65 54.19,162.65 51.79,160.25 50.83,160.25 v1(50.42,159.84)
  BOTTOM w0.079: v2(98.88,163.76) 98.88,163.22 99.23,162.88 99.23,162.42 99.53,162.11 100.36,162.11 100.57,162.04 101.18,162.04 U1.H35
  BOTTOM w0.114: JDIM1.49 51.93,159.57 51.74,159.38 50.88,159.38 v1(50.42,159.84)
M_A_DQ22: length 65.6
  IN4 w0.089: v1(96.6,162.17) 96.6,162.35 96.07,162.88 94.05,162.88 92.24,164.7 73.9,164.7 68.84,159.64 65.72,159.64 65.64,159.55 65.64,159.23 65.55,159.14 65.28,159.14 65.19,159.23 65.19,159.55 65.1,159.64 64.84,159.64 64.75,159.55 64.75,159.23 64.66,159.14 64.39,159.14 64.3,159.23 64.3,159.55 64.21,159.64 63.95,159.64 63.86,159.55 63.86,159.23 63.77,159.14 63.5,159.14 63.41,159.23 63.41,159.55 63.32,159.64 63.06,159.64 62.97,159.55 62.97,159.23 62.88,159.14 62.61,159.14 62.52,159.23 62.52,159.55 62.44,159.64 62.17,159.64 62.08,159.55 62.08,159.23 61.96,159.1 54.74,159.1 52.77,157.13 51.14,157.13 50.62,156.61 48.97,156.61 48.82,156.46 v1(47.88,156.46)
  BOTTOM w0.079: v1(96.6,162.17) 96.6,162.05 96.91,161.74 98.48,161.74 98.97,161.25 98.97,161 99.41,160.56 100,160.56 100.09,160.64 100.36,160.64 100.49,160.6 100.68,160.6 U1.K36
  BOTTOM w0.114: JDIM1.58 47.02,157.32 v1(47.88,156.46)
M_A_DQ23: length 64.5
  IN4 w0.089: v1(50.81,156.18) 50.81,156.31 51.28,156.78 51.8,156.78 51.92,156.67 51.92,156.22 52.02,156.12 52.25,156.12 52.35,156.22 52.35,156.67 52.46,156.78 52.91,156.78 54.21,158.09 56.08,158.09 56.21,158.21 56.21,158.67 56.3,158.76 56.55,158.76 56.63,158.67 56.63,158.16 56.71,158.09 56.99,158.09 57.08,158.18 57.08,158.65 57.18,158.76 57.42,158.76 57.51,158.67 57.51,158.16 57.58,158.09 63.08,158.09 63.19,158.19 63.19,158.65 63.3,158.76 63.55,158.76 63.63,158.67 63.63,158.18 63.72,158.09 63.92,158.09 64.03,158.19 64.03,158.65 64.14,158.76 65.97,158.76 66.07,158.85 66.07,159.2 66.17,159.3 66.37,159.3 66.46,159.21 66.46,158.84 66.54,158.76 66.77,158.76 66.86,158.84 66.86,159.21 66.94,159.3 67.18,159.3 67.27,159.2 67.27,158.86 67.37,158.76 67.6,158.76 67.69,158.85 67.69,159.22 67.77,159.3 68.05,159.3 68.14,159.21 68.14,158.83 68.2,158.76 68.44,158.76 68.53,158.84 68.53,159.23 68.59,159.3 68.98,159.3 74.04,164.35 92.09,164.35 93.82,162.63 94.83,162.63 v1(95.28,162.17)
  BOTTOM w0.079: U1.K37 99.34,160.39 98.8,160.93 98.8,161.15 98.46,161.48 96.8,161.48
  BOTTOM w0.114: 96.8,161.48 95.97,161.48 95.95,161.51 ; v1(50.81,156.18) 51.17,155.82 51.67,155.82 51.92,156.07 JDIM1.63
  BOTTOM w0.127: v1(95.28,162.17) 95.95,161.51
M_A_DQ24: length 64.5
  IN4 w0.089: v1(50.02,154.21) 50.02,154.48 50.12,154.58 52.91,154.58 53.47,155.14 53.47,155.53 53.75,155.81 54.13,155.81 54.28,155.96 54.28,156.34 54.38,156.44 54.71,156.44 54.8,156.35 54.8,156.04 54.9,155.94 55.27,155.94 55.35,156.03 55.35,156.48 55.47,156.59 55.69,156.59 55.82,156.46 55.82,156.03 55.9,155.94 56.2,155.94 56.28,156.02 56.28,156.7 56.39,156.8 56.66,156.8 56.74,156.71 56.74,156.56 56.82,156.48 60.27,156.48 60.35,156.55 60.35,156.72 60.42,156.8 60.74,156.8 60.84,156.7 60.84,156.4 60.97,156.27 60.97,156.04 61.07,155.94 64.32,155.94 64.44,156.06 64.44,156.53 64.59,156.68 67.64,156.68 67.8,156.52 68.02,156.52 74.57,163.07 91.89,163.07 93.47,161.48 97.17,161.48 v2(98.06,160.6)
  BOTTOM w0.079: U1.N36 100.7,159.36 100.54,159.36 100.33,159.43 98.76,159.43 98.06,160.13 v2(98.06,160.6)
  BOTTOM w0.114: v1(50.02,154.21) 50.02,154.76 50.33,155.07 JDIM1.67
M_A_DQ25: length 64.7
  IN4 w0.089: v1(94.12,160.6) 93.15,160.6 91.7,162.04 75,162.04 67.87,154.91 64.56,154.91 64.43,154.77 64.43,154.44 64.34,154.35 64.01,154.35 63.92,154.44 63.92,154.82 63.83,154.91 57.65,154.91 56.82,154.09 54.01,154.09 53.25,153.33 48.12,153.33 47.35,154.1 46.72,154.1 46.61,154.21 v1(46.61,154.91)
  BOTTOM w0.079: v1(94.12,160.6) 94.94,159.78 97.9,159.78 98.59,159.08 99.86,159.08 100.03,158.92 100.36,158.92 100.44,158.95 100.71,158.95 100.81,158.92 100.99,158.92 101.07,158.95 101.33,158.95 101.4,158.92 101.64,158.92 101.77,158.97 101.98,158.97 U1.N34
  BOTTOM w0.114: v1(46.61,154.91) 46.2,155.32 JDIM1.66
M_A_DQ26: length 64.5
  IN4 w0.089: v1(97.2,159.18) 97.21,159.17 97.21,158.8 97.1,158.69 95.61,158.69 94.97,159.33 92.59,159.33 91.46,160.45 75.64,160.45 67.97,152.78 60.83,152.78 60.78,152.83 57.76,152.83 56.68,151.75 53.94,151.75 53.57,151.38 49.07,151.38 48.86,151.17 48.86,150.07 48.73,149.95 48.39,149.95 48.28,150.06 48.28,150.86 v1(48.03,151.1)
  BOTTOM w0.079: U1.R37 100.22,157.86 99.47,157.86 99.19,157.58 97.7,157.58 97.43,157.85 97.43,158.95 v1(97.2,159.18)
  BOTTOM w0.114: JDIM1.84 45.53,150.82 45.81,150.54 47.47,150.54 v1(48.03,151.1)
M_A_DQ27: length 65
  IN4 w0.089: v1(95.76,159.2) 95.76,159.47 95.64,159.58 92.74,159.58 91.53,160.79 75.49,160.79 68.4,153.7 67.5,153.7 67.37,153.58 67.37,153.22 67.28,153.13 66.94,153.13 66.85,153.22 66.85,153.59 66.73,153.7 66.12,153.7 65.56,153.15 60.95,153.15 60.93,153.18 57.62,153.18 57.32,152.88 54.51,152.88 53.35,151.73 47.31,151.73 v1(46.69,151.1)
  BOTTOM w0.079: U1.R34 102.18,158.65 102.03,158.8 101.8,158.8 101.67,158.75 101.37,158.75 101.29,158.79 101.11,158.79 101.02,158.75 100.78,158.75 100.69,158.78 100.47,158.78 100.39,158.75 99.94,158.75 99.78,158.92 98,158.92 97.31,159.6 96.17,159.6 v1(95.76,159.2)
  BOTTOM w0.114: v1(46.69,151.1) 46.2,151.59 45.75,151.59 45.52,151.82 JDIM1.80
M_A_DQ28: length 64
  IN4 w0.089: v1(51.41,154.17) 52.99,154.17 54.41,155.6 56.1,155.6 56.18,155.51 56.18,155.13 56.25,155.06 56.52,155.06 56.63,155.17 56.63,156.05 56.71,156.14 56.98,156.14 57.07,156.05 57.07,155.68 57.16,155.59 57.43,155.59 57.51,155.68 57.51,156.05 57.6,156.14 57.87,156.14 57.96,156.05 57.96,155.68 58.04,155.6 58.31,155.6 58.4,155.69 58.4,156.05 58.49,156.14 58.76,156.14 58.85,156.05 58.85,155.69 58.94,155.6 59.2,155.6 59.29,155.69 59.29,156.05 59.38,156.14 59.65,156.14 59.74,156.05 59.74,155.69 59.83,155.6 60.09,155.6 60.18,155.69 60.18,156.05 60.27,156.14 60.55,156.14 60.63,156.07 60.63,155.69 60.72,155.6 64.71,155.6 64.83,155.72 64.83,156.24 64.93,156.34 65.16,156.34 65.27,156.22 65.27,155.69 65.36,155.6 65.62,155.6 65.7,155.69 65.7,156.21 65.83,156.34 66.52,156.34 66.63,156.23 66.63,155.69 66.72,155.6 66.99,155.6 67.09,155.7 67.09,156.25 67.19,156.34 67.47,156.34 67.55,156.26 67.55,155.97 67.65,155.87 67.86,155.87 74.71,162.73 91.85,162.73 93.32,161.26 96.11,161.26 v1(96.76,160.6)
  BOTTOM w0.079: U1.N37 100.03,159.17 99.95,159.25 98.68,159.25 97.97,159.96 97.4,159.96 v1(96.76,160.6)
  BOTTOM w0.114: JDIM1.71 51.52,154.07 v1(51.41,154.17)
M_A_DQ29: length 64.4
  IN4 w0.089: v1(47.96,154.86) 47.96,153.98 48.26,153.68 52.97,153.68 54.55,155.25 55.48,155.25 56.02,154.72 56.97,154.72 57.51,155.25 67.72,155.25 74.85,162.39 91.81,162.39 93.17,161.03 95.26,161.03 95.44,160.85 v1(95.44,160.61)
  BOTTOM w0.079: v1(95.44,160.61) 95.84,161 98.15,161 98.43,160.72 98.43,160.02 98.85,159.6 100.36,159.6 100.57,159.53 101.18,159.53 U1.N35
  BOTTOM w0.114: JDIM1.70 47.42,154.32 v1(47.96,154.86)
