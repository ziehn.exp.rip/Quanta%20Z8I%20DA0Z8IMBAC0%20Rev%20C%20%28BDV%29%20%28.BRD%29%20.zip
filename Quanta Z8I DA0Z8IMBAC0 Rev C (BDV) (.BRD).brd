# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
G5335-PWRGD-1: length 2.2
  BOTTOM w0.203: PR276.2 146.13,128.31 146.31,128.13 146.31,127.65 145.94,127.28 PU16.1
G5335-PWRGD-2: length 2.2
  TOP w0.203: PR9090.2 167.36,155.47 v1(166.88,155.47) 166.88,156.02 v2(167.03,156.17)
  BOTTOM w0.254: v2(167.03,156.17) PU9004.1
G5335-SS-1: length 2.4
  BOTTOM w0.203: PU16.23 145.19,127.75 145.19,127.75 145.19,128.04 145.04,128.19 PC232.1 144.33,128.77 v1(144.17,128.93)
G5335-SS-2: length 2.6
  BOTTOM w0.254: PU9004.23 166.28,156.68 166.6,157 166.6,157.02 166.99,157.4 167.85,157.4 168.13,157.12 PC9091.1
G5335-TON-1: length 1.5
  BOTTOM w0.203: PR268.1 146.74,123.62 146.21,124.15 PU16.6
G5335-TON-2: length 2.6
  BOTTOM w0.203: PR9086.1 168.45,151.41 167.69,152.17 167.64,152.17 v1(167.62,152.19) 167.5,152.31 167.5,153 167.34,153.16 PU9004.6
G5335-VCC-1: length 5.2
  TOP w0.114: v1(145.47,127.38) 145.15,127.7 PR104.2
  TOP w0.508: PR104.2 145.02,128.47 144.42,129.07 PC234.1 143.56,128.6 143.91,128.25 v1(144.19,128.25)
  BOTTOM w0.254: PU16.21 v1(144.19,128.25)
G5335-VCC-2: length 4.1
  BOTTOM w0.254: 165.98,157.21 165.86,157.09 165.5,157.09 165.28,156.86 PU9004.21
  BOTTOM w0.508: PC9075.1 PR9087.2 166.94,158.17 165.98,157.22 165.98,157.21
G5719LX1.5V:
  vias: v1(8.41,33.42)
GC6_FB_EN: length 6.1
  TOP w0.114: R372.2 113.65,186.86 113.65,187.7 R394.1 v1(114.11,189.26) 113.66,189.71 112.03,189.71 Q16.2
GC6_FB_EN_N17: length 14.7
  TOP w0.114: R372.1 114.96,186.33 v1(115.88,186.33) 115.89,186.34 120.93,186.34 121.35,186.76 122.01,186.76 122.4,186.37 122.4,185.98 v2(119.06,182.64)
  BOTTOM w0.102: U8.B2 120.34,183.25 119.97,182.88 119.73,182.88 119.5,182.64 v2(119.06,182.64)
GC6_FB_EN_Q: length 144.9
  TOP w0.079: 104.12,125.08 104.55,125.51 104.55,125.99 104.76,126.21 105,126.21 105.18,126.38 105.18,126.92 104.86,127.24 104.86,127.38 v2(104.81,127.44)
  TOP w0.102: 104.12,125.08 102.5,125.08 102.49,125.07 101.84,125.07 101.65,124.88
  TOP w0.114: v1(114.83,182.52) 114.83,182.88 v1(113.82,183.89) 112.58,185.13 110.91,185.13 Q14.3 ; R25430.2 87.32,116.64 R25431.1 88.03,116.9 88.98,116.9 90.74,118.65 91.36,118.65 92.88,120.18 93.38,120.18 93.61,120.41 93.61,120.91 94.35,121.65 95.7,121.65 96.54,122.49 99.92,122.49 101.65,124.22 101.65,124.88
  IN1 w0.089: v1(110.81,182.4) 114.71,182.4 v1(114.83,182.52) 115.12,182.81 116.59,182.81 118.6,184.82 118.98,184.82 119.64,185.48 119.64,192.32 119.31,192.64 119.31,193.13 121.07,194.89 121.07,196.53 122.11,197.57 122.11,202.93 123.73,204.55 124.25,204.55 124.8,205.1 124.8,205.46 125.61,206.27 v1(126.03,206.27)
  IN4 w0.089: v1(110.81,182.4) 110.81,181.34 110.3,180.83 110.3,174.66 108.98,173.34 108.98,171.28 109.4,170.86 109.4,151.08 110.01,150.47 110.01,136.49 107.34,133.83 107.34,133.65 107.09,133.4 105.08,133.4 104.89,133.21 104.89,132.85 104.6,132.56 103.27,132.56 103,132.29 103,132.1 102.39,131.48 102.39,130.09 102.51,129.97 102.51,129.46 102.39,129.33 102.39,128.32 103.64,127.06 104.43,127.06 v2(104.81,127.44)
  BOTTOM w0.079: U1.CC29 105.18,127.81 v2(104.81,127.44)
  BOTTOM w0.114: v1(126.03,206.27) 125.25,207.05 122.05,207.05 121.41,207.7 121.41,208.45 122.17,209.21 123.28,209.21 123.52,209.45 124.02,209.45 125.18,210.6 126.58,210.6 127.11,210.07 U11.1
GPD7: length 20.5
  TOP w0.114: v1(98.89,129.45) 99.01,129.34 99.01,128.55 97.08,126.62 96.48,126.62 96.26,126.4 94.26,126.4 93.64,125.78 92.5,125.78 91.75,125.03 90.61,125.03 90.13,124.54 89.73,124.54 88.7,123.52 86.77,123.52 86.47,123.82 R157.2 85.45,123.82 R152.1
  BOTTOM w0.079: U1.BV35 100.98,131.06 100.75,131.06 100.69,131.09 100.44,131.09 100.37,131.06 99.79,131.06 98.89,130.16 v1(98.89,129.45)
GPD9: length 19.2
  TOP w0.079: v2(104.24,131.98) 104.24,132.06 103.78,132.51 102.79,132.51 102.2,133.1 101.92,133.1 100.74,134.28
  TOP w0.114: 100.74,134.28 100.67,134.35 98.19,134.35 96.99,135.54 93.44,135.54 92.44,134.54 91.51,134.54 90.14,135.92 88.75,135.92 TP6.1
  BOTTOM w0.089: U1.BT30 104.24,132.19 v2(104.24,131.98)
GPIO0: length 1.5
  BOTTOM w0.114: TP104.1 28.26,57.82 U40.17
GPIO10_VREF: length 87
  TOP w0.102: 124.19,185.78 v1(124.18,185.77)
  TOP w0.381: v1(124.18,185.77) 124.19,185.76 124.19,185.11 123.54,184.46 v2(123.49,184.46) ; R398.2 124.19,185.78 ; v1(163.07,190.55) 162.52,190 Q20.2
  IN2 w0.508: v1(140.9,176.24) 141.47,175.67 141.47,172.27 143.46,170.27 146.48,170.27 147.4,171.19 163.22,171.19 164.64,169.77 167.21,169.77 167.69,170.25 167.69,187.29 164.44,190.55 v1(163.07,190.55)
  IN4 w0.508: v2(123.49,184.46) 123.49,183.39 124.48,182.39 124.48,179.51 125.53,178.46 127.71,178.46 128.84,177.33 128.84,174.24 129.85,173.24 131.94,173.24 134.87,176.17 140.82,176.17 v1(140.9,176.24)
  BOTTOM w0.381: v2(123.49,184.46) U8.C5
GPO: length 8.6
  TOP w0.114: U6521.3 23.84,164.61 24.26,164.18 24.61,164.18 24.87,163.93 24.87,163.58 25.03,163.42 26.9,163.42 27.33,162.99 v1(27.49,162.99) R67524.2 27.58,163.82 28.49,164.73 R67474.2 R67504.1
GPP_B18: length 29.9
  TOP w0.079: 100.74,122.92 102.05,124.23 102.27,124.23 102.34,124.3 105.53,124.3 105.77,124.54 105.77,124.96 105.26,125.47 105.26,126.11 105.54,126.39 v2(105.54,126.65)
  TOP w0.114: R120.1 83.36,116.38 v1(83.42,116.33) 83.81,116.33 83.95,116.19 84.57,116.19 84.76,116.37 86.85,116.37 87.29,115.93 89.53,115.93 R122.2 94.98,121.38 95.74,121.38 96.61,122.25 100.07,122.25 100.74,122.92
  BOTTOM w0.079: v2(105.54,126.65) 105.49,126.65 105.18,126.95 U1.CE29
GPP_B23: length 22.6
  TOP w0.114: v1(96.67,126.21) 96.59,126.13 94.37,126.13 93.75,125.52 92.61,125.52 91.86,124.76 90.72,124.76 90.24,124.27 89.84,124.27 88.81,123.25 87.79,123.25 R90.2 87.63,122.82 87.41,122.59 86.3,122.59 85.77,123.12 84.16,123.12 83.97,123.31 82.86,123.31 R89.1
  BOTTOM w0.079: U1.CC34 101.9,127.95 100.11,127.95 99.86,127.7 98.91,127.7 97.63,126.42 96.88,126.42 v1(96.67,126.21)
GPP_F10: length 6.6
  BOTTOM w0.079: TP21.1 114,118.06 114,118.92 113.22,119.69 113.14,119.69 112.62,120.21 112.62,120.64 112.62,120.64 112.62,121.24 112.56,121.39 112.56,121.97 112.47,122.05 112.47,123.37 U1.CK17
GPP_F23: length 16.6
  TOP w0.102: v2(113.31,125.95) 113.31,126.03 114.07,126.79 114.57,126.79 115.01,126.35 115.01,126.16 115.2,125.97 115.66,125.97 115.91,125.72 115.91,123.29 117.36,121.84 118.05,121.84 118.47,121.42
  TOP w0.114: 118.47,121.42 R158.2 118.64,121.01 119.58,120.08 119.93,120.08 v1(120.04,119.96) 120.04,119.61 120.45,119.2 120.45,118.55 122.09,116.91 R153.1
  BOTTOM w0.079: v2(113.31,125.95) 113.16,125.95 U1.CF17
GPP_H21: length 16.6
  BOTTOM w0.079: U1.CF25 107.61,126.19 107.33,125.91 107.33,124.89 107.41,124.82 107.41,124.54 107.33,124.47 107.33,123.28 107.39,123.22 107.39,122 107.45,121.94 107.45,120.79 107.77,120.47 107.77,119.95 107.17,119.35 107.17,118.33 106.9,118.05 106.9,116.49 107.39,116 107.39,115.72
  BOTTOM w0.114: R144.1 105.06,112.86 105.25,112.67 v1(105.44,112.67) 105.76,112.99 106.21,112.99 107.39,114.17 107.39,115.72
GPP_H23: length 17.5
  TOP w0.079: v2(107.03,124.69) 107.17,124.55 107.17,123.31 106.19,122.33 106.19,122.09
  TOP w0.114: TP20.1 103.02,112.57 103.02,113.2 103.34,113.52 105.29,113.52 105.46,113.69 106.36,114.59 106.36,119.38 106.19,119.56 106.19,122.09
  BOTTOM w0.079: v2(107.03,124.69) 107.17,124.55 107.17,123.14 U1.CM26
GPU_CHOKE_THERMAL: length 0.9
  BOTTOM w0.254: TP13168.1 102,193.55 PR9025.1
GPU_EVENT#: length 88.7
  TOP w0.079: v2(104.18,127.43) 104.59,127.84 105.02,127.84 105.18,127.68 105.18,127.3 105.44,127.05 106.31,127.05 106.51,126.85 106.51,126.64 107.31,125.84 107.31,125.44 107.14,125.26 106.95,125.26 106.67,124.98 106.67,124.39 106.45,124.18 106.45,123.35 105.2,122.09
  TOP w0.114: v1(109.57,180.71) v1(109.57,181.7) 109.69,181.82 109.69,182.55 108.53,183.7 D4.1 ; 105.2,122.09 105.14,122.03 105.14,119.65 104.71,119.22 104.71,118.53 105.02,118.22 105.75,118.22 106.15,117.83 106.15,114.68 105.2,113.74 103.06,113.74 102.65,113.33 102.65,112.08 R25482.2
  IN3 w0.102: v2(104.18,127.43) 104.57,127.04 106.64,127.04 107.13,127.54 108.34,127.54 109.48,128.68 109.48,137.9 110.01,138.44 110.01,150.69 109.64,151.07 109.64,154.91 109.93,155.2 109.93,160.84 110.26,161.17 110.26,172.63 v1(108.97,173.92)
  IN4 w0.089: v1(109.57,180.71) 109.8,180.48 109.8,174.75 v1(108.97,173.92)
  BOTTOM w0.079: U1.CC30 104.18,127.58 v2(104.18,127.43)
GPU_EVENT#_GPU: length 7.5
  TOP w0.114: R373.2 113,182.96 112.6,182.56 R25490.1 112.1,183.15 112.24,183.29 112.24,184.04 111.73,184.55 v1(110.78,184.55) 110.15,185.18 109.78,185.18 D4.2
GPU_GPIO0: length 10.6
  BOTTOM w0.102: 123.52,182.14 123.27,181.88 122.5,181.88 122.24,181.62 121.32,181.62 120.72,181.03
  BOTTOM w0.114: R370.1 116.36,179.37 118.02,181.03 120.72,181.03 ; 123.52,182.14 123.52,183.65 U8.C6
GPU_GPIO2: length 12.8
  TOP w0.102: v2(123.48,185.29) 122.94,185.29
  TOP w0.114: R373.1 113.97,182.58 114.52,182.04 115.14,182.04 115.75,182.65 v1(115.75,182.8) 116.11,182.8 116.85,182.05 119.17,182.05 122.41,185.29 122.94,185.29
  BOTTOM w0.102: U8.D6 v2(123.48,185.29)
GPU_GPIO6: length 7
  BOTTOM w0.102: U8.A4 121.85,182.08 121.13,182.08 120.53,181.49 117.6,181.49
  BOTTOM w0.114: 117.6,181.49 116.45,180.34 R376.1
GPU_GPIO21: length 10.3
  BOTTOM w0.102: 117.39,181.7 117.4,181.72 120.44,181.72 121.03,182.31 121.03,182.72 121.18,182.88 121.69,182.88 121.82,183 121.82,183.65 U8.C4
  BOTTOM w0.114: 117.39,181.7 116.91,181.23 116.91,181.1 116.55,180.74 114.31,180.74 R404.1
GPU_PEX_RST_HOLD#: length 12.7
  BOTTOM w0.102: 117.83,181.26 120.63,181.26 121.22,181.85 122.14,181.85 122.67,182.38 122.67,184.45 U8.D5
  BOTTOM w0.114: 117.83,181.26 117.79,181.26 116.44,179.91 115.1,179.91 114.91,179.72 114.91,179.59 114.61,179.29 114.4,179.29 114.08,178.98 R399.1
GPU_PWR_GD: length 102.9
  TOP w0.114: v1(119.54,210.05) 119.54,207.02 118.24,205.71 118.24,204.45 v1(118.98,203.71)
  TOP w0.254: PR9008.1 v2(105.16,194.1)
  IN1 w0.089: v2(105.16,194.1) 104.38,193.33 104.38,190.56 105.02,189.92 105.44,189.92 106.31,189.05 107.01,189.05 107.67,188.38 110.7,188.38 112.33,190.01 113.01,190.01 113.45,190.45 113.45,196.09 114.28,196.93 114.28,199.51 114.74,199.97 114.74,207.34 115.13,207.72 116.69,207.72 119.02,210.05 v1(119.54,210.05)
  IN3 w0.102: v1(118.98,203.71) 120.21,202.47 120.21,196.24 119.56,195.59 119.56,194.71 120.45,193.82 120.45,191.15 120.34,191.04 120.34,190.02 121.53,188.82 121.53,187.01 121.11,186.59 121.11,176.22 v1(119.53,174.63)
  BOTTOM w0.114: v1(119.53,174.63) 119.29,174.87 117.88,174.87 117.1,175.65 v1(104.68,175.65) 104.23,176.09 102.37,176.09 102.01,176.45 102.01,177.86 100.11,179.75 99.94,179.75 99.87,179.8 99.29,180.39 98.75,180.39 98.46,180.67 PR9079.1 ; R324.1 120.24,210.05 v1(119.54,210.05)
GPUT_CLK_L: length 14.1
  TOP w0.114: v1(132.59,176.27) 131.98,176.27 v1(131.91,176.2)
  IN2 w0.102: v1(131.91,176.2) 131.29,176.2 130.56,176.93 130.56,177.72 128.81,179.47 128.81,180.19 126.81,182.18 v2(126.81,184.44)
  BOTTOM w0.102: v2(126.81,184.44) U8.D9
  BOTTOM w0.114: v1(131.91,176.2) 132,176.12 R365.1 132.23,175.53 132.49,175.27 Q13.4
GPUT_DATA_L: length 21.9
  IN2 w0.102: v2(125.17,184.45) U8.D8 127.14,184.85 127.48,184.5 127.48,182.09 129.26,180.31 129.26,179.61 131.09,177.78 133.79,177.78 134.97,176.59 136.2,176.59 137.35,175.44 v1(137.54,175.44)
  BOTTOM w0.102: v2(125.17,184.45) 125.19,184.48 U8.D8
  BOTTOM w0.114: v1(137.54,175.44) R362.1 136.93,175.99 v1(136.68,176.25) 136.36,176.57 Q13.1
GS_HUB_INT1#: length 342.5
  TOP w0.114: v1(130.51,213.11) 130.51,213.69 130.41,213.79 Q6540.1 130.41,215.25 130.67,215.52 R25639.1
  IN1 w0.089: v1(130.51,213.11) 130.39,213.23 127.12,213.23 125.23,211.35 125.23,211.12 124.2,210.09 122.34,210.09 119.78,207.52 119,207.52 116.63,205.15 116.63,198.65 117.29,197.99 117.29,195.69 115.07,193.47 115.07,189.38 114.14,188.44 114.14,187.48 112.51,185.85 107.37,185.85 106.51,186.71 105.97,186.71 105.33,187.35 103.63,187.35 103.03,187.96 103.03,188.56 100.99,190.6 100.8,190.6 100.48,190.91 97.41,190.91 96.39,191.94 95.25,191.94 92.6,194.59 82.01,194.59 81.23,193.8 81.23,191.44 80.44,190.65 79.52,190.65 77,193.17 75.93,193.17 75.39,193.72 72.29,193.72 70.22,195.79 65.33,195.79 62.66,193.12 57.84,193.12 55.48,190.76 53.46,190.76 49.84,187.15 45.54,187.15 44.83,187.85 44.01,187.85 42.18,186.02 42.18,180.58 39.91,178.32 38.73,178.32 37.27,176.86 37.27,176.2 35.95,174.88 33.14,174.88 32.84,174.57 v1(32.84,173.7) ; v2(110.94,113.12) 109.78,114.28 107.43,114.28 106.35,113.19 104.49,113.19 103.12,111.82 102.26,111.82 101.23,110.79 96.32,110.79 95.04,109.52 93.95,109.52 92.73,108.3 89.78,108.3 87.82,106.34 83.93,106.34 82.57,104.98 80.55,104.98 79.89,104.32 79.07,104.32 78.41,103.66 v1(78.41,103.4)
  IN2 w0.102: v1(71.26,177.13) 69.56,177.13 68.07,175.64 65.73,175.64 64.55,176.83 64.17,176.83 v1(63.77,177.22)
  BOTTOM w0.079: 110.31,118.21 110.31,119.36 110.64,119.68 111.13,119.68 111.6,120.16 111.6,120.92 111.25,121.28 111.25,122.57 111.06,122.75 110.79,122.75 110.61,122.93 110.61,123.19 110.1,123.71 U1.CK22
  BOTTOM w0.114: v1(32.84,173.7) 32.1,173.7 29.09,170.68 29.09,167.52 31.25,165.35 31.25,165.01 32.09,164.17 32.09,162.88 32.73,162.24 35.47,162.24 36.16,161.55 41.24,161.55 42.51,162.82 42.51,168.29 42.73,168.51 42.73,172.55 46.45,176.27 62.83,176.27 v1(63.77,177.22) ; R67483.1 111.34,112.72 v2(110.94,113.12) 110.82,113.24 110.15,113.24 109.9,113.5 109.9,116.41 110.31,116.83 110.31,118.21 ; v1(78.41,103.4) 77.96,103.86 77.96,106.52 77.37,107.11 77.37,108.37 72.71,113.03 72.71,125.76 74.55,127.61 74.55,168.84 75.27,169.56 75.27,173.85 74.46,174.66 73.97,174.66 71.62,177.01 71.38,177.01 v1(71.26,177.13)
GS_I2C_SCL: length 104
  TOP w0.114: R67482.2 84.12,110.46 v1(84.13,110.46)
  IN3 w0.102: v1(102.29,178.69) 103.6,177.37 106.5,177.37 110.85,173.03 110.85,166.98 111.72,166.11 111.72,158.5 111.38,158.15 111.38,138.71 111.15,138.47 111.15,134.9 111.51,134.54 111.51,129.84 111.3,129.63 111.16,129.63 110.21,128.67 110.21,127.06 109.78,126.63 108.15,126.63 107.93,126.41 106.73,126.41 106.4,126.08 105.32,126.08 v2(104.9,125.66) 104.49,126.08 102.27,126.08 99.26,123.07 99.05,123.07 98.28,122.3 97.18,122.3 96.73,121.84 96.73,121.08 95.85,120.21 95.85,119.26 90.69,114.11 90.69,111.06 90.18,110.54 89.42,110.54 88.96,110.08 88.47,110.08 88.3,110.26 86,110.26 85.62,109.88 84.7,109.88 v1(84.13,110.46)
  BOTTOM w0.079: v2(104.9,125.66) 104.9,125.83 U1.CF29
  BOTTOM w0.114: Q6569.1 100.29,181.59 99.91,181.21 99.91,180.14 100.03,180.02 100.22,180.02 101.45,178.79 102.19,178.79 v1(102.29,178.69) 102.52,178.46 v1(102.52,177.62) 102.53,177.6 R25632.1
GS_I2C_SDA: length 97
  TOP w0.114: R67481.2 83.37,109.7 v1(83.58,109.49)
  IN3 w0.102: v1(83.58,109.49) 83.72,109.35 84.35,109.35 84.66,109.65 85.72,109.65 86.09,110.03 88.2,110.03 88.38,109.86 89.05,109.86 89.51,110.31 90.28,110.31 90.92,110.96 90.92,114.01 96.08,119.17 96.08,120.11 97.15,121.18 97.48,121.18 99.15,122.84 99.35,122.84 101.79,125.28 105.96,125.28 v2(106.33,125.66) 106.85,126.18 107.98,126.18 108.23,126.43 109.86,126.43 110.41,126.97 110.41,128.59 111.25,129.43 111.38,129.43 111.71,129.76 111.71,134.66 111.38,135 111.38,138.38 111.61,138.61 111.61,158.06 111.95,158.4 111.95,166.2 111.08,167.08 111.08,173.12 106.57,177.63 105.41,177.63 v1(104.58,178.46)
  BOTTOM w0.079: U1.CF27 106.48,125.81 v2(106.33,125.66)
  BOTTOM w0.114: Q6539.4 104.04,179.47 v1(104.07,179.45) 104.07,178.97 v1(104.58,178.46) R25630.1
GSPI1_MOSI: length 21.8
  TOP w0.079: 100.74,126.98 101.01,127.25 101.01,127.28 102.43,128.7 103.71,128.7 103.88,128.87 104.27,128.87 v2(104.72,128.41)
  TOP w0.114: 100.74,126.98 99.93,126.18 99.29,126.18 99.02,125.91 99.02,125.39 98.63,125 95.48,125 94.35,123.87 92.48,123.87 92.3,123.69 91.17,123.69 90.68,123.21 90.28,123.21 89.25,122.18 88.51,122.18 87.68,121.36 R124.2
  BOTTOM w0.079: v2(104.72,128.41) 104.71,128.43 104.71,128.69 104.56,128.84 U1.CA30
H_CPU_SVIDALRT#: length 8.5
  BOTTOM w0.079: U1.AA3 122.07,153.59 122.17,153.57 122.25,153.57 122.48,153.64 122.53,153.64 122.73,153.59 122.75,153.59 125.12,153.59 125.74,154.21 126.74,154.21
  BOTTOM w0.114: R64.1 127.3,154.84 127.3,154.4 127.12,154.21 126.74,154.21
H_CPU_SVIDCLK: length 58.8
  TOP w0.114: v1(168.15,150.72) 167.98,150.55 v1(167.98,149.58) 168.29,149.27 PR7003.2
  IN4 w0.089: v2(129.72,157.09) 130.8,156.02 131.7,156.02 132.15,155.56 135.58,155.56 136.31,156.28 137.21,156.28 137.71,155.78 138.67,155.78 139.64,154.81 139.64,150.22 140.45,149.4 140.45,148.37 140.94,147.88 150.34,147.88 150.44,147.97 156.23,147.97 156.74,147.47 157.1,147.47 159.93,144.63 160.26,144.63 160.5,144.87 160.5,145.39 161.48,146.36 163.51,146.36 163.86,146.71 163.86,147.84 165.6,149.57 165.6,149.88 166.02,150.3 167.26,150.3 v1(167.98,149.58)
  BOTTOM w0.079: 127.72,155.96 127.31,155.55 R66.1
  BOTTOM w0.114: 127.72,155.96 128.14,156.38 128.14,156.49 128.3,156.66 129.3,156.66 129.72,157.08 v2(129.72,157.09) 130.76,157.09 R65.2 ; v1(167.98,149.58) 168.29,149.26 PR7015.1
H_CPU_SVIDDAT: length 57.8
  TOP w0.114: PR7001.2 166.33,149.48 v1(166.34,149.49) 166.25,149.58 v1(165.48,149.58)
  IN4 w0.089: v1(166.34,149.49) 166.34,149.34 164.56,147.57 164.56,147.44 165.21,146.8 165.21,146.64 165.08,146.51 164.95,146.51 164.83,146.63 164.75,146.63 164.5,146.38 164.5,146.29 164.63,146.16 164.63,146.05 164.45,145.88 164.28,145.88 164.21,145.95 164.07,145.95 163.8,145.68 161.77,145.68 161.19,145.1 161.19,144.59 160.55,143.95 159.65,143.95 157.97,145.62 157.85,145.62 157.59,145.36 157.46,145.36 157.34,145.48 157.34,145.61 157.6,145.87 157.6,146 157.47,146.12 157.35,146.12 157.08,145.86 156.96,145.86 156.83,145.99 156.83,146.11 157.09,146.37 157.09,146.5 156.81,146.78 156.45,146.78 155.94,147.29 150.72,147.29 150.63,147.19 140.66,147.19 139.77,148.08 139.77,149.12 138.95,149.93 138.95,154.53 138.39,155.09 137.42,155.09 136.92,155.59 136.59,155.59 135.65,154.66 130.4,154.66 129.11,155.94 v2(129.11,157.09)
  BOTTOM w0.114: R68.1 128.13,157.09 v2(129.11,157.09) ; PR7019.1 v1(166.34,149.49)
H_CPU_SVIDDAT_R: length 8.5
  BOTTOM w0.079: 127.72,157.3 127.61,157.19 127.35,157.19 126.89,156.73 R68.2 126.24,155.99 126.24,155.37 124.97,154.1 122.47,154.1 U1.AA2
  BOTTOM w0.114: 127.72,157.3 127.89,157.47 128.19,157.47 128.42,157.7 R67.2
H_PROCHOT#: length 236
  TOP w0.114: Q6509.3 141.84,95.6 142.51,94.93 143.35,94.93 143.67,95.25 v1(143.67,95.41)
  IN3 w0.102: v1(167.51,120.56) 167.81,120.27 169.66,120.27 169.95,120.56 171.66,120.56 173.96,118.26 180.76,118.26 181.68,117.33 190.57,117.33 192.64,115.26 195.71,115.26 195.71,115.26 200.98,115.26 204.34,111.9 206.4,111.9 206.4,111.9 206.74,111.9 208.18,110.45 208.18,104.39 207.22,103.43 206.28,103.43 205.42,102.57 205.42,101.31 203.86,99.75 203.86,98.8 200.77,95.7 197.11,95.7 196.42,95.02 153.34,95.02 152.65,95.7 150.6,95.7 150.38,95.48 149.51,95.48 148.48,96.51 144.44,96.51 143.67,95.74 v1(143.67,95.41)
  IN4 w0.089: v1(167.51,120.56) 167.3,120.78 167.3,122.05 166.91,122.44 166.91,123.13 166.42,123.62 166.42,124.88 167.56,126.02 167.56,129.04 169.01,130.48 169.01,132.43 168.24,133.2 168.24,134.94 169.19,135.89 169.19,138.3 168.63,138.87 168.63,139.84 168.2,140.26 168.2,141.25 168.68,141.73 168.68,142.46 168.24,142.9 168.24,144.43 169.32,145.5 169.32,149.71 168.9,150.12 v1(168.58,150.12) 168.58,149.34 164.44,145.21 161.96,145.21 161.66,144.91 161.66,144.26 160.59,143.19 158.97,143.19 156.15,146 156.15,146.41 155.75,146.82 150.92,146.82 148.02,143.92 140.89,143.92 139.3,145.51 139.3,148.91 138.47,149.73 138.47,154.34 138.19,154.62 136.52,154.62 136.08,154.18 130.15,154.18 128.59,155.73 128.59,157.42 128.85,157.67 130.13,157.67 v2(130.29,157.83)
  BOTTOM w0.114: PU1.10 161.12,119.75 161.8,119.07 PR22.1 162.52,118.57 162.76,118.32 162.95,118.32 163.32,117.94 163.32,117.73 163.46,117.59 165.05,117.59 166.23,118.78 166.23,119.47 167.32,120.56 v1(167.51,120.56) ; v1(168.58,150.12) 166.01,150.12 165.48,149.6 PR7012.2 ; R23.1 130.61,157.83 v2(130.29,157.83) 130.29,158.52 129.88,158.93 C6618.2 129.09,158.93 R9.1
H_THRMDA1: length 74.5
  TOP w0.114: Q6544.3 140.28,159.7 Q6544.2 138.11,159.43 138.11,156.4 137.18,155.47 v1(137.11,155.47) 137.03,155.47 v1(136.6,155.04)
  IN3 w0.102: v1(136.6,155.04) 136.15,154.59 130.51,154.59 127.54,157.57 127.54,159.67 126.83,160.37 126.83,162.7 125.57,163.96 125.57,167.95 123.25,170.27 122.03,170.27 113.84,178.46 113.84,179.86 112.82,180.89 112.82,181.21 110.33,183.71 105.04,183.71 101.81,186.94 99.41,186.94 98.18,188.17 95.23,188.17 v1(94.52,187.45)
  BOTTOM w0.114: v1(94.52,187.45) 94.52,187.14 94.31,186.94 C96270.1 93.14,186.94 93.06,186.86 U2.2
H_THRMDC1: length 71
  TOP w0.114: Q6544.1 139.02,158.75 138.38,158.11 138.38,156.29 137.72,155.64 137.72,155.32 136.65,154.25 v1(136.65,154.11)
  IN3 w0.102: v1(136.65,154.11) 136.39,154.36 130.42,154.36 127.31,157.47 127.31,159.57 126.6,160.28 126.6,162.61 124.6,164.61 124.6,165.43 122.37,167.66 122.37,169.61 113.62,178.37 113.62,179.77 112.34,181.04 111.33,181.04 109.13,183.24 107.43,183.24 106.86,182.67 105.76,182.67 101.72,186.71 99.32,186.71 98.09,187.94 95.66,187.94 v1(95.18,187.46)
  BOTTOM w0.114: v1(95.18,187.46) 95.18,187.2 v1(94.39,186.41) 94.31,186.49 C96270.2 93.27,186.49 92.99,186.21 U2.3
H_VCCST_PWRGD: length 9.1
  BOTTOM w0.102: U1.BJ2 122.21,136.78 123.27,137.84 125.81,137.84
  BOTTOM w0.114: v1(129.59,139.75) 129.5,139.65 R2228.1 128.73,138.15 C2542.2 127.75,138.15 127.44,137.84 125.81,137.84
HDD_INTA: length 3.3
  TOP w0.254: U6515.6 144.27,214.9 144.6,215.23 TP13170.1
HDMI_CRT_SW: length 1.2
  TOP w0.114: R67597.1 33.43,120.19 33.07,120.55 TP13171.1
HDMI_EQ0: length 4.8
  TOP w0.114: U23.8 21.42,144.6 21.09,144.93 20.45,144.93 v1(20.35,145.03) 20.35,145.87 R749.1 20.86,146.39 20.86,147.32 R746.1
HDMI_EQ1: length 4.3
  TOP w0.114: U23.2 24.42,145.61 R748.1 24.25,146.38 R747.1
HDMI_HPD: length 15.3
  TOP w0.102: v1(24.06,136.01) 23.71,136.37 R67387.2 ; R67385.2 v1(17.74,133.08)
  BOTTOM w0.102: v1(24.06,136.01) 24.06,135.16 22.84,133.93 22.15,133.93 21.92,134.16 21.31,134.16 20.23,133.08 v1(17.74,133.08) 17.74,133.9 16.92,134.72 R1250.2 16.24,134.34 16.41,134.18 VC2.1 R25297.1
HDMI_HPD_C: length 5.9
  BOTTOM w0.102: CN37.19 11.96,133.39 13.66,133.39 14.28,132.77 C616.1 15.07,132.77 15.11,132.81 R25297.2
HDMI_HPD_CON: length 168.2
  TOP w0.102: v1(33.16,133.77) 33.63,133.3 R67398.1 ; v1(23.62,148.76) 23.15,148.29 v1(23.15,147.98) 23.15,147.15 R67386.1
  IN1 w0.102: v1(121.31,120.05) 121.31,119.63 120.98,119.29 120.98,118.23 118.3,115.56 115.48,115.56 115.22,115.3 112.67,115.3 111.37,114 111.37,112.91 111.09,112.63 110.05,112.63 109.99,112.69 109.27,112.69 109.09,112.51 107.93,112.51 107.65,112.79 104.66,112.79 103.28,111.42 102.43,111.42 100.33,109.32 97.4,109.32 97.02,108.94 93.94,108.94 92.9,107.9 89.95,107.9 87.99,105.94 84.09,105.94 82.74,104.58 80.72,104.58 80.05,103.92 79.24,103.92 78.87,103.56 78.87,103.24 77.93,102.3 76.76,102.3 76.31,101.86 76.31,98.54 75.59,97.82 75.35,97.82 74.67,97.14 74.67,96.83 73.82,95.98 v1(73.18,95.98)
  IN3 w0.102: v1(33.16,133.77) 33.64,134.25 33.64,142.5 33.23,142.91 33.23,146.27 32.76,146.74 32.76,147.44 31.88,148.32 24.06,148.32 v1(23.62,148.76)
  IN4 w0.102: v1(33.16,133.77) 33.16,131.77 32.41,131.02 32.41,129.63 31.7,128.92 31.7,126.14 33.94,123.9 33.94,121.96 33.26,121.28 33.26,115.07 36.2,112.13 36.2,102.65 38.37,100.48 42.59,100.48 43.22,101.11 49.16,101.11 54.44,95.82 56.88,95.82 58.09,94.61 67.61,94.61 68.68,95.68 72.88,95.68 v1(73.18,95.98)
  BOTTOM w0.079: v1(121.31,120.05) 121.31,120.47 120.8,120.98 120.8,121.46 120.55,121.71 120.17,121.71 120.04,121.84 120.04,122.13 U1.CN6
HDMI_HPD_R: length 1.9
  TOP w0.114: U23.21 23.42,137.54 R67387.1
HDMI_IN_CLK: length 148
  TOP w0.102: C816.1 22.01,132.73 21.87,132.73 v1(21.58,133.02)
  IN1 w0.102: v2(119.88,152.23) 120,152.23 120.06,152.29 120.06,152.52 119.77,152.81 119.77,155.86 119.45,156.18 118.14,156.18 117.67,156.65 117.67,156.84 117.32,157.2 115.02,157.2 113.46,158.76 113.46,165.38 112.98,165.87 109.72,165.87 109.61,165.76 107.9,165.76 107.03,166.64 104.14,166.64 103.99,166.79 102.57,166.79 101.82,167.54 90.76,167.54 90.47,167.83 72.13,167.83 65.25,174.71 63.09,174.71 62.14,175.67 59.11,175.67 57.98,174.54 50.65,174.54 50.14,175.04 45.07,175.04 40.32,170.29 40.32,166.47 35.85,162 34.91,162 34.38,161.48 33.64,161.48 30.07,157.91 30.07,156.11 28.68,154.71 28.68,150.11 28.08,149.51 28.08,143.79 28.56,143.31 28.56,139.42 26.15,137.01 24.34,137.01 23.39,136.07 23.39,134.12 22.56,133.29 21.73,133.29 21.58,133.13 v1(21.58,133.02)
  BOTTOM w0.079: v2(119.88,152.23) 119.88,151.78 119.84,151.73 U1.AE6
HDMI_IN_CLK#: length 148
  TOP w0.102: C817.1 20.89,133 v1(21.58,133.68)
  IN1 w0.102: v2(120.46,152.24) 120.26,152.44 120.26,152.6 119.97,152.9 119.97,155.95 119.53,156.38 118.22,156.38 117.87,156.73 117.87,156.93 117.4,157.4 115.11,157.4 113.67,158.84 113.67,165.47 113.06,166.07 109.63,166.07 109.53,165.97 107.98,165.97 107.11,166.84 104.22,166.84 104.07,166.99 102.66,166.99 101.91,167.74 90.85,167.74 90.56,168.03 72.22,168.03 65.33,174.92 63.17,174.92 62.22,175.87 59.03,175.87 57.9,174.74 50.73,174.74 50.22,175.25 44.99,175.25 40.12,170.37 40.12,166.55 35.77,162.21 34.82,162.21 34.3,161.68 33.56,161.68 29.87,157.99 29.87,156.19 28.48,154.8 28.48,150.2 27.88,149.6 27.88,143.7 28.35,143.23 28.35,139.5 26.07,137.22 24.25,137.22 23.19,136.15 23.19,134.21 22.47,133.49 21.77,133.49 v1(21.58,133.68)
  BOTTOM w0.102: U1.AE5 120.17,151.94 v2(120.46,152.24)
HDMI_IN_D0: length 148.6
  TOP w0.102: v1(23.98,132.87) 24.56,132.87 C814.1
  IN1 w0.102: v1(23.98,132.87) 24.18,133.07 25.66,133.07 25.84,133.26 25.84,134.11 25.65,134.31 24.25,134.31 24.15,134.41 24.15,135.06 24.33,135.24 25.29,135.24 29.56,139.5 29.56,147.24 32.1,149.78 32.1,155.94 32.94,156.79 32.94,159.21 34.53,160.8 38.26,160.8 40.99,163.52 40.99,170.03 45.4,174.43 49.89,174.43 50.42,173.9 58.2,173.9 59.36,175.06 61.86,175.06 62.81,174.1 64.92,174.1 72.78,166.25 99.81,166.25 100.91,165.14 108.65,165.14 110.09,163.71 110.09,158.4 112.26,156.23 117.19,156.23 117.63,155.79 117.63,154.57 118.71,153.49 118.71,151.33 119.24,150.8 119.91,150.8 120.37,151.25 v2(120.42,151.25)
  BOTTOM w0.102: U1.AF5 120.17,150.85 120.42,151.1 v2(120.42,151.25)
HDMI_IN_D0#: length 148.6
  TOP w0.102: C853.1 23.45,133 v1(23.98,133.53)
  IN1 w0.102: v1(23.98,133.53) 23.98,133.34 24.04,133.27 25.57,133.27 25.64,133.34 25.64,134.03 25.56,134.1 24.16,134.1 23.95,134.32 23.95,135.14 24.24,135.44 25.21,135.44 29.35,139.58 29.35,147.33 31.89,149.87 31.89,156.03 32.74,156.87 32.74,159.29 34.45,161 38.18,161 40.79,163.61 40.79,170.11 45.31,174.64 49.97,174.64 50.51,174.1 58.12,174.1 59.28,175.26 61.94,175.26 62.89,174.31 65,174.31 72.86,166.45 99.89,166.45 100.99,165.35 108.74,165.35 110.29,163.79 110.29,158.49 112.34,156.43 117.27,156.43 117.83,155.88 117.83,154.66 118.91,153.58 118.91,151.42 119.33,151 119.74,151 119.84,151.09 119.84,151.23 v2(119.79,151.28)
  BOTTOM w0.102: U1.AF6 119.72,150.81 119.88,150.98 119.88,151.18 v2(119.79,151.28)
HDMI_IN_D1: length 148.4
  TOP w0.102: v1(26.41,132.85) 26.56,133 C812.1
  IN1 w0.102: v2(119.74,149.4) 119.82,149.4 120.01,149.59 120.01,149.68 119.9,149.79 119.52,149.79 119.45,149.72 118.03,149.72 117.64,150.12 117.64,151.43 117.44,151.63 116.83,151.63 116.58,151.88 115.56,151.88 109.43,158.01 109.43,163.5 108.41,164.52 99.75,164.52 99.27,165 73.16,165 64.67,173.49 62.56,173.49 61.61,174.45 59.62,174.45 58.46,173.29 50.06,173.29 49.53,173.82 45.69,173.82 41.66,169.79 41.66,163.11 32.75,154.2 32.75,149.55 30.99,147.79 30.99,146.38 30.19,145.59 30.19,139.17 29.39,138.37 29.39,138.18 29.5,138.07 29.86,138.07 30.09,137.85 30.09,137.23 29.86,137.01 28.11,137.01 28.01,136.9 28.01,136.43 28.11,136.33 29.4,136.33 29.7,136.03 29.7,135.5 29.39,135.19 26.84,135.19 26.73,135.08 26.73,134.44 26.85,134.32 27.92,134.32 28.15,134.08 28.15,133.34 27.87,133.05 26.61,133.05 v1(26.41,132.85)
  BOTTOM w0.102: U1.AJ6 119.32,149.16 119.32,149.36 119.38,149.42 119.71,149.42 v2(119.74,149.4)
HDMI_IN_D1#: length 148.4
  TOP w0.102: C96255.1 25.9,133 v1(26.41,133.51)
  IN1 w0.102: v1(26.41,133.51) 26.66,133.26 27.78,133.26 27.95,133.43 27.95,134 27.83,134.12 26.77,134.12 26.53,134.36 26.53,135.17 26.76,135.39 29.31,135.39 29.49,135.58 29.49,135.95 29.32,136.12 28.02,136.12 27.8,136.35 27.8,136.99 28.02,137.21 29.77,137.21 29.88,137.32 29.88,137.76 29.78,137.86 29.42,137.86 29.19,138.09 29.19,138.46 29.99,139.25 29.99,145.67 30.78,146.47 30.78,147.87 32.55,149.64 32.55,154.28 41.46,163.19 41.46,169.88 45.61,174.03 49.61,174.03 50.15,173.49 58.37,173.49 59.53,174.65 61.69,174.65 62.64,173.7 64.75,173.7 73.24,165.21 99.35,165.21 99.83,164.72 108.49,164.72 109.64,163.58 109.64,158.09 115.65,152.08 116.66,152.08 116.91,151.83 117.52,151.83 117.84,151.51 117.84,150.2 118.11,149.93 119.37,149.93 119.43,149.99 119.99,149.99 120.22,149.76 120.22,149.58 v2(120.37,149.42)
  BOTTOM w0.102: U1.AJ5 120.17,149.22 v2(120.37,149.42)
HDMI_IN_D2: length 146.9
  TOP w0.102: C96258.1 29.52,132.86 29.35,132.69 29.07,132.69 v1(28.82,132.94)
  IN1 w0.102: v1(28.82,132.94) 28.82,133.1 28.91,133.18 29.41,133.18 30.88,134.64 30.88,145.33 31.75,146.2 31.75,147.46 33.41,149.12 33.41,152.39 34.97,153.95 34.97,155.07 35.43,155.53 35.43,156.01 36.59,157.17 40.89,157.17 41.17,157.46 41.17,158.2 40.86,158.51 39.36,158.51 39.26,158.61 39.26,159.23 39.41,159.38 39.95,159.38 40.23,159.66 40.23,160.81 42.29,162.87 42.29,168.82 45.27,171.8 47.35,171.8 47.99,171.17 49.77,171.17 51.28,172.68 58.71,172.68 59.87,173.84 61.33,173.84 62.31,172.85 64.44,172.85 72.95,164.35 98.99,164.35 99.44,163.9 108.14,163.9 108.39,163.65 108.39,163.18 108.34,163.13 108.34,160.31 107.66,159.63 107.66,154.88 110.69,151.84 113.7,151.84 116.13,149.41 117.02,149.41 117.74,148.69 117.74,148.26 118.1,147.9 118.67,147.9 119.53,148.75 119.75,148.75 119.81,148.69 v2(119.81,148.46)
  BOTTOM w0.102: v2(119.81,148.46) 119.77,148.5 119.48,148.5 119.41,148.43 119.41,148.14 U1.AL6
HDMI_IN_D2#: length 146.9
  TOP w0.102: v1(28.82,133.6) 28.72,133.6 C811.1
  IN1 w0.102: v1(28.82,133.6) 29.04,133.38 29.33,133.38 30.67,134.73 30.67,145.41 31.55,146.29 31.55,147.54 33.2,149.2 33.2,152.48 34.77,154.04 34.77,155.15 35.23,155.61 35.23,156.1 36.51,157.37 40.8,157.37 40.97,157.54 40.97,158.12 40.78,158.31 39.28,158.31 39.06,158.53 39.06,159.32 39.33,159.59 39.86,159.59 40.02,159.75 40.02,160.89 42.08,162.95 42.08,168.9 45.18,172.01 47.43,172.01 48.07,171.37 49.69,171.37 51.2,172.88 58.63,172.88 59.79,174.04 61.41,174.04 62.4,173.06 64.53,173.06 73.04,164.55 99.08,164.55 99.53,164.1 108.23,164.1 108.59,163.73 108.59,163.1 108.54,163.05 108.54,160.23 107.86,159.55 107.86,154.96 110.78,152.04 113.78,152.04 116.21,149.61 117.1,149.61 117.94,148.77 117.94,148.34 118.19,148.1 118.59,148.1 119.44,148.96 119.9,148.96 v2(120.4,148.47)
  BOTTOM w0.102: U1.AL5 120.4,148.27 v2(120.4,148.47)
HDMI_MB_HPD_R: length 1.8
  TOP w0.102: U23.5 22.92,145.18 22.69,145.41 R67386.2
HDMI_SCLK: length 30.5
  TOP w0.102: CN37.15 11.34,130.77 11.34,131.82 11.67,132.15 12.35,132.15 12.8,131.7 12.8,131.3 13.06,131.04 D13089.2 15.22,131.04 C614.1 16.04,131.55 16.17,131.42 R490.2 16.56,130.6 v1(16.49,130.54) ; v1(30.98,122.19) 30.98,122.31 30.76,122.53 R67389.2
  IN3 w0.102: v1(16.49,130.54) 16.61,130.42 17.16,130.42 18.5,129.08 18.5,125.61 19.56,124.56 21.33,124.56 22.83,123.06 26.4,123.06 27.85,121.6 30.39,121.6 v1(30.98,122.19)
HDMI_SCLK_R: length 24.7
  TOP w0.114: v1(22.6,135.17) 22.18,135.6 22.18,137.46 22.42,137.7 U23.19 ; v1(31.7,122.29) R67389.1
  IN3 w0.102: v1(22.6,135.17) 22.91,134.86 22.91,134.27 22.21,133.57 22.21,130.03 23.75,128.49 27.84,128.49 31.24,125.09 31.24,123.3 31.91,122.63 31.91,122.5 v1(31.7,122.29)
HDMI_SDATA: length 26.1
  TOP w0.102: CN37.16 12.37,130.21 D13090.2 14.35,130.58 C613.1 15.56,130.58 R491.2 16.08,130.29 16.29,130.07 16.71,130.07 17.08,130.44 v1(17.08,131.02) ; R67388.2 30.73,121.76 v1(30.31,122.18)
  IN3 w0.102: v1(30.31,122.18) 30.13,122.01 28.02,122.01 26.56,123.46 23,123.46 21.5,124.96 19.72,124.96 18.91,125.78 18.91,129.25 17.13,131.02 v1(17.08,131.02)
HDMI_SDATA_R: length 25.3
  TOP w0.114: v1(22.67,135.85) 22.67,137.21 22.92,137.46 U23.20 ; v1(31.71,121.55) 31.7,121.56 R67388.1
  IN3 w0.102: v1(31.71,121.55) 32.14,121.97 32.14,122.73 31.47,123.39 31.47,125.18 27.93,128.72 23.84,128.72 22.44,130.13 22.44,133.47 23.14,134.17 23.14,135.38 v1(22.67,135.85)
HOLD#: length 6.1
  BOTTOM w0.114: R109.2 117.23,106.55 117.61,106.16 R107.2 118.41,106.16 118.77,106.52 TP19.1 119.41,107.44 120.07,108.1 CN59.7 U6528.7 CN60.7
HOOK3: length 2.8
  BOTTOM w0.114: R222.2 118.98,100.5 118.9,100.43 TP55.1 118.37,100.91 118.7,101.24 C248.2 R221.1
HP-L2: length 20.1
  IN1 w0.381: v1(14.85,22.28) 14.85,24.82 15.2,25.17 15.2,26.02 13.07,28.14 13.07,32.52 13.23,32.68 v1(13.23,32.99)
  BOTTOM w0.203: v1(13.23,32.99) 13.26,32.96 13.68,32.96 14.15,32.48 v1(14.28,32.48) 14.36,32.48 14.88,33.01 U20.32
  BOTTOM w0.381: v1(14.85,22.28) 14.85,22.9 C589.2 15.37,22.87 15.37,22.73 15.71,22.39 R476.2 16.64,22.26 R474.1 16.61,21.56 R472.2
HP-L3: length 14
  BOTTOM w0.381: R472.1 C96266.1 C592.2 13.93,19.53 13.61,19.85 v1(13.61,24.93) 12.45,26.09 9.25,26.09 CN51.4
HP-R2: length 28.3
  TOP w0.381: v1(18.41,22.53) 17.69,22.53 16.44,23.77 15.46,23.77 v1(15.42,23.82) 15.1,24.13 15.1,25.49 14.34,26.25 14.21,26.25 13.47,27 11.31,27 10.93,27.37 v1(10.93,28.43)
  IN1 w0.381: v1(14.22,33.13) 14.32,33.02 14.32,30.31 15.19,29.43 15.19,28.91 15.62,28.49 15.62,27.9 16.57,26.95 16.57,25.15 v1(15.88,24.46)
  BOTTOM w0.203: v1(14.22,33.13) 14.4,33.31 15.74,33.31 15.84,33.41 U20.33
  BOTTOM w0.381: v1(18.41,22.53) R475.1 17.56,22.62 R477.2 17.1,23.86 C594.2 16.48,23.86 v1(15.88,24.46) ; R473.2 10.49,28.87 v1(10.93,28.43)
HP-R3: length 8.6
  BOTTOM w0.381: CN51.3 6.08,25.61 8.32,27.85 C96267.1 C593.2 R473.1 10.28,27.77 10.49,27.56 11.51,27.56 v1(11.69,27.73)
HP_JD#: length 21.8
  TOP w0.381: v1(12.14,15.26) 11.97,15.09 11.23,15.08 10.86,14.71 D13095.1 10.16,14.71 v1(9.6,15.28) 9.17,15.71 CN51.6
  IN1 w0.381: v1(12.14,15.26) 12.3,15.41 12.98,15.41 21.31,23.74 21.31,26.79 v1(21.62,27.1)
  BOTTOM w0.381: v1(21.62,27.1) 22.03,27.1 22.19,26.94 R451.2
HWPG: length 83.8
  TOP w0.114: R2257.2 91.9,105.97 v1(91.95,105.91) ; U37.21 v1(150.1,101.54) ; R25524.2 139.58,100.15 139.88,100.45 140.69,100.45 v1(141.18,100.94) 141.28,100.83 141.28,100 R25312.1 141.66,99.87 142.07,100.28 D62.2 141.87,101.37 v1(141.87,102.39) 142.68,103.21 D60.2 141.21,103.6 D51.2 140.1,103.59 139.75,103.25 D64.2
  IN3 w0.102: v1(150.1,101.54) 148.35,99.79 142.51,99.79 141.36,100.94 v1(141.18,100.94) 140.66,101.45 135.94,101.45 135.41,101.98 130.01,101.98 128.98,100.95 123.42,100.95 121.84,99.37 117.61,99.37 116.9,98.65 113.43,98.65 v1(110.99,96.21)
  IN4 w0.089: v1(91.95,105.91) 92.83,105.91 94.11,104.64 94.84,104.64 96.08,103.4 101.87,103.4 103.07,104.59 103.07,105.02 103.4,105.35 105.27,105.35 106.38,104.23 106.38,103.86 108.25,101.99 108.25,99.27 109.3,98.22 109.75,98.22 110.99,96.99 v1(110.99,96.21)
HWPG_1.5V: length 198
  TOP w0.114: R25524.1 v1(139.58,98.24) 139.58,97.63 140.74,96.46 142.31,96.46 143.01,95.76 v1(143.01,95.39)
  IN2 w0.102: v1(143.01,95.39) 142.47,95.39 142.39,95.48 138.46,95.48 137.74,96.2 121.95,96.2 120.62,94.87 98.62,94.87 98.01,95.48 93.13,95.48 92.5,94.84 79.06,94.84 78.3,94.08 75.76,94.08 73.62,91.94 68.79,91.94 67.99,92.75 57.09,92.75 56.29,91.94 38.17,91.94 35.02,88.8 35.02,87.7 32.37,85.05 32.37,78.47 30.47,76.57 30.47,64.12 31.28,63.31 31.28,54.5 30.47,53.69 30.47,45.24 27.48,42.24 25.4,42.24 25.32,42.32 12.94,42.32 12.86,42.24 11.08,42.24 6.35,37.5 6.35,34.28 5.64,33.57 v1(5.64,33.2)
  BOTTOM w0.114: PR284.1 5.29,32.56 5.3,32.57 PR6416.2 5.55,33.11 v1(5.64,33.2)
HWPG_1.8VS5: length 160.2
  TOP w0.114: v1(140.52,100.94) 140.29,101.16 D62.1 ; v1(37.8,144.91) 38.21,144.91 38.38,145.08 v1(38.38,145.28) 38.25,145.42 PR9255.2 37.29,145.42 36.91,145.79 PR9256.1
  IN1 w0.089: v1(37.8,144.91) 38.76,144.91 39.86,143.81 39.86,133.31 39.3,132.76 37.43,132.76 35.49,130.81 35.49,127.9 37.41,125.97 38.84,125.97 42.08,122.73 42.71,122.73 v1(43.25,122.19)
  IN3 w0.102: v1(111.65,96.21) 113.68,98.24 117.07,98.24 117.78,98.96 122.01,98.96 123.59,100.54 129.15,100.54 130.18,101.57 135.24,101.57 135.77,101.04 140.41,101.04 v1(140.52,100.94)
  IN4 w0.089: v1(43.25,122.19) 42.7,121.64 42.7,115.68 42.5,115.48 42.5,109.03 44.64,106.89 44.64,104.86 46.22,103.27 46.22,102.64 46.97,101.89 49.56,101.89 54.85,96.6 57.2,96.6 58.42,95.39 67.28,95.39 68.36,96.47 70.93,96.47 71.71,97.25 74.09,97.25 75.08,96.25 75.99,96.25 76.94,97.2 81.03,97.2 81.68,96.55 83.1,96.55 83.67,97.13 84.51,97.13 85.23,96.41 88.18,96.41 89.04,97.27 91.96,97.27 92.31,96.92 97.84,96.92 98.03,97.11 100.72,97.11 102.12,95.71 111.15,95.71 v1(111.65,96.21)
HWPG_1.35VGFX: length 256.9
  TOP w0.114: R25468.1 78.14,116.08 77.55,115.49 77.55,108.4 v1(77.83,108.12) 78.32,107.63 v1(78.38,107.63)
  TOP w0.203: PR9088.2 167.65,157.34 v2(167.08,156.78) 167.19,156.67 167.45,156.67 167.66,156.47 PR9090.1
  IN3 w0.102: v1(174.86,120.58) 175.31,121.03 175.68,121.03 175.96,120.76 175.96,120.47 177.5,118.92 180.99,118.92 181.95,117.97 191.81,117.97 192.57,117.2 204.6,117.2 208.18,113.62 208.18,111.35 208.82,110.72 208.82,104.13 207.71,103.02 207.71,102.31 205.64,100.24 205.64,96.61 203.41,94.38 142.9,94.38 138.53,98.76 134.49,98.76 134.31,98.94 124.25,98.94 122.67,97.36 121.09,97.36 119.79,96.06 118.88,96.06 118.23,95.41 117.58,95.41 v1(116.93,96.06)
  IN4 w0.089: v2(167.08,156.78) 169.18,154.68 169.18,152.08 171.05,150.22 171.05,149.8 172.16,148.69 172.16,147.76 170.59,146.2 170.59,144.22 170.27,143.9 170.27,140.64 169.91,140.28 169.91,139.54 171.07,138.38 171.07,137.75 172.43,136.4 172.43,132.64 172.26,132.47 172.26,131.12 172.57,130.81 172.57,129.11 176.39,125.3 177.63,125.3 177.77,125.15 177.77,124.47 174.86,121.57 v1(174.86,120.58) ; v1(78.38,107.63) 80.52,107.63 80.93,108.04 85.17,108.04 87.24,110.12 91.55,110.12 92,109.67 92.28,109.67 92.82,109.13 92.82,107.39 94.31,105.9 99.77,105.9 101.03,107.16 104.55,107.16 106.32,105.39 106.76,105.39 107.16,104.99 107.16,103.9 108.84,102.23 108.84,100.15 112.34,96.65 116.34,96.65 v1(116.93,96.06)
HWPG_1VS5: length 103.7
  TOP w0.114: v1(142.35,106.73) 141.96,106.35 141.96,105.39 141.42,104.85 D64.1 ; v1(179.21,112.85) 179.21,117.51 v1(178.79,117.93) 178.79,117.97 177.7,119.06 177.7,121.42 178.26,121.98 178.51,121.98 v1(178.97,122.44)
  IN3 w0.102: v1(179.21,112.85) 179.01,112.65 174.94,112.65 171.69,109.4 170.13,109.4 169.5,110.03 169.5,110.36 168.09,111.77 165.74,111.77 164.87,110.9 153.09,110.9 152.54,111.45 151.87,111.45 149.57,109.15 149.57,108.76 148.63,107.83 148.63,107.6 146.92,105.89 142.8,105.89 142.35,106.35 v1(142.35,106.73)
  IN4 w0.089: v1(145.17,129.73) 145.61,129.29 145.87,129.29 146.4,128.76 147.92,128.76 149.63,127.06 149.63,125.89 151.35,124.17 155.47,124.17 156.72,122.92 161.04,122.92 161.5,122.46 161.5,122.21 163.09,120.62 163.09,118.65 164,117.74 165.72,117.74 165.96,117.5 168.37,117.5 168.88,118.02 169.2,118.02 169.68,118.5 171.92,118.5 173.2,119.78 175.83,119.78 176.99,120.94 176.99,122.44 177.45,122.9 178.5,122.9 v1(178.97,122.44)
  BOTTOM w0.114: v1(145.17,129.73) 145.17,129.7 145.57,129.3 PR275.2
  BOTTOM w0.203: PR276.1 PR275.2
HWPG_VDDR: length 213.8
  TOP w0.114: PR5009.1 72.39,182.34 72.01,181.96 71.5,181.96 70.8,181.26 PR5006.1 72.46,180.46 72.84,180.09 72.84,178.6 v1(72.4,178.16) ; v1(179.64,122.49) 180.12,122.01 180.12,119.93 v1(179.89,119.71) v1(179.89,112.77) ; D51.1 141.2,106.25 v1(141.69,106.73)
  IN1 w0.089: v1(72.4,178.16) 72.99,177.57 72.99,176.91 75.61,174.29 91.39,174.29 96.16,179.06 98.67,179.06 100.35,177.39 103.57,177.39 103.87,177.09 110.24,177.09 111.17,176.17 115.98,176.17 117.68,174.46 118.9,174.46 123.96,169.39 125.02,169.39 126.35,168.06 126.35,166.14 126.99,165.49 126.99,164.9 129.85,162.05 130.47,162.05 132.15,160.37 132.15,158.65 131.68,158.18 131.68,156.5 132.03,156.16 132.03,155.16 133.92,153.27 134.89,153.27 140.04,148.12 140.04,134.22 141.73,132.53 142.28,132.53 142.44,132.36 146.51,132.36 150.5,128.37 150.5,126.39 151.63,125.27 163.94,125.27 165.46,123.75 167.77,123.75 169.3,122.22 173.65,122.22 174.18,122.76 175.34,122.76 175.65,123.06 179.06,123.06 v1(179.64,122.49)
  IN3 w0.102: v1(141.69,106.73) 142.24,107.29 143.89,107.29 145.06,106.12 146.83,106.12 148.4,107.69 148.4,107.92 148.64,108.16 148.64,109.19 151.13,111.68 152.63,111.68 153.19,111.13 164.78,111.13 165.65,112 168.18,112 169.73,110.45 169.73,110.12 170.22,109.63 171.6,109.63 174.85,112.87 178.62,112.87 179.03,113.28 179.39,113.28 179.89,112.78 v1(179.89,112.77)
I2C8_SCL: length 162.7
  TOP w0.114: R67854.2 95.06,109.3 v1(95.06,110.1) ; R67875.1 147.99,214.67 v1(148.43,214.24) 150.45,214.24 150.73,213.97 v1(151.03,213.97) 151.25,214.18 Q6567.1
  IN1 w0.089: v1(148.43,214.24) 148.26,214.4 146.1,214.4 144.2,212.5 141.69,212.5 140.31,213.88 135.17,213.88 134.71,214.34 132.3,214.34 131.27,215.37 128.18,215.37 124.91,212.11 121.71,212.11 120.79,211.19 120.79,209.61 119.46,208.28 118.69,208.28 115.69,205.29 115.69,197.11 114.31,195.73 114.31,189.89 111.49,187.07 v1(111.49,186.65)
  IN3 w0.102: v1(111.61,172.19) 111.86,171.94 111.86,167.53 113.26,166.12 113.26,159.22 111.93,157.89 111.93,135.43 113.33,134.03 113.33,133.77 113.17,133.61 113.17,131.63 113.56,131.24 113.56,127.03 112.55,126.02 112.02,126.02 111.58,125.58 111.04,125.58 110.29,124.84 108.94,124.84 108.84,124.74 107.67,124.74 107.33,125.08 104.61,125.08 v2(104.19,124.66) 103.82,124.29 102.39,124.29 102.31,124.21 101.4,124.21 99.77,122.58 99.21,122.58 97.83,121.2 97.83,120.3 93.66,116.13 93.66,110.68 94.28,110.06 95.02,110.06 v1(95.06,110.1)
  IN4 w0.089: v1(111.49,186.65) 113.39,184.76 113.39,173.56 112.02,172.19 v1(111.61,172.19)
  BOTTOM w0.079: v2(104.19,124.66) 103.88,124.35 U1.CJ31
I2C8_SDA: length 164.7
  TOP w0.114: v1(148.42,217.19) 147.88,217.19 v1(147.76,217.07) 147.51,216.82 147.51,216.69 147.15,216.33 R67873.1 147.15,216.06 147.51,215.7 148.23,215.7 148.45,215.93 148.69,215.93 149.22,216.46 Q6567.4 ; R67853.2 94.71,109.62 94.53,109.81 v1(94.53,110.49)
  IN1 w0.089: v1(112.17,186.66) 112.17,187.47 114.5,189.81 114.5,195.65 115.88,197.03 115.88,205.21 118.76,208.09 119.54,208.09 120.98,209.53 120.98,211.11 121.79,211.92 124.99,211.92 128.26,215.18 131.19,215.18 132.22,214.15 134.64,214.15 135.09,213.69 140.23,213.69 141.61,212.31 144.28,212.31 146.18,214.21 147.85,214.21 148.23,213.84 148.67,213.84 148.87,214.04 148.87,214.46 148.26,215.07 148.26,217.03 v1(148.42,217.19)
  IN3 w0.102: v1(112.66,172.27) 112.09,171.69 112.09,167.62 113.49,166.22 113.49,159.13 112.16,157.79 112.16,135.53 113.53,134.15 113.53,133.68 113.38,133.53 113.38,131.71 113.76,131.33 113.76,126.94 112.61,125.79 112.08,125.79 111.67,125.38 111.12,125.38 110.38,124.63 109.02,124.63 108.93,124.53 107.55,124.53 107.27,124.25 105.21,124.25 v2(104.79,124.67) 104.21,124.09 102.48,124.09 102.39,124.01 101.79,124.01 101.76,123.98 101.5,123.98 99.87,122.35 99.3,122.35 98.06,121.11 98.06,120.2 93.89,116.04 93.89,110.78 94.17,110.49 v1(94.53,110.49)
  IN4 w0.089: v1(112.17,186.66) 112.17,186.26 113.58,184.84 113.58,173.48 112.66,172.57 v1(112.66,172.27)
  BOTTOM w0.079: U1.CJ30 104.53,124.41 v2(104.79,124.67)
I2C_SCL: length 82.1
  TOP w0.114: Q6556.3 63.62,94.12 63.74,94 R67570.1 63.74,93.35 63.97,93.12 63.97,92.09 v1(63.65,91.77) ; v1(96.97,109.54) 96.95,109.53 R67860.2
  IN1 w0.089: v1(63.65,91.77) 64.78,90.64 75.94,90.64 77.4,92.1 77.4,92.79 79.17,94.57 92.79,94.57 93.47,95.25 94.99,95.25 v1(95.66,94.59)
  IN3 w0.102: v1(96.97,109.54) 96.96,109.54 96.46,110.05 96.38,110.05 94.45,111.98 94.45,115.95 100.45,121.95 104.48,121.95 106.02,123.49 v2(106.1,123.49)
  BOTTOM w0.079: v2(106.1,123.49) 106.13,123.53 106.13,124.89 U1.CH28
  BOTTOM w0.114: v1(96.97,109.54) 97.21,109.3 97.21,100.4 98.48,99.13 98.48,97.42 97.36,96.3 95.82,96.3 95.66,96.13 v1(95.66,94.59)
I2C_SDA: length 82.4
  TOP w0.114: R67859.2 96.18,109.52 v1(96.28,109.62) ; Q6559.3 61.39,92.93 61.37,92.91 R67564.1 61.74,92.02 v1(61.74,91.78)
  IN1 w0.089: v1(61.74,91.78) 63.08,90.45 76.02,90.45 77.59,92.02 77.59,92.71 79.25,94.38 92.86,94.38 93.55,95.06 94.52,95.06 v1(94.99,94.59)
  IN3 w0.102: v2(106.81,123.46) 106.35,123.92 105.87,123.92 105.69,123.75 105.69,123.48 104.39,122.18 100.35,122.18 94.22,116.04 94.22,111.88 96.28,109.83 v1(96.28,109.62)
  BOTTOM w0.079: v2(106.81,123.46) 106.81,123.93 106.79,123.94 106.79,124.41 106.48,124.73 U1.CH27
  BOTTOM w0.114: v1(94.99,94.59) 94.95,94.63 94.95,95.96 95.56,96.57 97.25,96.57 98.21,97.53 98.21,99.02 96.94,100.29 96.94,108.91 96.28,109.57 v1(96.28,109.62)
I2CA_SCL: length 10
  BOTTOM w0.102: U8.B7 124.33,182.86 124.33,182.11
  BOTTOM w0.305: R326.1 118.75,180.47 120.96,180.47 121.47,180.98 123.32,180.98 124.33,182 124.33,182.11
I2CA_SDA: length 8.6
  BOTTOM w0.305: R25492.1 118.16,178.82 119.38,180.04 121.13,180.04 121.67,180.58 123.52,180.58 124.79,181.85 124.79,182.38 U8.A7
I2CINT13: length 2.3
  TOP w0.079: U6516.B5 154.11,215.39 153.86,215.64
  TOP w0.114: v1(153.71,215.79) 153.86,215.64
  BOTTOM w0.114: v1(153.01,216.1) 153.11,216 153.5,216 v1(153.71,215.79) 153.76,215.84 R25644.1
I219_PCH_SMCLK: length 186.1
  TOP w0.102: v2(114.36,125.38) 114.36,125.36 113.73,124.72 113.73,123.18 114.01,122.9 114.01,122.61 115.87,120.74 115.87,119.66 116.25,119.29 R67529.1
  TOP w0.114: v1(12.61,162.37) 12.61,162.31 12.14,161.85 v1(11.97,161.85) 11.76,162.05 10.58,162.05 10.33,162.3 Q6554.4 10.33,163.25 10.22,163.36 9.35,163.36 R67525.1
  IN1 w0.089: v1(43.32,117.74) 41.63,119.43 38.73,119.43 37.81,118.51 35.12,118.51 34.84,118.8 29.05,118.8 28.26,118.01 23.93,118.01 22.9,119.05 22.9,119.63 21.47,121.05 21.47,123.05 21.04,123.47 21.04,128.56 v1(20.56,129.04)
  IN3 w0.102: v1(12.61,162.37) 12.8,162.17 12.8,160.56 14.02,159.34 14.99,159.34 15.67,158.66 15.67,155.06 20.82,149.9 20.82,138.07 19.6,136.84 19.6,134.15 20.33,133.42 20.33,129.66 20.56,129.44 v1(20.56,129.04) ; v2(114.36,125.38) 113.92,124.94 113.92,124.85 113.58,124.51 112.56,124.51 112.47,124.61 111.2,124.61 110.89,124.3 110.89,124.05 110.45,123.61 109.6,123.61 107.59,121.59 106.84,121.59 106.44,121.19 101.24,121.19 100.87,120.81 100.87,120.34 100.16,119.63 100.16,117.22 100.84,116.53 100.84,112.94 98.32,110.43 98.32,109.72 97.29,108.68 94.06,108.68 92.89,109.85 91,109.85 90.62,109.48 89.86,109.48 89.4,109.02 88.03,109.02 87.85,109.19 86.57,109.19 86.2,108.82 85.01,108.82 84.34,108.15 71.54,108.15 67.98,104.59 66.56,104.59 66.37,104.39 65.47,104.39 63.56,102.47 59.53,102.47 58.21,103.8 57.65,103.8 56.92,104.53 55.22,104.53 54.94,104.25 53.83,104.25 51.52,106.56 50.18,106.56 49.91,106.29 48.46,106.29 47.29,105.12 45.49,105.12 44.99,105.62 44.99,116.08 v1(43.32,117.74)
  BOTTOM w0.079: v2(114.36,125.38) 114.41,125.38 114.79,125.01 U1.CH14
I219_PCH_SMDATA: length 188.5
  TOP w0.102: R67530.1 115.52,119.21 115.67,119.37 115.67,120.67 114.05,122.29 113.87,122.29 112.8,123.36 112.8,124.14 113.4,124.73 113.46,124.73 113.72,125 113.72,125.51 v2(114.35,126.13)
  TOP w0.114: v1(12.64,164.66) 12.75,164.54 R67526.1 12.42,163.65 11.76,163.65 11.63,163.78 Q6554.1
  IN1 w0.089: v1(43.29,118.47) 41.99,119.77 38.58,119.77 37.66,118.86 35.26,118.86 34.98,119.14 28.91,119.14 28.12,118.35 24.08,118.35 23.24,119.19 23.24,119.77 21.81,121.2 21.81,123.19 21.39,123.61 21.39,128.96 v1(21.24,129.11)
  IN3 w0.102: v2(114.35,126.13) 113.72,125.5 113.72,124.94 113.5,124.71 112.65,124.71 112.55,124.81 111.12,124.81 110.68,124.38 110.68,124.13 110.36,123.81 109.31,123.81 107.43,121.93 106.68,121.93 106.25,121.51 101.06,121.51 100.51,120.96 100.51,120.49 99.8,119.78 99.8,117.07 100.49,116.38 100.49,113.09 97.97,110.57 97.97,109.87 97.14,109.04 94.21,109.04 93.04,110.21 90.85,110.21 90.48,109.83 89.71,109.83 89.25,109.37 88.18,109.37 88,109.55 86.43,109.55 86.05,109.17 84.86,109.17 84.19,108.51 71.4,108.51 67.84,104.95 66.42,104.95 66.22,104.74 65.33,104.74 63.41,102.83 59.68,102.83 58.36,104.15 57.8,104.15 57.07,104.89 55.08,104.89 54.79,104.6 53.98,104.6 51.67,106.91 50.03,106.91 49.77,106.64 48.31,106.64 47.14,105.47 45.64,105.47 45.34,105.77 45.34,116.64 43.51,118.47 v1(43.29,118.47) ; v1(12.64,164.66) 13.19,164.11 13.19,160.68 14.17,159.69 15.14,159.69 16.02,158.8 16.02,155.2 21.18,150.05 21.18,137.92 19.95,136.7 19.95,134.3 20.69,133.57 20.69,129.81 21.24,129.26 v1(21.24,129.11)
  BOTTOM w0.079: U1.CF15 113.84,126.26 113.94,126.16 114.29,126.16 114.31,126.13 v2(114.35,126.13)
  BOTTOM w0.114: v1(12.64,164.66) 12.61,164.69 v1(11.97,164.69)
I219_SMCLK: length 13.3
  TOP w0.114: U6521.28 16.31,167.01 15.53,167.79 15.53,169.06 15.07,169.52 14.26,169.52 13.91,169.17 R4023.1 13.05,168.97 v1(10.34,166.27) 10.33,166.25 Q6554.3 10.33,163.95 10.23,163.85 9.34,163.85 R67525.2
I219_SMDATA: length 8.1
  TOP w0.114: U6521.31 16.25,165.81 15.9,166.16 14.92,166.16 TP13162.1 13.84,165.77 13.75,165.87 R4024.1 13.27,165.76 13.27,163.73 R67526.2 12.7,163.16 11.99,163.16 Q6554.6
ICCINSERTN: length 17.3
  TOP w0.114: U6509.19 214.6,97.53 214.87,97.81 v1(214.87,99.32)
  BOTTOM w0.114: CN53.2 225.4,101.64 224.66,102.38 223.74,102.38 223.74,102.39 222.85,102.39 222.71,102.54 v1(220.88,102.54) 216.57,102.54 215.62,101.59 215.62,100.07 v1(214.87,99.32)
ICMNT: length 120.7
  TOP w0.114: v1(205.52,124.94) 203.27,122.69 202.93,122.69 v1(202.64,122.4) 202.19,121.95 202.19,110.05 202.9,109.35 202.9,107.52 200.62,105.24 200.62,103.43 200.98,103.06 200.98,102.03 199.47,100.51 199.47,96.81 198.31,95.65 197.21,95.65 196.33,94.78 171.98,94.78 C6564.2 170.84,94.98 169.59,94.98 169.32,95.25 169.32,96.01 168.27,97.06 168.27,97.47 167.79,97.94 U37.67
  IN3 w0.102: v1(205.52,124.94) 204.97,125.49 201.92,125.49 197.28,120.85 190.77,120.85 190.51,120.59 189.41,120.59 188.68,119.86 184.49,119.86 184.05,120.3 181.9,120.3 180.65,121.55 177.25,121.55 176.4,122.4 174.49,122.4 174.2,122.11 169.31,122.11 169.02,121.82 168.49,121.82 167.74,122.57 167.74,122.87 167.56,123.05 165.08,123.05 v1(164.87,123.26)
  BOTTOM w0.114: PC37.2 164.39,125.03 164.56,124.87 164.56,124.04 164.87,123.73 v1(164.87,123.26)
  BOTTOM w0.203: PR32.1 162.72,121.33 162.79,121.41
  BOTTOM w0.254: PC37.2 162.72,124.78 162.86,124.64 162.86,124.19 162.67,124 162.67,122.93 162.95,122.64 162.95,121.57 162.79,121.41
