# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_RXP6_C: length 9.4
  TOP w0.102: C382.2 127.9,207.75 127.9,206.24 127.09,205.43 127.09,202.5 128.07,201.51 128.07,200.65 v2(127.62,200.2)
  BOTTOM w0.102: U8.AB10 127.59,200.2 v2(127.62,200.2)
PEG_RXP7: length 101.3
  TOP w0.102: C6556.1 128.75,210.67 128.85,210.76 128.85,211.09 128.66,211.27 126.59,211.27 125.08,209.76 123.04,209.76 122.77,210.03 122.77,210.44 122.67,210.55 v1(122.47,210.55)
  IN4 w0.102: v2(119.82,132.74) 119.82,132.5 119.92,132.39 120.2,132.39 120.28,132.31 121.41,132.31 121.75,132.65 121.75,133.84 121.45,134.15 121.45,135.09 120.76,135.77 118.3,135.77 117.29,136.78 116.09,136.78 113.72,139.14 113.72,167.67 114.17,168.11 114.17,171.12 114.73,171.68 114.73,176.84 116.12,178.23 116.12,187.46 114.93,188.65 114.93,192.68 116.95,194.71 116.95,197.62 116.28,198.29 116.28,204.67 121.58,209.97 122.62,209.97 122.8,210.15 122.8,210.43 122.68,210.55 v1(122.47,210.55)
  BOTTOM w0.079: v2(119.82,132.74) 119.82,132.3 119.74,132.23 119.63,132.23 U1.BT6
PEG_RXP7_C: length 10
  TOP w0.102: C6556.2 128.54,210.09 128.77,210.09 128.83,210.04 128.83,209.24 128.68,209.09 128.68,207.52 128.59,207.44 128.59,204.77 128.92,204.44 128.92,202.46 128.68,202.21 128.68,201.91 128.62,201.85 v2(128.43,201.85)
  BOTTOM w0.102: v2(128.43,201.85) 128.43,201.58 128.3,201.45 U8.AD11
PEG_RXP8: length 107.2
  TOP w0.102: v1(128.33,212.57) 128.54,212.57 128.67,212.44 128.67,212.15 128.96,211.86 129.29,211.86 129.94,211.21 129.94,208.89 129.83,208.78 C6555.1
  IN4 w0.102: v1(128.33,212.57) 128.58,212.57 128.72,212.71 128.72,212.91 128.61,213.02 127.96,213.02 127.15,212.21 122.23,212.21 120.96,210.94 120.96,209.92 115.82,204.79 115.82,197.27 116.37,196.72 116.37,194.71 114.27,192.61 114.27,187.08 115.71,185.63 115.71,178.5 114.29,177.08 114.29,171.97 113.77,171.45 113.77,168.39 113.23,167.85 113.23,158.94 112.83,158.53 112.83,155.21 113.19,154.85 113.19,138.91 116.74,135.36 120.64,135.36 121.06,134.94 121.06,134.23 120.92,134.08 120.92,133.41 120.63,133.12 118.83,133.12 118.53,132.83 118.53,132.18 118.41,132.06 118.41,131.9 v2(118.51,131.8)
  BOTTOM w0.079: v2(118.51,131.8) 118.51,131.57 118.36,131.41 U1.BU8
PEG_RXP8_C: length 9.3
  TOP w0.102: C6555.2 129.67,208.25 129.83,208.25 129.98,208.11 129.98,207.6 129.22,206.84 129.22,205.44 129.7,204.95 129.7,201.64 129.49,201.43 129.49,201.24 v2(129.29,201.04)
  BOTTOM w0.102: v2(129.29,201.04) 129.33,200.99 129.33,200.81 129.16,200.63 128.9,200.63 U8.AC12
PEG_TXN5: length 97.6
  IN4 w0.102: v2(124.1,205.86) 123.93,205.68 123.04,205.68 122.17,204.82 122.17,204.5 120.09,202.42 120.09,196.31 119.31,195.53 119.31,193.2 118.49,192.39 118.49,190.18 119.09,189.58 119.09,186.86 118.39,186.16 118.39,182.14 118.72,181.82 118.72,176.76 117.75,175.79 117.75,170.37 117.5,170.12 117.5,167.57 116.74,166.81 116.74,160.33 116.57,160.16 116.57,158.29 115.68,157.4 115.68,141.15 116.32,140.51 117.51,140.51 117.6,140.6 120.21,140.6 121.79,139.02 121.79,137.72 123.44,136.08 125,136.08 125.73,135.35 125.73,132.02 128.28,129.47 129.71,129.47 129.88,129.29 129.88,129.16 v2(129.7,128.98)
  BOTTOM w0.102: v2(129.7,128.98) 129.89,128.78 129.89,128.7 129.65,128.46 128.85,128.46 128.37,128.95 127.85,128.95 C192.2 ; v2(124.1,205.86) 124.26,205.7 124.61,205.7 124.87,205.45 124.87,204.86 124.47,204.46 124.47,204.1 U8.AG7
PEG_TXN5_C: length 7.6
  BOTTOM w0.079: U1.BW4 121.41,130.83 121.84,130.88 122.14,131 122.27,131 122.48,130.94 122.53,130.93 122.85,131 122.9,131 122.93,131.01 122.98,131.02 124.85,131.02 125.86,130.01 125.86,129.42 126.26,129.03 126.96,129.03 C192.1
PEG_TXN6: length 88.6
  IN4 w0.102: v2(124.33,202.64) 124.05,202.92 123.91,202.92 122.2,201.21 122.2,194.88 121.96,194.64 121.96,191.35 122.1,191.22 122.1,187 121.45,186.36 121.45,180.7 122.4,179.76 122.4,173.47 120.99,172.06 120.99,161.47 120.68,161.15 120.68,160.26 121.18,159.75 121.18,158.52 121,158.33 121,157.31 121.11,157.2 121.11,155.93 120.98,155.8 120.98,155.27 121.08,155.17 121.08,153.71 120.98,153.61 120.98,152.85 121.08,152.75 121.08,151.1 120.98,151 120.98,147.91 121.08,147.81 121.08,147.2 122.2,146.08 122.2,144.59 122.86,143.93 122.86,142.95 123.74,142.07 126.1,142.07 128.06,140.11 129.3,140.11 130.64,138.77 130.64,137.97 131.36,137.25 131.36,134.75 131.86,134.25 132.84,134.25 134.08,133.01 134.08,132.08 133.53,131.53 132.88,131.53 132.46,131.11 131.91,131.11 131.84,131.04 131.84,130.74 v2(132.06,130.52)
  BOTTOM w0.102: C194.2 130.29,129.8 131.47,129.8 131.84,130.18 131.84,130.3 v2(132.06,130.52) ; v2(124.33,202.64) 124.36,202.61 124.36,202.61 U8.AE7
PEG_TXN6_C: length 10
  BOTTOM w0.079: 127.56,129.69 127.54,129.69 127.55,129.7 127.53,129.72 126.26,129.72 126.08,129.9 126.08,130.03 124.35,131.76 123.78,131.76 123.64,131.62 123.26,131.62 123.1,131.46 122.72,131.46 122.71,131.46 122.71,131.46 122.59,131.51 122.47,131.51 122.34,131.44 122.08,131.44 121.94,131.52 121.26,131.62 U1.BU4
  BOTTOM w0.102: 127.56,129.69 128.48,129.69 128.54,129.75 129.41,129.75 C194.1
PEG_TXN7: length 94
  IN4 w0.102: v2(125.98,203.47) 125.75,203.24 125.51,203.24 124.67,204.08 123.91,204.08 121.39,201.56 121.39,195.43 121.12,195.16 121.12,191.24 120.45,190.57 120.45,189.94 121.24,189.15 121.24,187.31 120.64,186.7 120.64,180.29 121.56,179.36 121.56,173.89 120.16,172.49 120.16,165.48 118.77,164.09 118.77,157.53 118.72,157.48 118.72,156.37 118.49,156.14 118.49,155.44 118.75,155.18 118.75,154.67 118.71,154.63 118.71,149.88 118.92,149.67 118.92,147.18 119.8,146.3 119.8,144.74 120.64,143.9 121.36,143.9 121.85,143.4 121.85,142.63 123.26,141.22 125.79,141.22 127.02,139.98 127.02,139.34 128.58,137.78 128.58,137.51 129.4,136.68 129.4,134.24 129.97,133.68 130.75,133.68 131.01,133.42 132.04,133.42 132.36,133.1 132.36,132.29 132.27,132.2 132.07,132.2 v2(131.86,132.42)
  BOTTOM w0.102: v2(125.98,203.47) 126.4,203.06 U8.AF9 ; C6551.2 127.27,130.68 128.19,130.68 128.8,131.3 129.35,131.3 129.43,131.21 130.75,131.21 131.04,131.5 131.04,131.98 131.26,132.2 131.64,132.2 v2(131.86,132.42)
PEG_TXN7_C: length 5.2
  BOTTOM w0.079: U1.BU2 122.47,132.13 123.4,132.13 123.53,132.26 124.58,132.26 126.04,130.79 126.38,130.79 C6551.1
PEG_TXN8: length 91.6
  IN4 w0.102: v2(130.58,131.69) 130.43,131.85 130,131.85 129.39,132.46 129.39,132.98 127.92,134.45 127.92,137.58 126.42,139.08 126.42,139.59 126.05,139.95 123.06,139.95 122.2,140.81 122.2,141.3 120,143.49 119.49,143.49 119.28,143.28 117.96,143.28 117.63,143.6 117.63,156.65 117.58,156.71 117.58,159.78 117.75,159.96 117.75,164.52 118.85,165.61 118.85,169.39 119.39,169.94 119.39,172.42 118.76,173.05 118.76,175.93 120.11,177.29 120.11,179.35 119.74,179.73 119.74,181.49 119.4,181.83 119.4,182.36 120.01,182.97 120.01,186.96 120.62,187.56 120.62,188.64 119.74,189.52 119.74,190.86 120.49,191.6 120.49,195.51 120.73,195.75 120.73,201.8 123.75,204.82 124.68,204.82 124.86,205 125.27,205 v2(125.48,205.2)
  BOTTOM w0.102: C6550.2 130.04,131.82 130.11,131.88 130.39,131.88 v2(130.58,131.69) ; U8.AG10 127.03,204.02 127.03,204.41 126.44,205 125.68,205 v2(125.48,205.2)
PEG_TXN8_C: length 9.4
  BOTTOM w0.079: 126.1,131.31 126.08,131.31 126.05,131.34 125.75,131.34 124.68,132.42 123.42,132.42 123.31,132.3 122.3,132.3 122.18,132.18 121.72,132.18 121.47,132.44 U1.BT4
  BOTTOM w0.102: 126.1,131.31 126.9,131.31 127.33,131.75 128.9,131.75 129.06,131.91 129.33,131.91 C6550.1
PEG_TXP5: length 97.7
  IN4 w0.102: v2(130.31,128.98) 130.09,129.19 130.09,129.37 129.79,129.67 128.37,129.67 125.93,132.1 125.93,135.43 125.09,136.28 123.52,136.28 122,137.8 122,139.11 120.3,140.8 117.52,140.8 117.43,140.72 116.4,140.72 115.88,141.23 115.88,157.31 116.78,158.2 116.78,160.08 116.94,160.24 116.94,166.73 117.7,167.49 117.7,170.03 117.95,170.28 117.95,175.71 118.92,176.67 118.92,181.9 118.59,182.23 118.59,186.07 119.29,186.77 119.29,189.66 118.69,190.26 118.69,192.3 119.51,193.12 119.51,195.44 120.29,196.23 120.29,202.34 122.37,204.42 122.37,204.73 123.12,205.48 124.03,205.48 124.1,205.41 v2(124.1,205.23)
  BOTTOM w0.102: v2(130.31,128.98) 130.09,128.76 130.09,128.62 129.73,128.26 128.77,128.26 128.28,128.74 127.84,128.74 C193.2 ; U8.AG6 124.07,203.85 124.26,204.04 124.26,204.55 124.65,204.94 124.65,205.38 124.53,205.5 124.28,205.5 124.1,205.33 v2(124.1,205.23)
PEG_TXP5_C: length 7.5
  BOTTOM w0.079: U1.BW3 121.85,130.7 122.17,130.83 122.25,130.83 122.43,130.78 122.5,130.76 122.54,130.76 123,130.86 124.78,130.86 125.71,129.94 125.71,129.36 126.19,128.87 127.26,128.87 127.34,128.8 127.34,128.57 127.26,128.49 C193.1
PEG_TXP6: length 88.6
  IN4 w0.102: v2(124.33,203.44) 124,203.12 123.83,203.12 122,201.29 122,194.97 121.76,194.73 121.76,191.27 121.89,191.14 121.89,187.09 121.25,186.44 121.25,180.62 122.2,179.67 122.2,173.55 120.79,172.14 120.79,161.55 120.47,161.24 120.47,160.18 120.98,159.67 120.98,158.6 120.79,158.42 120.79,157.22 120.9,157.11 120.9,156.01 120.78,155.88 120.78,155.18 120.87,155.09 120.87,153.79 120.78,153.7 120.78,152.77 120.88,152.67 120.88,151.18 120.78,151.08 120.78,147.82 120.88,147.72 120.88,147.12 121.99,146 121.99,144.5 122.65,143.84 122.65,142.87 123.66,141.86 126.01,141.86 127.97,139.9 129.21,139.9 130.43,138.68 130.43,137.89 131.15,137.17 131.15,134.66 131.77,134.05 132.76,134.05 133.88,132.92 133.88,132.17 133.44,131.73 132.8,131.73 132.38,131.31 131.83,131.31 131.64,131.12 131.64,130.73 v2(131.45,130.54)
  BOTTOM w0.102: C195.2 130.37,130.02 131.38,130.02 131.63,130.27 131.63,130.37 v2(131.45,130.54) ; v2(124.33,203.44) U8.AF7
PEG_TXP6_C: length 10
  BOTTOM w0.079: 127.56,129.89 127.54,129.89 127.53,129.88 126.32,129.88 126.24,129.96 126.24,130.09 124.41,131.92 123.72,131.92 123.58,131.78 123.19,131.78 123.04,131.62 122.76,131.62 122.65,131.67 122.43,131.67 122.3,131.6 122.12,131.6 121.92,131.7 121.89,131.77 121.89,131.95 121.82,132.02 121.64,132.02 121.56,131.95 U1.BU3
  BOTTOM w0.102: C195.1 129.69,130.25 129.69,130.07 129.57,129.95 128.45,129.95 128.4,129.89 127.56,129.89
PEG_TXP7: length 94.1
  IN4 w0.102: v2(125.98,202.66) 125.61,203.04 125.42,203.04 125.19,203.27 124.58,203.88 123.99,203.88 121.59,201.48 121.59,195.34 121.32,195.08 121.32,191.15 120.65,190.48 120.65,190.03 121.45,189.23 121.45,187.22 120.84,186.62 120.84,180.37 121.76,179.45 121.76,173.8 120.36,172.4 120.36,165.4 118.97,164.01 118.97,157.45 118.92,157.4 118.92,156.28 118.69,156.05 118.69,155.52 118.95,155.26 118.95,154.58 118.91,154.54 118.91,149.97 119.13,149.75 119.13,147.26 120,146.39 120,144.82 120.72,144.1 121.44,144.1 122.05,143.49 122.05,142.71 123.35,141.42 125.88,141.42 127.23,140.07 127.23,139.42 128.78,137.87 128.78,137.59 129.6,136.77 129.6,134.33 130.05,133.88 130.84,133.88 131.09,133.62 132.12,133.62 132.56,133.18 132.56,132.21 132.35,132 132.07,132 v2(131.86,131.78)
  BOTTOM w0.102: U8.AE9 v2(125.98,202.66) ; v2(131.86,131.78) 131.86,131.89 131.75,132 131.35,132 131.25,131.9 131.25,131.42 130.84,131.01 129.35,131.01 129.26,131.09 128.89,131.09 128.28,130.48 127.26,130.48 C6553.2
PEG_TXP7_C: length 5.2
  BOTTOM w0.079: C6553.1 126.67,130.22 126.77,130.32 126.77,130.59 126.72,130.64 125.97,130.64 124.51,132.1 123.6,132.1 123.47,131.97 122.96,131.97 U1.BU1
PEG_TXP8: length 91.7
  IN4 w0.102: v2(130.58,132.3) 130.33,132.05 130.09,132.05 129.59,132.54 129.59,133.06 128.12,134.53 128.12,137.66 126.62,139.17 126.62,139.67 126.13,140.16 123.14,140.16 122.4,140.9 122.4,141.38 120.09,143.7 119.41,143.7 119.19,143.48 118.04,143.48 117.84,143.69 117.84,156.73 117.78,156.79 117.78,159.69 117.96,159.87 117.96,164.43 119.05,165.53 119.05,169.31 119.6,169.85 119.6,172.5 118.96,173.14 118.96,175.85 120.31,177.2 120.31,179.44 119.94,179.81 119.94,181.58 119.6,181.92 119.6,182.27 120.22,182.89 120.22,186.87 120.82,187.48 120.82,188.72 119.94,189.61 119.94,190.77 120.69,191.52 120.69,195.43 120.93,195.67 120.93,201.71 123.83,204.62 124.76,204.62 124.94,204.8 125.37,204.8 125.48,204.69 v2(125.48,204.47)
  BOTTOM w0.102: C6552.2 130.04,132.18 130.12,132.1 130.38,132.1 v2(130.58,132.3) ; v2(125.48,204.47) 125.48,204.69 125.58,204.79 126.36,204.79 126.82,204.33 126.82,203.73 126.75,203.65 126.6,203.65 U8.AG9
PEG_TXP8_C: length 9.4
  BOTTOM w0.079: U1.BT3 121.74,132.44 121.64,132.53 121.64,132.63 121.74,132.74 122.1,132.74 122.37,132.46 123.24,132.46 123.36,132.57 124.74,132.57 125.81,131.5 126.05,131.5 126.08,131.53 126.1,131.53
  BOTTOM w0.102: C6552.1 129.33,132.11 128.97,132.11 128.81,131.95 127.25,131.95 126.83,131.53 126.1,131.53
PEGX_RST#: length 51.5
  TOP w0.114: v2(121.84,186.16) 120.55,184.87 v1(115.89,184.87) 115.72,185.04 114.67,185.04 113.23,186.48 113.23,187.87 113.56,188.2 113.56,189.14 113.41,189.29 112.53,189.29 112.36,189.12 v1(112.36,188.52)
  IN3 w0.102: v1(121.75,204.92) 121.75,202.38 120.85,201.47 120.85,194.48 121.58,193.75 121.58,189.84 122.17,189.26 122.17,186.74 121.84,186.42 v2(121.84,186.16)
  BOTTOM w0.114: v1(121.75,204.92) 120.78,204.92 120.06,205.63 119.46,205.63 R296.2 ; R384.1 108.72,180.05 R306.2 108.38,180.38 R305.2 109.05,181.12 109.77,181.84 109.77,182.21 110.82,183.26 110.82,183.83 111.24,184.25 111.24,185.76 111.02,185.99 111.02,186.89 111.19,187.07 111.19,188.19 111.52,188.52 v1(112.36,188.52)
PEGX_RST#_C: length 6.4
  BOTTOM w0.114: v1(109.4,185.92) 108.82,185.92 108.73,185.84 U9.4 107.5,185.84 107.45,185.79 107.45,184.16 107.69,183.92 107.93,183.92 108.31,183.54 108.31,182.61 108.38,182.54 R305.1
PEQ: length 10.4
  TOP w0.114: v1(29.57,131.53) 30.03,131.99 30.03,132.77 R763.2 R762.1 30.5,134.87 v1(30.76,135.12) ; U30.8 v1(24.62,130.34)
  IN3 w0.102: v1(29.57,131.53) 29.39,131.53 28.93,131.07 25.35,131.07 v1(24.62,130.34)
PEX_CLKREQ#: length 28.6
  BOTTOM w0.114: U8.AC6 123.92,200.44 123.48,200 123.48,199.58 123.29,199.39 119.22,199.39 118.84,199.77 115.93,199.77 114.74,198.58 114.74,197.39 113.92,196.58 v1(113.92,194.61) 113.92,193.2 114.38,192.74 114.38,190.14 113.3,189.06 R25487.2 113.09,189.1 110.38,189.1 Q9.1 110.27,188.39 110.48,188.39 110.71,188.15 110.71,187.25 110.59,187.13 110.59,185.82 110.69,185.72 R297.1
PEX_TERMP: length 5.2
  BOTTOM w0.102: 140.87,204.97 139.98,204.08 139.98,203.41 U8.AF25
  BOTTOM w0.114: 140.87,204.97 142.14,206.24 R312.2
PEX_TSTCLK: length 6
  BOTTOM w0.127: U8.AF22 137.69,203.62 137.69,203.8 139.42,205.53 139.96,205.53 140.58,206.15 140.58,206.94 140.52,207 R307.2
PEX_TSTCLK#: length 6.9
  BOTTOM w0.127: R307.1 140.97,207.05 140.82,206.91 140.82,206.05 140.06,205.29 139.52,205.29 137.93,203.7 137.93,203.52 137.57,203.15 137.57,202.69 U8.AE22
PHASE1_CORE: length 16.5
  TOP w0.114: v1(156.85,160.12) 156.19,160.12 v1(156.14,160.17)
  TOP w0.508: v1(148.9,152.49) 149.01,152.6 PR7072.2 ; PC7105.1 155.82,160.49 v1(156.14,160.17)
  IN4 w0.508: v1(156.14,160.17) 156.14,154.51 154.11,152.49 v1(148.9,152.49)
PHASE2_CORE: length 16.7
  TOP w0.114: v1(148.06,135.53) v3(148.82,135.53)
  TOP w0.508: PR7081.2 149.77,136.48 v3(148.82,135.53) ; v1(156.65,144.62) 156.5,144.77 PC7056.1
  IN4 w0.508: v1(156.65,144.62) 156.65,143.4 156.96,143.08 156.96,141.99 151.5,136.52 149.81,136.52 v3(148.82,135.53)
PHASE_GT: length 15.5
  TOP w0.114: v1(140.44,162.76) v3(140.44,162)
  TOP w0.508: v1(152.73,165.15) 152.99,164.89 PC7101.1
  IN4 w0.508: v3(140.44,162) 143.11,164.66 152.25,164.66 v1(152.73,165.15)
PHASE_SA: length 7.7
  TOP w0.114: v1(162.89,128.88) v1(162.89,128.22)
  TOP w0.508: PR7087.2 157.86,131.08 v1(158.39,131.61)
  IN4 w0.508: v3(167.9,130.69) 165.43,128.22 v1(162.89,128.22)
PIRQA#: length 56.5
  TOP w0.079: v2(104.14,128.41) 104.54,128.01 105.16,128.01 105.36,127.81 106.38,127.81 106.87,127.31 106.87,126.75 107.68,125.94 107.68,124.52 107.5,124.34 107.5,123.17 106.62,122.29 106.62,122.09
  TOP w0.114: 106.62,122.09 106.62,119.74 106.79,119.56 106.79,114.41 105.95,113.57 105.95,112.51 105.59,112.16 105.59,111.85 105.9,111.54 105.9,109.92 105.48,109.5 R179.1 105.24,109.97 v1(105.43,110.16) ; v1(90.22,103.03) 90.22,102.89 89.77,102.45 88.74,102.45 88.57,102.62 86.73,102.62 v1(86.26,102.16) 85.74,102.16 85.57,101.99 85.12,101.99 84.92,102.18 82.93,102.18 82.66,101.91 R580.1 82.66,100.99 82.85,100.8 82.85,100.16 R593.1
  IN1 w0.089: v1(90.22,103.03) 90.22,103.38 89.43,104.17 89.43,105.7 90.18,106.45 96.2,106.45 97.89,108.14 101.38,108.14 103.4,110.16 v1(105.43,110.16)
  BOTTOM w0.079: v2(104.14,128.41) 103.71,128.41 U1.CC32
PLTRST#: length 534.9
  TOP w0.114: R894.2 147.43,100.3 v1(147.04,100.3) 147.04,100.99 v1(147.12,101.06) ; v1(19.53,78.97) 19.53,79.23 20.04,79.73 26.03,79.73 28.4,77.36 28.4,73.69 27.88,73.17 R648.2 ; U6521.36 16.62,163.81 16.44,163.63 v1(16.44,163.09) ; v1(83.12,101.57) 83.23,101.68 R56.2 83.99,101.61 83.4,101.02 R601.1
  IN1 w0.089: v1(83.12,101.57) 83.12,99.82 84.41,98.52 88.16,98.52 88.91,97.77 96.59,97.77 97.7,98.88 109.31,98.88 v1(110.68,100.26) ; v1(16.44,163.09) 16.57,163.22 24.02,163.22 30,169.21 30,171.48 30.23,171.71 33.01,171.71 33.16,171.55 36.92,171.55 42.84,177.48 42.84,178.49 43.79,179.43 43.79,183.91 45.41,185.54 50.51,185.54 54.12,189.15 56.15,189.15 57.88,190.87 68.8,190.87 70.67,189 70.67,188.55 71.5,187.72 71.5,184.15 70.79,183.45 70.79,181.44 71.83,180.41 72.68,180.41 73.77,179.32 74.45,179.32 77.37,176.39 80.73,176.39 81.18,176.84 v1(83.19,176.84) ; v1(201.66,105.14) 202.47,105.14 203.93,106.61 206.67,106.61 207,106.27 209.23,106.27 209.56,106.61 213.75,106.61 214.24,107.1 215.98,107.1 216.63,106.45 220.92,106.45 223.83,109.36 223.83,112.6 226.7,115.47 226.7,119.98 226.36,120.32 226.36,120.79 223.07,124.09 v1(223.07,124.25)
  IN3 w0.102: v1(22.65,114.64) 23.3,113.99 23.3,106.83 21.01,104.54 21.01,103.02 21.64,102.38 21.64,99.59 23.22,98.02 23.22,97.17 22.41,96.36 22.41,95.59 21.66,94.84 21.66,93.4 21.21,92.96 21.21,89.35 20.73,88.87 20.73,87.53 21.19,87.07 21.19,83.74 20.42,82.98 20.42,80.46 19.53,79.57 v1(19.53,78.97) ; v1(110.68,100.26) 111.15,99.79 116.57,99.79 117.18,100.41 121.41,100.41 122.99,101.99 128.55,101.99 130.12,103.56 138.73,103.56 139.79,102.49 141.28,102.49 142.71,101.06 v1(147.12,101.06) 148.03,101.06 149.63,102.66 155.6,102.66 156.7,103.76 156.7,104.09 156.95,104.34 159.8,104.34 160.3,104.84 163.21,104.84 163.83,104.21 166.47,104.21 166.83,104.57 167.41,104.57 168.08,105.23 171.6,105.23 176.03,109.66 178.7,109.66 185.31,103.05 192.63,103.05 192.96,103.39 198.51,103.39 200.27,105.14 v1(201.66,105.14)
  IN4 w0.089: v1(16.44,163.09) 16.01,162.66 16.01,147.92 20.28,143.64 20.28,138.28 17.42,135.41 17.42,134.32 15.9,132.8 15.9,130.05 15.33,129.48 15.33,119.61 14,118.28 14,117.13 14.1,117.03 v1(14.63,117.03) ; v1(104.93,184.68) 104.93,184.34 100.52,179.94 96.16,179.94 92.4,176.18 83.86,176.18 v1(83.19,176.84)
  BOTTOM w0.079: 98.41,135.34 99.26,136.19 101.21,136.19 U1.BJ35
  BOTTOM w0.114: v1(22.65,114.64) 22.18,114.17 20.53,114.17 20.03,113.66 17.78,113.66 16.79,114.66 16.79,116.1 15.86,117.03 v1(14.63,117.03) ; 98.41,135.34 96.56,135.34 95.18,133.96 94.55,133.96 94.2,134.31 85.98,134.31 84.71,133.04 83.34,133.04 82.63,132.34 82.08,132.34 ; v1(104.93,184.68) 105.11,184.68 105.62,185.19 U9.2 ; v1(83.19,176.84) 83.19,173.92 80.31,171.03 80.31,139.67 81.75,138.22 81.75,132.67 82.08,132.34 ; v1(83.12,101.57) 83.12,101.59 82.28,102.43 82.28,104.61 83.05,105.38 83.05,106.97 82.11,107.92 82.11,112.18 83.06,113.13 83.06,114.57 80.88,116.75 80.88,122.95 80.52,123.31 80.52,130.24 81.75,131.47 81.75,132.01 82.08,132.34 ; R2665.2 195.9,112.54 196.62,111.82 196.62,110.33 197.8,109.15 198.17,109.15 201.66,105.66 v1(201.66,105.14) ; CN49.8 v1(223.07,124.25)
PLTRST#_EC: length 3.8
  TOP w0.114: R894.1 148.42,100.63 C2374.1 149.92,101.01 150.35,101.01 150.47,101.14 U37.22
PM_EXTTS#0: length 13.2
  TOP w0.114: v1(45.93,138.23) 45.96,138.26 R224.2
  IN3 w0.102: v1(45.93,138.23) 51.38,138.23 52.04,138.89 v1(54.12,138.89)
  BOTTOM w0.114: JDIM02.134 54.69,138.32 v1(54.12,138.89) ; v1(45.93,138.23) 45.84,138.32 JDIM1.134
PMON: length 27.6
  TOP w0.203: PR7039.1 169.68,138.98 v1(169.68,138.63) ; v1(168.55,124.48) 168.55,124.45 v1(168,123.9) 167.49,123.38 166.44,123.38 165.8,122.75 165.8,121.97 164.87,121.03 164.87,120.48 164.24,119.85 v1(163.64,119.85)
  IN3 w0.203: v1(168.55,124.48) 168.55,124.85 169.23,125.53 169.23,136.69 169.06,136.86 169.06,138.01 v1(169.68,138.63)
  BOTTOM w0.203: v1(163.64,119.85) 163.99,120.19 PR23.1 PC18.2 164.04,119.18 163.92,119.3 163.5,119.3 PR25.1
PP: length 1.4
  TOP w0.114: U33.4 90.94,97.82 91.02,97.73 91.57,97.73 R600.2
PROC_POPIRCOMP: length 4.3
  TOP w0.079: R16.1 103.81,133.27 ; 105.69,132.48 105.73,132.52 106.26,132.52 v2(106.71,132.96)
  TOP w0.102: 105.69,132.48 105.33,132.48 105.23,132.58 105.14,132.58 v1(104.83,132.89) 104.83,132.99 104.37,133.45 103.99,133.45 103.81,133.27
  BOTTOM w0.089: v2(106.71,132.96) 106.71,133.02 106.48,133.24 U1.BP27
PROC_TRST#: length 13.7
  TOP w0.102: v2(119.32,154.05) 119.77,153.6 122.81,153.6 123.04,153.83 127.6,153.83 128.25,154.48 128.84,154.48 129.27,154.05 130.82,154.05 131.27,154.49 131.49,154.49
  TOP w0.114: 131.49,154.49 R6.2
  BOTTOM w0.102: v2(119.32,154.05) 119.52,153.86 U1.AB6
PROCHOT#: length 10
  BOTTOM w0.079: U1.Y4 121.44,154.4 121.74,154.1 122.07,154.1 122.24,154.27 124.9,154.27 126.07,155.44 126.07,156.5 126.65,157.08 126.93,157.08 127.33,157.48 127.33,157.55 127.72,157.94
  BOTTOM w0.114: R9.2 128.35,158.37 127.99,158.01 127.79,158.01 127.72,157.94
PROCHOT_EC: length 13.6
  TOP w0.114: Q6509.2 142.79,97.56 143.5,96.85 R25298.2 144.11,98.65 144.69,99.23 144.69,99.75 v1(145.11,100.17) 146.05,101.11 146.05,101.25 147.09,102.28 147.18,102.28 147.48,102.57 148.27,102.57 C6610.2 148.69,102.97 149.14,102.51 149.74,102.51 150.37,103.14 U37.17
PROCPWRGD: length 6.1
  BOTTOM w0.079: 126.09,143.62 125.1,143.62 123.76,144.96 122.46,144.96 U1.AR2
  BOTTOM w0.114: R34.2 127.33,144.02 126.81,144.02 126.4,143.62 C6619.1 126.09,143.62
PS_FB_CLAMP: length 6
  BOTTOM w0.114: U8.F3 120.95,186.08 120.33,186.08 120.19,185.93 119.28,185.93 119.13,186.08 117.86,186.08 R313.1
PULSAR_38P4M_REFCLK: length 96.9
  TOP w0.102: v2(130.03,114.52) 130.03,115.04 129.48,115.59 129.05,115.59 127.24,117.39 127.24,118.04 125.49,119.8 R67868.2
  IN4 w0.102: v2(130.03,114.52) 131.09,114.52 131.66,113.95 131.66,110.71 132.7,109.67 132.7,108.97 135.11,106.56 137.09,106.56 137.63,106.02 139.95,106.02 140.2,105.76 147.82,105.76 148.04,105.98 154.63,105.98 155.65,107 163.24,107 163.46,107.21 167.24,107.21 168.02,108 170.03,108 174.53,112.5 177.86,112.5 179.17,113.81 183.92,113.81 185.79,115.69 190.5,115.69 192.08,114.1 196.12,114.1 197.04,113.18 197.04,108.52 v1(196.57,108.05)
  BOTTOM w0.102: CN17.64 192.89,107.9 193.68,108.7 195.92,108.7 v1(196.57,108.05)
PULSAR_38P4M_REFCLK_R: length 7.6
  TOP w0.102: R67868.1 124.71,120.52 124.03,121.2 C204.2 R148.2 122.71,121.13 v2(123.27,120.57)
  BOTTOM w0.079: v2(123.27,120.57) 123.21,120.62 122.43,120.62 122.07,120.98 122.07,121.23 121.88,121.42 U1.CM3
PVADPTR: length 296.1
  TOP w0.254: PQ8007.3 66.92,200.76 67.96,200.76 PC5.1 PC1.1
  TOP w0.381: v1(82.92,188.08) 82.92,188.27 83.41,188.75 PR9278.2 83.17,189.08 PD8001.1 ; v1(35.01,108.6) 34.93,108.53 33.99,108.53 32.98,107.51 32.3,107.51 30.83,106.04 30.83,105.17 30.33,104.67 PR9279.1 ; v1(36.81,115) 36.91,115.11 38.32,115.11 39.01,114.41 PQ8006.3
  TOP w0.508: v1(163.37,123.84) 163.1,123.57 PR31.1 162.54,122.92 161.77,123.69 159.39,123.69 159.26,123.57 156.88,123.57 PD9002.2
  TOP w3.048: 61.59,192.43 59.66,190.5 54.28,190.5 51.45,187.66 49.7,187.66 46.19,184.16 46.19,178.18 40.57,172.56 40.57,146.57 41.11,146.03 41.11,120.18 40.11,119.19 40.11,116.58
  IN1 w0.508: v1(156.24,168.5) 156.13,168.4 153.43,168.4 152.95,168.89 151.23,168.89 150.85,169.26 142.4,169.26 137.9,173.76 v1(137.9,174.71) ; v1(66.91,193.9) 67.38,193.9 68.09,193.19 68.75,193.19 69.58,192.37 69.58,191.7 70.18,191.09 76.75,191.09 79.18,188.67 79.18,187.93 79.72,187.39 82.23,187.39 v1(82.92,188.08)
  IN2 w0.508: v1(137.9,174.71) 137.9,174.23 136.59,172.92 123.69,172.92 121.25,175.36 116.58,175.36 112.82,179.12 110.27,179.12 107.95,181.43 107.56,181.43 107.02,181.97 106.72,181.97 105.7,182.99 105.7,187.02 105.11,187.6 102.94,187.6 100.64,185.3 97.62,185.3 97.18,185.74 97.18,186.18 96.63,186.73 94.26,186.73 93.58,187.41 93.58,188.44 91.96,190.06 89.1,190.06 88.65,189.61 84.11,189.61 82.92,188.42 v1(82.92,188.08) ; v1(156.24,168.5) 157.53,169.79 158.9,169.79 160.33,168.37 165.09,168.37 166.34,167.12 166.34,160.3 167.72,158.92 167.72,156.68 168.69,155.72 168.69,155.05 169.06,154.67 169.06,154.33 169.53,153.86 169.53,149.81 168.26,148.54 167.64,148.54 166.4,147.31 166.4,145.29 166.83,144.86 166.83,140.55 167.13,140.25 167.13,135.41 167.86,134.68 167.86,133.31 169.55,131.62 169.55,130.16 168.16,128.78 168.16,126.3 165.7,123.84 165.12,123.84 164.86,124.11 163.64,124.11 v1(163.37,123.84)
  IN3 w0.381: v1(36.81,115) 34.12,112.31 34.12,108.97 34.49,108.6 v1(35.01,108.6)
  vias: v1(41.84,115.59)
PWM1_CORE: length 24.7
  TOP w0.114: v1(151.69,158.87) 151.09,158.87 v1(151.02,158.8)
  IN1 w0.203: v1(160.04,142.13) 158.32,143.85 158.32,145.29 155.93,147.67 155.93,156.61 155.46,157.08 153.16,157.08 151.45,158.8 v1(151.02,158.8)
  BOTTOM w0.203: PU7000.17 160.12,142.21 v1(160.04,142.13)
  BOTTOM w0.305: PR7105.1 150.51,159.18 150.89,158.8 v1(151.02,158.8)
PWM2_CORE: length 3.3
  BOTTOM w0.114: PR7077.1 158.63,140.72 v1(158.5,140.59)
  BOTTOM w0.203: PR7077.1 159.79,140.72 160.17,141.1 160.17,141.54 160.44,141.81 PU7000.16
PWM-VID: length 38
  TOP w0.114: v2(96.17,197.58) 96.35,197.41 PR9015.1
  IN4 w0.089: v2(96.17,197.58) 95.18,196.59 95.18,192.52 97,190.7 97.89,190.7 98.58,190.01 100.54,190.01 102.44,188.11 104.25,188.11 104.83,188.69 105.27,188.69 105.54,188.42 105.54,187.76 106.01,187.29 110.55,187.29 111.22,187.96 112.94,187.96 113.45,187.45 113.45,185.91 114.26,185.1 114.26,180.66 114.98,179.94 114.98,179.02 v1(114.83,178.87)
  BOTTOM w0.114: v1(114.83,178.87) 114.99,178.87 115.33,179.21 R370.2
PWM_GT: length 32.9
  IN3 w0.203: v1(158.82,144.21) 158.47,144.55 158.47,145.59 155.88,148.18 155.88,156.39 155.55,156.72 153.54,156.72 152.54,157.72 152.54,162.69 153.34,163.5 153.34,166.1 152.84,166.6 v1(152.84,167.06)
  BOTTOM w0.203: PU7000.22 v1(158.82,144.21)
  BOTTOM w0.254: v1(152.84,167.06) 152.84,167.78 153.07,168.01 154.48,168.01 v1(154.49,168.02) 154.98,167.52 PR7109.1
PWM_SA: length 18.4
  TOP w0.254: v1(164.63,132.94) 164.63,133.06 v1(164.21,133.47) 164.19,133.45 PR7113.1
  IN4 w0.254: v1(164.63,132.94) 164.63,134.73 166.28,136.39 166.28,138.02 166.64,138.38 166.64,145.69 167.48,146.53 v2(167.67,146.53)
  BOTTOM w0.203: v2(167.67,146.53) 167.37,146.53 167.19,146.35 166.46,146.35 166.3,146.19 PU7000.36
PWRLED#: length 114.4
  TOP w0.114: v1(152.82,100.81) 152.82,100.72 152.44,100.34 U37.24 149.26,100.34 R67484.1 ; v1(205.98,108.62) 206.2,108.83 v1(206.2,109.34)
  IN1 w0.089: v1(205.98,108.62) 206.68,107.92 213.7,107.92 214.49,108.71 218.52,108.71 224.29,114.48 224.29,119.91 v1(225.25,120.87)
  IN3 w0.102: v1(205.98,108.62) 205.98,108.31 205.33,107.66 205.33,104.8 203.28,102.75 203.28,101.28 202.42,100.42 202.42,99.51 v1(202.19,99.28) 200.9,97.99 193.24,97.99 192.72,97.47 182.57,97.47 181.44,96.34 178.46,96.34 177.78,97.02 169.63,97.02 169.53,96.92 166.18,96.92 165.36,96.11 153.79,96.11 151.95,97.95 151.95,99.94 v1(152.82,100.81)
  BOTTOM w0.114: CN55.10 227.95,120.46 227.72,120.23 226.08,120.23 225.43,120.87 v1(225.25,120.87) ; CN48.20 202.45,110.52 204.06,108.92 205.69,108.92 v1(205.98,108.62) ; CN52.12 204.85,100.03 204.1,99.28 v1(202.19,99.28)
R_SPK+: length 73.5
  IN4 w1.016: 22.26,37.36 26.43,37.36 27.94,38.87 28.98,38.87 32.36,42.26 32.36,58.62 32.91,59.17 32.91,72.18 32.36,72.73 32.36,78.18 33.42,79.24 33.42,85.53 35.86,87.97 35.86,88.87 37.1,90.11 44.27,90.11 47.06,92.9
  vias: v1(21.16,37.61) v1(21.16,36.95) v1(46.9,93.99) v1(47.22,93.39) v1(47.56,93.99)
R_SPK+_1: length 153.1
  TOP w1.016: 49.7,94.21 49.7,97.52 46.86,100.37 44.78,100.37 41.71,103.44 41.71,105.21
  IN3 w1.016: 86.67,194.84 85.68,193.86 79.2,193.86 77.77,192.43 75.69,192.43 75.13,192.99 71.99,192.99 69.92,195.05 65.82,195.05 60.72,189.95 60.72,181.7 54.55,175.54 45.97,175.54 41.62,171.19 41.62,128.89 37.65,124.91 37.65,122.42 40.9,119.17 40.9,107.53 41.04,107.39
  BOTTOM w1.016: 87.43,198.27 87.43,199.45 88.28,200.3 93.65,200.3 94.3,200.95 CN63.1
  vias: v1(41.49,106.38) v1(42.15,106.4) v1(49.63,92.68) v1(87.06,196.65) v1(87.73,196.65)
R_SPK+_2:
  vias: v1(46.25,97.21) v1(46.91,97.21) v1(47.55,96.47)
R_SPK-: length 69.8
  IN4 w1.016: 22.41,38.7 25.9,38.7 27.4,40.2 28.43,40.2 31.04,42.8 31.04,59.24 31.59,59.79 31.59,71.6 31.04,72.15 31.04,78.99 32.1,80.04 32.1,86.08 34.54,88.52 34.54,89.42 36.56,91.43 42.99,91.43 43.67,92.11 43.67,92.85
  vias: v1(20.52,37.44) v1(20.53,36.73) v1(43.3,93.91) v1(43.64,93.32) v1(43.96,93.91)
R_SPK-_1: length 165.1
  TOP w1.016: 46.35,90.97 49.92,90.97 51.03,92.09 51.03,98.06 47.4,101.69 45.33,101.69 43.23,103.79 43.23,104.11
  IN3 w1.016: 85.4,195.6 84.97,195.18 78.65,195.18 77.22,193.75 76.24,193.75 75.68,194.31 72.54,194.31 70.47,196.37 65.27,196.37 59.39,190.5 59.39,182.25 54,176.86 45.42,176.86 40.3,171.74 40.3,129.43 36.33,125.46 36.33,121.87 39.58,118.62 39.58,106.84 41.3,105.13 41.56,105.13
  BOTTOM w1.016: CN63.2 93.67,202.2 93.09,201.62 87.73,201.62 85.91,199.79 85.91,198.52
  vias: v1(42.75,105) v1(43.33,105.32) v1(45.52,91.08) v1(85.59,196.65) v1(86.25,196.65)
R_SPK-_2:
  vias: v1(43.3,94.8) v1(43.96,94.8) v1(45.77,95.02)
REGN6V: length 5.2
  TOP w0.203: PR39.1 155.95,119.39 v1(155.48,118.92) 155.32,118.77 154.9,118.77 154.54,118.41 v1(154.04,118.41)
  BOTTOM w0.152: PU1.24 155.42,118.95 155.17,118.7 PC9.1 154.27,118.7 154.11,118.54 154.11,118.48 v1(154.04,118.41)
REQ_WLAN#: length 4.4
  TOP w0.114: v1(182.49,110.29) 182.97,110.29 v1(183.34,110.66) 183.44,110.77 R652.1 184.13,111.43 Q63.1
  BOTTOM w0.114: v1(182.49,110.29) 182.85,110.65 CN17.53
RF_EN: length 203.2
  TOP w0.114: R25318.2 168.51,94.95 168.81,95.25 v1(168.81,95.81) ; v1(72.16,93.34) 72.16,97.63 v1(72.32,97.79) 72.77,98.24 72.77,99.37 73.58,100.18 73.58,104.23 76.01,106.66 76.01,116.54 76.32,116.85 76.32,118.93 76.11,119.13 76.11,122.35 78.76,125 84.78,125 R25494.1
  IN1 w0.089: v1(168.81,95.81) 168.16,96.46 166.17,96.46 165.21,95.51 154.68,95.51 152.94,97.25 139.23,97.25 138.54,97.94 134.2,97.94 133.13,99.01 114.71,99.01 113.62,97.92 108.37,97.92 106.54,96.09 102.69,96.09 101.58,97.21 98.45,97.21 98.05,96.8 92.83,96.8 92.14,96.12 84.98,96.12 84.24,96.86 83.22,96.86 82.48,96.12 78.19,96.12 77.64,96.66 75.48,96.66 74.87,96.05 74.47,96.05 72.16,93.75 v1(72.16,93.34)
  IN3 w0.102: v1(204.41,102.17) 204.2,101.96 204.2,100.72 203.46,99.99 203.46,98.97 200.6,96.11 195.06,96.11 194.38,95.42 169.19,95.42 v1(168.81,95.81)
  BOTTOM w0.114: CN17.56 192.43,109.9 193.82,111.29 195.18,111.29 195.5,110.97 R672.1 195.7,110.28 197.51,108.47 197.88,108.47 200.93,105.42 200.93,104.84 200.93,104.84 201.36,104.41 202.18,104.41 v1(204.41,102.17)
RF_OFF_PCH: length 13.3
  TOP w0.114: v1(99.3,129.94) 98.41,129.94 95.67,127.2 94,127.2 93.38,126.58 92.21,126.58 91.45,125.83 89.88,125.83 R37.1
  BOTTOM w0.079: v1(99.3,129.94) 99.3,130.26 99.87,130.84 U1.BV36
RGND_CORE: length 56.8
  TOP w0.114: v1(140.77,158.83) 140.77,158.36 140.3,157.89 140.3,155.85 PR7046.2
  IN1 w0.089: v2(168.33,137.16) 167.95,137.55 166.27,137.55 165.29,138.52 165.29,139.85 164.94,140.21 161.96,140.21 161.33,140.84 161.33,143.07 161.03,143.37 160.65,143.37 159.28,144.74 159.28,146.75 156.89,149.14 156.89,153.98 157.41,154.51 157.41,155.92 156.89,156.45 156.89,157.01 155.86,158.04 154.2,158.04 153.51,158.73 153.51,160.13 152.44,161.2 151.38,161.2 149.25,159.07 141.02,159.07 v1(140.77,158.83)
  BOTTOM w0.114: PU7000.48 167.65,140.61 167.82,140.44 167.82,140.3 167.27,139.75 167.27,139.36 167.28,139.35 PC7008.1 167.27,138.76 PC7009.1 167.27,137.55 167.66,137.16 v2(168.33,137.16)
RGND_GT: length 51.2
  TOP w0.114: v1(160.88,146.81) 160.97,146.73 v1(161.5,146.73) 161.5,146.35 161,145.86 PC7015.1 161.36,145.61 161.61,145.86 PC7014.1 ; v2(129.49,164.64) 128.89,164.64 PR7053.2
  IN4 w0.089: v1(160.88,146.81) 160.77,146.93 159.53,146.93 157.75,148.7 145.78,148.7 145.62,148.86 141.6,148.86 141.18,149.28 141.18,149.86 140.5,150.54 140.5,157.67 140.03,158.14 139.5,158.14 138.61,159.03 138.61,160.81 137.97,161.45 132.18,161.45 130.82,162.81 130.82,164.56 130.33,165.04 129.9,165.04 v2(129.49,164.64)
  BOTTOM w0.114: v1(160.88,146.81) 161.17,146.53 161.71,146.53 161.9,146.34 PU7000.25
RGND_SA: length 35.2
  TOP w0.114: PC7024.1 168.03,142.35 v2(168.24,142.15) 168.27,142.12 168.43,142.12 168.78,142.47 PC7022.1 ; PR7062.2 146.21,132.99 146.56,132.64 v1(146.87,132.64) 146.92,132.59 v1(147.62,132.59)
  IN4 w0.089: v2(168.24,142.15) 167.81,141.72 167.81,137.9 167.45,137.54 167.45,132.79 166.7,132.04 164.38,132.04 163.95,132.47 162.68,132.47 162.25,132.04 159.85,132.04 158.76,133.14 148.17,133.14 v1(147.62,132.59)
  BOTTOM w0.114: v2(168.24,142.15) 168.17,142.21 PU7000.44
RING2: length 15.7
  IN4 w1.016: 20.94,26.32 20.34,25.72 15.08,25.72 14.49,26.31 10.62,26.31 9.77,27.16 7.7,27.16
  BOTTOM w0.203: v1(20.44,27.75) 20.21,27.97 U20.17
  vias: v1(5.44,27.71) v1(6.33,27.84) v1(7,27.84) v1(20.42,27.07)
ROM_CS: length 18.5
  TOP w0.102: v2(128.49,184.46) 127.03,182.99 127.03,182.65
  TOP w0.114: TP67.1 113.66,177.95 115.03,177.95 117.14,180.05 124.62,180.05 127.03,182.46 127.03,182.65
  BOTTOM w0.102: v2(128.49,184.46) U8.D12
ROM_SCLK: length 7.2
  TOP w0.102: v2(128.46,183.63) 127.72,182.89 127.72,182.65
  TOP w0.114: v2(128.16,182.05) 128.02,182.05 127.72,182.35 127.72,182.65
  BOTTOM w0.102: v2(128.46,183.63) 128.46,183.65 128.86,184.05 U8.C12 ; v2(128.16,182.05) 128.32,181.89 128.32,180.7 128.46,180.55
  BOTTOM w0.114: R342.1 R352.2 129.57,179.44 128.46,180.55
ROM_SI: length 6.2
  BOTTOM w0.102: U8.B12 128.54,182.9 128.54,180.9 128.89,180.55
  BOTTOM w0.114: 128.89,180.55 129.74,179.7 129.84,179.7 130.34,179.19 R350.2 R341.1
ROM_SO: length 7.4
  BOTTOM w0.102: 132.56,180.08 132.44,180.21 130.58,180.21 128.88,181.91 U8.A12
  BOTTOM w0.114: 132.56,180.08 133.13,179.51 R351.2 133.13,179.12 132.35,178.34 R343.1
RREF: length 4.5
  BOTTOM w0.305: R752.2 23.59,63.17 24.75,63.17 24.95,63.37 v1(25.45,63.37) 26.06,63.37 26.26,63.17 27.55,63.17 27.76,63.39 U40.1
RSET: length 5.4
  TOP w0.203: U6521.12 23.59,168.21 23.75,168.36
  TOP w0.254: 23.75,168.36 24.01,168.62 v1(24.01,169.08) 24.01,170.33 24.51,170.84 24.98,170.84 25.1,170.72 R67477.2 R4009.1
RSMRST#: length 170.7
  TOP w0.114: v1(146.03,95.4) 146.03,95.3 v1(146.54,94.79) 146.88,94.45 150.46,94.45 151.57,95.55 151.57,95.56 154.24,98.24 154.63,98.24 155.3,98.9 155.3,102.09 156.27,103.06 159,103.06 160.02,104.08 160.02,106.32 159.54,106.8 159.54,108.1 159.36,108.28 U37.112 ; v2(98.44,131.31) 98.26,131.31 95.41,128.46 93.68,128.46 93.33,128.11 92.11,128.11 90.81,126.81 87.83,126.81 87.5,127.14 84.69,127.14 84.63,127.08 R45.1 83.69,127.58 81.76,127.58 EC1.2 81,127.33 R47.2 79.48,127.33 79.25,127.1 77.09,127.1 73.43,123.44 73.43,108.63 73.8,108.26 73.8,105.85 72.59,104.64 72.59,100.6 71.78,99.78 71.78,98.32 71.16,97.7 71.16,94.01 70.81,93.66 v1(70.81,93.34)
  IN1 w0.089: v1(146.03,95.4) 146.03,95.58 145.68,95.93 138.68,95.93 137.99,96.62 119.39,96.62 118.09,95.32 102.37,95.32 101.26,96.43 98.77,96.43 98.37,96.03 93.15,96.03 92.46,95.34 78.08,95.34 77.66,94.92 76.39,94.92 73.87,92.4 71.75,92.4 v1(70.81,93.34)
  BOTTOM w0.079: U1.BR36 100.88,132.63 100.77,132.52 100.51,132.52 100.36,132.45 100.07,132.45 99.91,132.61 99.33,132.61 98.81,132.09 98.72,132.09 98.44,131.81 v2(98.44,131.31)
RTC_RST#: length 51.8
  TOP w0.114: v1(82.78,103.54) 82.68,103.63 R979.2 81.77,103.63 81.18,103.04 80.65,103.04 80.57,103.12 C1217.1 79.97,103.12 79.89,103.04 79.62,103.04 J9007.1 78.66,102.54 78.24,102.96 Q22.3
  BOTTOM w0.079: U1.BR34 101.92,132.97 101.73,132.97 101.6,133.1 101.13,133.1 101.02,133.12 100.72,133.12 100.67,133.1 100.44,133.1 100.26,133.18 98.47,133.18 97.07,131.78 96.03,131.78 95.34,131.09 95.01,131.09
  BOTTOM w0.114: 95.01,131.09 93.42,131.09 v1(92.88,130.54) 92.02,129.68 92.02,127.6 88.13,123.72 84.33,123.72 82.16,121.55 82.16,116.17 83.56,114.77 83.56,112.93 82.62,111.99 82.62,108.1 83.55,107.17 83.55,105.18 82.78,104.4 v1(82.78,103.54)
RTC_X1: length 25.2
  IN4 w0.089: v2(99.47,120.39) 99.47,121.8 99.76,122.09 99.76,123.44 100.62,124.3 100.62,127.52 100.8,127.7 100.8,132.13 101.99,133.32 102.74,133.32 103.12,133.7 103.12,133.93 103.44,134.25 103.93,134.25 v2(104.28,133.9)
  BOTTOM w0.114: Y1.1 102.02,116.3 102.02,117.28 C206.2 102.57,117.33 R169.1 102.82,117.97 102.12,117.97 101.78,118.31 101.34,118.31 99.49,120.16 99.49,120.37 v2(99.47,120.39) ; U1.BN31 104.28,133.91 v2(104.28,133.9)
RTC_X2: length 24.5
  IN4 w0.089: v2(100.1,120.8) 100.1,121.46 100.36,121.71 100.36,123.19 101.21,124.05 101.21,127.4 101.4,127.58 101.4,131.88 102.59,133.08 102.78,133.08 103.31,133.61 103.31,133.83 103.44,133.96 103.59,133.96 v2(103.7,133.86)
  BOTTOM w0.114: v2(103.7,133.86) 103.68,133.86 U1.BN32 ; Y1.2 105.07,116.75 104.77,117.06 C209.2 104.34,117.33 103.97,117.33 103.79,117.51 R169.2 103.79,117.89 103.1,118.59 102.38,118.59 102.04,118.93 101.59,118.93 100.1,120.42 v2(100.1,120.8)
S5_ON: length 333.1
  TOP w0.114: PR566.2 38.38,140.32 v1(38.07,140.64) ; v1(199.45,113.42) 199.45,113.78 199.38,113.85 199.38,120.07 199.15,120.3 199.15,126.1 v1(199.14,126.11) 199.05,126.2 PR6015.1 ; v1(36.82,168.81) 36.65,168.65 PR6027.1 ; U37.100 164.16,112.03 164.44,112.32 164.74,112.32 165.32,112.89 166.43,112.89 R25309.1 166.68,112.95 167.84,114.12 169.66,114.12 170.01,113.77 170.01,113.3 170.35,112.96 174.31,112.96 174.65,113.29 174.83,113.29 v1(176.31,114.77)
  IN3 w0.102: v1(176.31,114.77) 176.93,115.4 186.29,115.4 186.57,115.12 190.98,115.12 193.69,112.41 198.45,112.41 v1(199.45,113.42) 200.86,113.42 204.85,109.43 205.79,109.43 206.45,108.76 206.45,108.45 205.56,107.56 205.56,104.7 203.51,102.65 203.51,101.19 202.64,100.32 202.64,99.13 201.28,97.76 193.34,97.76 191.68,96.11 175.49,96.11 174.8,96.8 169.73,96.8 169.63,96.69 166.27,96.69 165.46,95.88 153.69,95.88 150.24,99.34 142.39,99.34 141.22,100.5 140.14,100.5 139.83,100.81 135.68,100.81 135.15,101.34 130.27,101.34 129.24,100.31 123.68,100.31 122.1,98.73 117.88,98.73 117.16,98.02 114.16,98.02 v1(112.31,96.16)
  IN4 w0.089: v1(112.31,96.16) 111.66,95.52 102.04,95.52 100.64,96.92 98.11,96.92 97.91,96.73 92.79,96.73 92.28,96.22 85.15,96.22 84.44,96.94 83.75,96.94 83.03,96.22 79.68,96.22 78.89,97.01 77.02,97.01 76.07,96.06 75,96.06 74.01,97.06 71.79,97.06 71.01,96.28 68.44,96.28 67.36,95.2 58.34,95.2 57.12,96.41 54.77,96.41 49.48,101.7 42.98,101.7 42.34,101.07 39.36,101.07 37.78,102.65 37.78,113.25 33.85,117.18 33.85,121.01 34.54,121.7 34.54,125.27 34.2,125.61 34.2,131.13 33.82,131.5 33.82,134.4 33.71,134.51 33.71,135.25 32.14,136.82 32.14,141.66 v1(33.71,143.23) 33.71,143.96 33.06,144.61 33.06,160.48 35.04,162.46 35.04,164.92 36.82,166.7 v1(36.82,168.81)
  BOTTOM w0.114: v1(38.07,140.64) 38.07,142.82 37.36,143.53 34.01,143.53 v1(33.71,143.23)
SATA_LED#: length 1.9
  BOTTOM w0.114: TP2092.1 31.6,71.67 CN16.10
SATA_RXN0_CN: length 10.1
  TOP w0.102: v1(232.27,104.99) 231.99,105.27 231.99,107.43 228.74,110.68 228.74,110.92 229.01,111.19 C6596.1
  BOTTOM w0.102: CN11.16 232.14,103.95 231.99,104.1 231.99,104.72 v1(232.27,104.99)
SATA_RXN0_HDD: length 155.4
  TOP w0.102: v1(230.41,121.35) 230.18,121.12 230.18,120.72 C6588.2
  IN4 w0.102: v1(230.41,121.35) 230.23,121.17 230.23,120.87 228.14,118.78 228.14,112.06 227.33,111.25 221.39,111.25 218.25,108.11 208.36,108.11 205.6,110.87 203.78,110.87 198.94,115.71 198.94,118.22 197.41,119.75 192.49,119.75 191.46,118.72 184.24,118.72 183.4,119.56 181.92,119.56 180.08,117.72 174.05,117.72 172.81,116.47 172.81,115.91 171.26,114.37 170.78,114.37 169.44,113.02 168.59,113.02 168.05,112.49 166.86,112.49 164.75,110.39 160.38,110.39 160,110 153.84,110 153.2,109.35 150.75,109.35 150.38,109.72 141.5,109.72 140.93,109.15 136.92,109.15 134.67,111.39 134.67,114.99 132.18,117.49 130.42,117.49 129.41,118.5 128.94,118.5 126.7,120.74 126.7,123.56 125.99,124.27 125.99,125.05 125.23,125.81 125.03,125.81 124.05,126.79 122.25,126.79 121.53,127.51 121.53,128 121.34,128.19 121.15,128.19 121.13,128.19 120.76,128.56 118.85,128.56 118.68,128.73 118.36,129.06 118.36,129.26 118.17,129.44 117.02,129.44 116.67,129.78 116.67,133.04 116.98,133.35 117.55,133.35 117.58,133.32 117.84,133.32 117.96,133.44 117.96,133.61 v2(117.87,133.71)
  BOTTOM w0.079: v2(117.87,133.71) 117.76,133.71 117.3,134.17 U1.BN10
SATA_RXN0_IN: length 3.6
  TOP w0.102: U42.4 228.92,118.32 228.77,118.47 228.77,119.06 229.01,119.3 229.83,119.3 230.08,119.55 230.08,119.71 C6588.1
SATA_RXN_OUT: length 2
  TOP w0.102: C6596.2 228.77,112.19 228.77,112.97 228.92,113.12 U42.12
SATA_RXP0_CN: length 10.1
  TOP w0.102: v1(231.51,104.99) 231.79,105.27 231.79,107.35 228.54,110.59 228.54,110.92 228.27,111.19 C6597.1
  BOTTOM w0.102: CN11.15 231.64,103.95 231.79,104.1 231.79,104.72 v1(231.51,104.99)
SATA_RXP0_HDD: length 155.3
  TOP w0.102: C6589.2 229.97,120.82 229.97,121.17 229.8,121.35 v1(229.64,121.35)
  IN4 w0.102: v2(118.54,133.71) 118.29,133.71 118.25,133.66 118.25,133.55 118.15,133.45 118.15,133.36 117.92,133.13 117.5,133.13 117.47,133.16 117.06,133.16 116.86,132.96 116.86,129.86 117.1,129.63 118.25,129.63 118.55,129.34 118.55,129.14 118.93,128.75 120.84,128.75 121.21,128.38 121.23,128.38 121.44,128.38 121.74,128.08 121.74,127.59 122.34,127 124.14,127 125.12,126.02 125.31,126.02 126.2,125.13 126.2,124.35 126.9,123.65 126.9,120.82 129.02,118.7 129.5,118.7 130.51,117.69 132.27,117.69 134.88,115.08 134.88,111.48 137,109.35 140.84,109.35 141.42,109.93 150.47,109.93 150.84,109.56 153.11,109.56 153.76,110.21 159.91,110.21 160.29,110.59 164.66,110.59 166.77,112.7 167.97,112.7 168.5,113.23 169.35,113.23 170.7,114.57 171.18,114.57 172.6,116 172.6,116.56 173.97,117.92 180,117.92 181.84,119.76 183.49,119.76 184.32,118.93 191.38,118.93 192.41,119.95 197.5,119.95 199.14,118.31 199.14,115.8 203.87,111.07 205.68,111.07 208.45,108.31 218.16,108.31 221.31,111.45 227.25,111.45 227.94,112.14 227.94,118.86 230.03,120.95 230.03,121.13 229.82,121.35 v1(229.64,121.35)
  BOTTOM w0.079: v2(118.54,133.71) 118.34,133.71 118.22,133.83 U1.BN8
SATA_RXP0_IN: length 3.6
  TOP w0.102: U42.5 228.42,118.32 228.56,118.47 228.56,119.14 228.93,119.5 229.75,119.5 229.87,119.63 229.87,119.81 C6589.1
SATA_RXP_OUT: length 2.1
  TOP w0.102: C6597.2 228.56,112.23 228.56,112.97 228.42,113.12 U42.11
SATA_TXN0_CN: length 10.1
  TOP w0.102: v1(233.01,104.99) 233.29,105.27 233.29,107.32 230.04,110.57 230.04,110.92 229.77,111.19 C6595.1
  BOTTOM w0.102: CN11.18 233.14,103.95 233.29,104.1 233.29,104.71 v1(233.01,104.99)
SATA_TXN0_HDD: length 144.8
  TOP w0.102: v1(220.35,122.09) 220.12,122.32 220.12,122.6 220.68,123.16 223.32,123.16 223.57,123.41 226.19,123.41 226.94,122.66 230.13,122.66 231.58,121.22 231.58,120.77 C6587.2
  IN1 w0.102: v1(128.64,135.05) 128.84,135.25 129.07,135.25 129.16,135.15 129.16,134.29 128.82,133.95 128.82,131.32 128.14,130.63 128.14,128.76 128.71,128.18 128.71,124.85 129.18,124.39 129.46,124.39 130.94,122.91 130.94,116 134.23,112.71 134.23,111.65 136.63,109.25 140.77,109.25 141.1,109.57 152.94,109.57 153.81,110.44 154.49,110.44 154.98,110.92 160.49,110.92 161.2,111.63 165.75,111.63 165.92,111.81 171.23,111.81 173.28,113.86 177.76,113.86 178.55,114.65 185.49,114.65 186.64,113.51 193.45,113.51 193.92,113.97 196.17,113.97 200.14,117.94 205.32,117.94 207.09,119.71 212.31,119.71 213.58,118.44 214.93,118.44 217.7,121.21 219.67,121.21 220.12,121.65 220.12,121.87 v1(220.35,122.09)
  BOTTOM w0.079: 126.9,135.12 126.88,135.12 126.86,135.14 126.61,135.14 125.25,133.78 123.95,133.78 123.63,134.1 123.32,134.1 123.11,133.89 122.74,133.89 122.67,133.92 122.41,133.92 122.38,133.9 122.16,133.86 122.03,133.9 121.95,133.94 121.28,134.06 U1.BN4
  BOTTOM w0.102: v1(128.64,135.05) 128.39,135.3 127.58,135.3 127.41,135.12 126.9,135.12
SATA_TXN0_IN: length 3.5
  TOP w0.102: U42.2 229.92,118.18 230.06,118.32 230.06,118.63 230.53,119.1 231.11,119.1 231.55,119.54 231.55,119.79 C6587.1
SATA_TXN_OUT: length 2.1
  TOP w0.102: C6595.2 230.06,112.23 230.06,112.97 229.92,113.12 U42.14
SATA_TXP0_CN: length 10.1
  TOP w0.102: v1(233.77,104.99) 233.49,105.27 233.49,107.4 230.24,110.65 230.24,110.92 230.5,111.19 C6594.1
  BOTTOM w0.102: v1(233.77,104.99) 233.49,104.71 233.49,104.1 233.64,103.95 CN11.19
SATA_TXP0_HDD: length 144.8
  TOP w0.102: C6586.2 231.78,120.77 231.78,121.3 230.21,122.87 227.02,122.87 226.27,123.61 223.49,123.61 223.24,123.36 220.59,123.36 219.92,122.69 219.92,122.33 v1(219.69,122.09)
  IN1 w0.102: v1(219.69,122.09) 219.92,121.86 219.92,121.74 219.59,121.41 217.62,121.41 214.85,118.64 213.67,118.64 212.39,119.92 207.01,119.92 205.23,118.14 200.05,118.14 196.09,114.17 193.83,114.17 193.37,113.71 186.72,113.71 185.58,114.85 178.47,114.85 177.68,114.06 173.2,114.06 171.15,112.01 165.84,112.01 165.66,111.83 161.12,111.83 160.4,111.12 154.89,111.12 154.41,110.64 153.72,110.64 152.86,109.78 141.01,109.78 140.69,109.45 136.71,109.45 134.43,111.73 134.43,112.8 131.14,116.08 131.14,123 129.55,124.59 129.26,124.59 128.92,124.94 128.92,128.26 128.34,128.84 128.34,130.54 129.03,131.23 129.03,133.87 129.37,134.21 129.37,135.23 129.15,135.45 128.71,135.45 128.64,135.52 v1(128.64,135.81)
  BOTTOM w0.079: 126.9,135.32 126.88,135.32 126.86,135.3 126.55,135.3 125.19,133.94 124.02,133.94 123.7,134.26 123.26,134.26 123.05,134.05 122.79,134.05 122.71,134.08 122.38,134.08 122.32,134.06 122.17,134.03 122.1,134.06 U1.BN3
  BOTTOM w0.102: 126.9,135.32 127.32,135.32 127.5,135.5 128.54,135.5 128.64,135.6 v1(128.64,135.81)
SATA_TXP0_IN: length 3.6
  TOP w0.102: U42.1 230.42,118.2 230.27,118.35 230.27,118.54 230.62,118.89 231.19,118.89 231.75,119.45 231.75,119.71 232.06,120.01 C6586.1
SATA_TXP_OUT: length 2
  TOP w0.102: C6594.2 230.27,112.18 230.27,112.97 230.42,113.12 U42.15
SATAGP0: length 3.6
  TOP w0.114: R25481.1 118.98,119.71 v2(119.08,119.61)
  BOTTOM w0.079: v2(119.08,119.61) 118.87,119.82 118.87,120.86 118.67,121.34 118.67,121.54 118.72,121.66 118.72,121.85 118.55,122.26 U1.CN8
SATAGP1: length 4.8
  TOP w0.102: R25433.1 117.32,120.29 v2(117.96,119.65)
  BOTTOM w0.079: v2(117.96,119.65) 117.96,119.76 117.53,120.2 117.53,120.56 117.67,120.7 117.67,121.25 117.59,121.41 117.59,122.02 117.44,122.17 117.44,122.67 117.16,122.94 U1.CM10
SC_PWRSV#: length 150.9
  TOP w0.114: v1(209.67,92.79) R67606.1 210.23,93.54 R25557.2
  IN1 w0.089: v1(96.98,94.59) 97.44,95.04 98,95.04 98.66,94.38 119.3,94.38 120.6,95.68 137.6,95.68 138.29,94.99 142.18,94.99 142.79,94.38 206.09,94.38 207.68,92.79 v1(209.67,92.79)
  BOTTOM w0.079: 106.32,115.72 106.32,115.9 106.23,116 106.23,118.33 106.5,118.6 106.5,120.23 105.86,120.88 U1.CR28
  BOTTOM w0.114: v1(96.98,94.59) 96.98,95.17 99.01,97.2 99.01,99.35 97.75,100.61 97.75,108.25 98.47,108.97 100.22,108.97 101.32,110.08 v1(101.32,111.12) 101.32,111.38 101.91,111.96 101.91,112.49 102.31,112.89 102.31,113.33 103.04,114.06 105.77,114.06 106.32,114.61 106.32,115.72
SCARDC6: length 10.3
  TOP w0.114: U6509.2 v1(221.95,92.33)
  BOTTOM w0.114: v1(221.95,92.33) 221.95,94.19 223.4,95.64 CN53.4
SCARDC8: length 12.4
  TOP w0.114: U6509.1 v1(222.49,91.68) 222.66,91.52 v1(222.66,91)
  BOTTOM w0.114: v1(222.49,91.68) 222.49,93.17 223.84,94.51 223.84,99.18 224.4,99.74 CN53.3
SCARDCLK: length 8.4
  TOP w0.114: v1(222.43,94.1) 222.43,94.48 v1(221.98,94.93) U6509.6
  BOTTOM w0.114: v1(221.98,94.93) 221.4,95.51 CN53.6
SCARDDATA: length 11.5
  TOP w0.114: v1(222.41,95.91) 222.83,95.5 224.72,95.5 225.04,95.18 225.27,95.18 C20053.1 225.66,94.79 v1(225.66,93.9) 224.82,93.9 224.72,94 R25558.1
  BOTTOM w0.114: v1(222.41,95.91) 221.86,96.46 221.86,99.49 222.4,100.04 CN53.5
SCARDFCB: length 9.8
  TOP w0.114: U6509.3 v1(219.13,92.98)
  BOTTOM w0.114: v1(219.13,92.98) 220.4,94.25 CN53.7
SCARDRST: length 8.2
  TOP w0.114: U6509.5 v1(219.01,94.28)
  BOTTOM w0.114: CN53.8 219.4,98.09 219.01,97.7 v1(219.01,94.28)
SCL_GSENSOR: length 31.9
  TOP w0.114: Q6567.6 148.97,215.16 v1(148.69,215.43) 147.69,215.43 R67875.2 ; C20137.1 138.64,212.83 v1(138.43,212.62) 138.38,212.57 v1(137.76,212.57)
  TOP w0.254: C20137.1 139.06,213.85 139.45,213.85 140,214.4 U6515.12
  IN1 w0.089: v1(148.69,215.43) 150.05,214.08 150.05,213.4 150.68,212.77 150.68,212.2 149.96,211.48 149.96,210.66 149.13,209.82 147.7,209.82 146.85,210.67 143.78,210.67 142.62,209.51 141.68,209.51 141.5,209.7 138.22,209.7 137.42,210.49 137.42,211.89 137.76,212.23 v1(137.76,212.57)
  BOTTOM w0.114: v1(148.69,215.43) 148.94,215.68 149.39,215.68 TP13174.1 149.63,216.63 R25638.2
SCL_GSENSOR_R: length 8.6
  TOP w0.079: U6516.E5 156.04,215.57 156.24,215.57
  TOP w0.114: v1(156.36,215.57) 156.24,215.57
  BOTTOM w0.114: v1(156.36,215.57) 156.36,215.89 156.05,216.2 v1(155.86,216.2) 155.86,216.38 154.97,217.27 152.74,217.27 R25636.2 151.67,217.16 150.6,217.16 R25638.1
SCL_SENSOR_HUB: length 100.3
  TOP w0.079: 155.04,215.64 154.86,215.46 154.86,214.89 U6516.C4
  TOP w0.114: v1(155.1,215.7) 155.04,215.64
  IN3 w0.102: v1(155.1,215.7) 154.38,214.98 151.6,214.98 150.98,214.36 150.98,213.34 150.73,213.09 150.06,213.09 149.79,212.82 149.79,210.41 148.92,209.53 146.23,209.53 145.85,209.16 145.85,208.33 144.49,206.97 140.78,206.97 139.72,205.92 137.46,205.92 136.4,206.97 135.64,207.74 132.4,207.74 132.31,207.83 128.16,207.83 127.72,208.27 125.29,208.27 123.2,206.18 123.2,205.51 122.88,205.18 122.37,205.18 122.2,205.35 121.57,205.35 121.22,205 121.22,202.42 120.44,201.64 120.44,194.15 120.68,193.91 120.68,191.06 120.56,190.95 120.56,190.11 121.76,188.92 121.76,186.91 121.34,186.49 121.34,176.12 120.22,174.99 v1(120.22,174.64)
  BOTTOM w0.114: Q6569.6 100.29,180.33 101.48,179.14 102.09,179.14 102.1,179.15 102.48,179.15 102.49,179.14 102.62,179.14 102.82,178.94 102.82,178.25 103.31,177.76 R25632.2 R25631.2 105.08,175.92 117.21,175.92 117.94,175.19 119.29,175.19 v1(119.43,175.33) 119.55,175.33 120.22,174.66 v1(120.22,174.64)
SD_1P8_RCOPM: length 17.3
  TOP w0.079: 100.74,122.62 101.72,123.61 v2(102,123.61)
  TOP w0.102: 100.74,122.62 100.15,122.04 97.05,122.04 96.78,121.77 96.78,121.28 96.5,121 95.23,121 91.36,117.13 v1(91.36,116.68) 89.86,115.18 R209.1
  BOTTOM w0.102: U1.CM34 102,123.22 v2(102,123.61) 102.31,123.92 U1.CK33
