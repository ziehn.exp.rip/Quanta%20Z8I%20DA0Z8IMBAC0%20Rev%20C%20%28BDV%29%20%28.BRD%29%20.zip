# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R67389  HDMI_R_P4@0_5%_2  [R0201]  30.98 122.78 180 top
R67390  HDMI_R_P4@0_5%_2  [R0201]  18.47 127.27 0 top
R67391  HDMI_R_P4@0_5%_2  [R0201]  18.46 126.18 0 top
R67392  HDMI_R_P4@0_5%_2  [R0201]  18.47 125.42 0 top
R67393  HDMI_R_P4@0_5%_2  [R0201]  18.46 124.27 0 top
R67394  HDMI_R_P4@0_5%_2  [R0201]  18.46 123.51 0 top
R67395  HDMI_R_P4@0_5%_2  [R0201]  18.46 122.45 0 top
R67396  HDMI_R_P4@0_5%_2  [R0201]  18.46 129.18 0 top
R67397  HDMI_R_P4@0_5%_2  [R0201]  18.47 128.03 0 top
R67398  *HDMI_CRT_P2@Short_4  [S0402]  33.63 132.7 90 top
R67401  SPK_VIKI@0_5%_6  [R0603]  41.83 94.38 270 top
R67402  SPK_VIKI@0_5%_6  [R0603]  38.88 94.38 270 top
R67403  SPK_VIKI@0_5%_6  [R0603]  48.38 94.53 270 top
R67404  SPK_VIKI@0_5%_6  [R0603]  44.78 94.4 270 top
R67411  *0_5%_4  [R0402]  57.97 190.78 270 bottom
R67412  *0_5%_4  [R0402]  54.92 190.78 270 bottom
R67413  2.2K_5%_4  [R0402]  96.41 107.3 270 top
R67414  *0_5%_4  [R0402]  56.95 190.78 270 bottom
R67415  *0_5%_4  [R0402]  55.93 190.78 270 bottom
R67418  *0_5%_2  [R0201]  93.53 185.57 90 bottom
R67422  *0_5%_2  [R0201]  201.04 123.72 180 bottom
R67447  0_5%_4  [R0402]  144.61 107.34 0 top
R67448  0_5%_4  [R0402]  146.27 109.78 0 top
R67461  USB3_P2@0_1%_4  [R0402]  208.27 115.89 270 bottom
R67462  USB3_P2@0_1%_4  [R0402]  207.27 115.89 270 bottom
R67470  *Short_4  [S0402]  12.25 62.03 0 bottom
R67474  8111K@10K_5%_4  [R0402]  28.88 164.87 0 top
R67475  *8111K@0_5%_4  [R0402]  30.92 164.87 180 top
R67476  8111K@0_5%_4  [R0402]  30.92 165.88 180 top
R67477  8111K@2.49K_1%_4  [R0402]  25.7 170.72 0 top
R67478  *2.2K_1%_2  [R0201]  26.12 46.02 180 bottom
R67481  2.2K_5%_2  [R0201]  82.81 109.7 0 top
R67482  2.2K_5%_2  [R0201]  82.81 110.46 0 top
R67483  *20K_1%_2  [R0201]  111.6 112.72 0 bottom
R67484  100K_5%_2  [R0201]  149.03 100.35 180 top
R67485  100K_5%_2  [R0201]  149.03 99.59 180 top
R67486  100K_5%_2  [R0201]  149.03 97.3 180 top
R67487  100K_5%_2  [R0201]  149.03 96.54 180 top
R67492  *Short_4  [S0402]  93.68 100.13 90 bottom
R67493  *Short_4  [S0402]  94.8 100.13 90 bottom
R67496  P4@0_1%_4  [R0402]  94.8 100.91 90 bottom
R67497  P4@0_1%_4  [R0402]  93.68 100.91 90 bottom
R67498  RS232_VIKI@0_1%_4  [R0402]  224.6 122.8 0 top
R67499  RS232_VIKI@0_1%_4  [R0402]  224.6 121.65 0 top
R67504  I219@0_5%_4  [R0402]  28.88 165.88 180 top
R67505  I219@0_5%_4  [R0402]  25.71 161.82 180 top
R67506  8111K@0_5%_4  [R0402]  25.71 162.84 180 top
R67507  I219@0_5%_4  [R0402]  33.33 175.34 270 top
R67508  8111K@0_5%_4  [R0402]  32.23 176.07 90 top
R67509  *I219@10K_5%_4  [R0402]  16.44 166.39 90 bottom
R67510  *I219@10K_5%_4  [R0402]  14.28 163.85 180 top
R67511  *I219@10K_5%_4  [R0402]  14.28 164.87 180 top
R67512  *I219@10K_5%_4  [R0402]  14.28 162.84 180 top
R67513  I219@0_5%_4  [R0402]  30.92 166.9 0 top
R67514  2_1%_6  [R0603]  56.44 123.85 270 top
R67524  *I219@10K_5%_4  [R0402]  27.49 164.21 90 top
R67525  *I219@0_5%_4  [R0402]  9.2 163.6 270 top
R67526  *I219@0_5%_4  [R0402]  12.75 163.6 90 top
R67529  I219@2.2K_5%_2  [R0201]  116.25 118.84 270 top
R67530  I219@2.2K_5%_2  [R0201]  115.52 118.85 270 top
R67532  22_1%_4  [R0402]  32.44 48.92 0 bottom
R67539  *Short_4  [S0402]  29.52 55.9 180 bottom
R67551  *Short_8  [S0805]  77.4 190.9 0 bottom
R67555  *NFC_P2@10K_1%_2  [R0201]  58.57 92.49 180 top
R67556  *NFC_P2@3.3K_5%_2  [R0201]  68.04 93.71 0 top
R67557  *NFC_P2@3.3K_5%_2  [R0201]  59.59 92.49 180 top
R67560  *NFC_P2@Short_6  [S0603]  69.98 98.23 270 top
R67561  *NFC_P2@4.7K_5%_4  [R0402]  59.11 95.91 0 top
R67562  *NFC_P2@Short_4  [S0402]  57.06 96.98 270 top
R67563  *NFC_P2@4.7K_5%_4  [R0402]  66.94 97.14 180 top
R67564  *NFC_P2@0_5%_4  [R0402]  60.98 92.39 0 top
R67565  *NFC_P2@Short_6  [S0603]  57.26 94.6 90 top
R67566  *NFC_P2@0_5%_4  [R0402]  65.92 93.59 0 top
R67567  *NFC_P2@0_5%_4  [R0402]  69.75 94.45 270 top
R67568  NFC_P2@4.7K_5%_4  [R0402]  62.9 97.14 180 top
R67569  NFC_P2@10K_1%_2  [R0201]  68.89 93.56 270 top
R67570  *NFC_P2@0_5%_4  [R0402]  64.13 93.6 180 top
R67571  NFC_P2@4.7K_5%_4  [R0402]  61.39 95.91 0 top
R67572  *NFC_P2@3.3K_5%_2  [R0201]  66.26 92.72 180 top
R67573  *NFC_P2@4.7K_5%_4  [R0402]  65.21 97.15 0 top
R67574  *0_5%_4  [R0402]  44.12 124.07 270 top
R67575  *0_5%_4  [R0402]  44.12 125.81 90 top
R67582  57.6K_1%_4  [R0402]  3.1 44.85 90 bottom
R67583  *100K_1%_4  [R0402]  3.1 52.37 270 bottom
R67586  54.9K_1%_4  [R0402]  6.49 54.22 270 bottom
R67591  *Short_4  [S0402]  6.66 45.92 270 bottom
R67592  10K_1%_2  [R0201]  7.67 45.74 270 bottom
R67593  *100K_1%_2  [R0201]  11.1 45.74 90 bottom
R67594  *1M_1%_2  [R0201]  10.09 45.74 270 bottom
R67595  *HDMI_CRT_P2@Short_2  [R0201]  31.99 122.94 180 top
R67596  *HDMI_CRT_P2@Short_2  [R0201]  31.98 124.29 180 top
R67597  *HDMI_CRT_P2@Short_4  [S0402]  33.04 119.78 0 top
R67598  I219@0_5%_4  [R0402]  21.93 158.93 180 top
R67599  I219@0_5%_4  [R0402]  22.28 160.3 90 top
R67600  0_5%_4  [R0402]  14.39 41.87 270 bottom
R67601  0_5%_4  [R0402]  16.05 42.21 0 bottom
R67602  0_5%_4  [R0402]  25.17 43.59 90 bottom
R67604  2.2K_5%_4  [R0402]  149.08 110.22 0 top
R67606  *SM@10K_1%_2  [R0201]  210.46 92.79 0 top
R67851  57.6K_1%_4  [R0402]  5.47 54.22 270 bottom
R67852  100K_1%_4  [R0402]  7.78 42.52 270 bottom
R67853  2.2K_5%_2  [R0201]  94.71 108.72 90 top
R67854  2.2K_5%_2  [R0201]  95.45 108.69 90 top
R67855  *Short_6  [S0603]  94.16 189.63 90 bottom
R67856  *Short_6  [S0603]  203.25 123.97 0 bottom
R67857  2.2K_5%_2  [R0201]  94 180.58 0 bottom
R67858  2.2K_5%_2  [R0201]  92.67 184.45 180 bottom
R67859  2.2K_5%_2  [R0201]  96.18 108.68 90 top
R67860  2.2K_5%_2  [R0201]  96.95 108.68 90 top
R67861  P4@0_1%_4  [R0402]  205.72 97.65 90 top
R67862  *P4@0_5%_4  [R0402]  151.99 210.39 270 bottom
R67864  P4@1K_5%_4  [R0402]  139.08 209.46 270 top
R67865  10K_1%_4  [R0402]  32.41 52.83 0 bottom
R67866  *HDD_R@Short_4  [S0402]  220.82 106.9 0 top
R67867  4.75K_1%_4  [R0402]  18 55.41 270 bottom
R67868  0_1%_4  [R0402]  125.1 120.09 180 top
R67869  HDMI_R_P4@0_5%_2  [R0201]  32.44 122.94 0 top
R67870  HDMI_R_P4@0_5%_2  [R0201]  32.43 124.29 0 top
R67871  *10K_5%_4  [R0402]  171.17 105.4 90 top
R67873  *SEN_P4@0_1%_4  [R0402]  147.54 216.2 180 top
R67875  *SEN_P4@0_1%_4  [R0402]  147.6 214.95 0 top
R67876  *P4@100K_1%_4  [R0402]  147.53 210.34 90 bottom
R67877  *P4@100K_1%_4  [R0402]  149.84 213.7 90 bottom
R67878  *Short_4  [S0402]  30.38 44.52 180 bottom
R67879  *Short_4  [S0402]  30.41 48.03 0 bottom
R67880  *Short_4  [S0402]  28.14 50.87 90 bottom
R67881  *0_5%_4  [R0402]  115.97 117.48 270 top
R67882  *0_5%_4  [R0402]  114.46 114.44 270 top
R67883  I219@1K_1%_4  [R0402]  85.14 135.91 90 top
R67884  10K_1%_2  [R0201]  49.51 190.69 180 top
R67885  P4@0_5%_4  [R0402]  184.71 100.58 180 top
R67886  *Short_4  [S0402]  182.9 100.58 180 top
R67887  *Short_4  [S0402]  32.41 54.76 180 bottom
R67888  10K_1%_4  [R0402]  32.41 53.79 0 bottom
R67889  2.2K_5%_4  [R0402]  122.58 123.67 270 top
R67890  10K_5%_4  [R0402]  28.45 44.32 270 bottom
R67891  *0_5%_4  [R0402]  19.87 54.51 90 bottom
R67892  *0_5%_4  [R0402]  20.88 54.51 90 bottom
R67893  0_5%_4  [R0402]  20.96 44.29 270 bottom
R67894  0_5%_4  [R0402]  19.94 44.29 270 bottom
R67895  22_1%_4  [R0402]  31.93 35.33 180 bottom
R67896  22_1%_4  [R0402]  31.93 37.61 180 bottom
R67897  22_1%_4  [R0402]  32.82 50.26 180 bottom
R67898  22_1%_4  [R0402]  32.36 51.61 180 bottom
R67899  22_1%_4  [R0402]  31.93 40.03 180 bottom
RV1  MESD05N92ULA  [DFN1006-3-1X0_6-0_55H-3P]  10.34 61.52 0 bottom
RV2  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  11.38 66.82 270 bottom
RV3  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  11.38 66.83 90 top
SW2  *NDT016-G1A-KKKT  [SW-NDT016-G1A-KKKT-4P]  13.62 152.24 180 bottom
SW4  TME-532W-Q-T/R_439  [SW-TME-532-V-6P]  65.3 183 270 bottom
SW5  *T3AL-23S-Q-T/R  [SW-T3AL-23-Q-TR-4P]  231.37 112.45 180 bottom
T1  *TP  [TP2050]  58.31 128.85 0 top
T2  *TP  [TP2050]  60.94 128.89 0 top
TP1  *  [TP2050]  93.76 168.26 180 bottom
TP2  *HDMI_CRT_P2@TP  [TP2650]  30.03 159.15 180 top
TP3  *  [TP2050]  89.67 136.38 0 top
TP5  *  [TP2050]  118.36 112.76 180 bottom
TP6  *  [TP2050]  88.37 136.29 0 top
TP7  *  [TP2050]  95.96 129.56 180 bottom
TP9  *  [TP2050]  112.15 119.83 0 top
TP10  *  [TP2050]  106.69 129.7 0 top
TP11  *  [TP2050]  106.67 112.26 0 top
TP12  *  [TP2050]  111.84 117.9 0 top
TP14  *  [TP2675]  131.96 109.68 270 bottom
TP15  *  [TP2675]  118.88 105.51 270 bottom
TP16  *  [TP2675]  119.08 103.5 270 bottom
TP17  *  [TP2675]  131.88 107.67 270 bottom
TP18  *  [TP2675]  123.75 100.61 270 bottom
TP19  *  [TP2675]  118.77 107.44 270 bottom
TP20  *  [TP2050]  103.48 112.12 0 top
TP21  *  [TP2050]  114.1 117.95 180 bottom
TP22  *PAD  [TP2050]  127.48 158.92 180 bottom
TP23  *PAD  [TP2050]  131 157.28 0 top
TP24  *PAD  [TP2050]  126.64 157.7 180 bottom
TP25  *PAD  [TP2050]  129.36 156.5 0 top
TP26  *PAD  [TP2050]  129.34 157.78 0 top
TP27  *PAD  [TP2050]  122.26 163.27 0 top
TP28  *PAD  [TP2050]  120.95 163.01 0 top
TP29  *PAD  [TP2050]  126.64 161.61 0 top
TP30  *PAD  [TP2050]  132 158.15 0 top
TP31  *PAD  [TP2050]  129.46 160.84 0 top
TP32  *PAD  [TP2050]  128.3 161.44 0 top
TP33  *PAD  [TP2050]  123.98 160.42 0 top
TP34  *PAD  [TP2050]  125.7 162.48 0 top
TP35  *PAD  [TP2050]  127.68 160.23 0 top
TP36  *PAD  [TP2050]  125.79 160.55 0 top
TP37  *PAD  [TP2050]  127.23 157.28 0 top
TP38  *PAD  [TP2050]  122.83 162.05 0 top
TP39  *PAD  [TP2050]  125.61 159.13 0 top
TP40  *PAD  [TP2050]  130.49 161.67 0 top
TP41  *PAD  [TP2050]  126.14 157.95 0 top
TP42  *PAD  [TP2050]  124.43 162.71 0 top
TP44  *PAD  [TP2050]  121.57 161.81 0 top
TP45  *PAD  [TP2050]  127.02 141.71 180 bottom
TP46  *PAD  [TP2050]  124.71 161.46 0 top
TP47  *PAD  [TP2050]  127.05 142.98 180 bottom
TP48  *PAD  [TP2050]  122.73 160.78 0 top
TP50  *PAD  [TP2050]  129.37 154.89 0 top
TP52  *PAD  [TP2050]  130.87 159.02 0 top
TP54  *PAD  [TP2050]  118.32 98.52 180 bottom
TP55  *PAD  [TP2050]  118.37 100.43 180 bottom
TP65  *  [TP2050]  112.32 179.22 0 top
TP66  *  [TP2050]  111.08 178.9 0 top
TP67  *  [TP2050]  113.56 178.04 0 top
TP68  *  [TP2050]  112.21 177.89 0 top
TP69  *  [TP2050]  130.74 177.19 0 top
TP70  *  [TP2050]  115.91 202.89 180 bottom
TP71  *  [TP2050]  115.91 200.25 180 bottom
TP72  *  [TP2050]  115.9 201.61 180 bottom
TP73  *  [TP2050]  115.93 204.2 180 bottom
TP81  *PAD  [TP2050]  15.55 70 180 bottom
TP84  *TP  [TP2050]  18.98 55.52 0 bottom
TP88  *TP  [TP2050]  21.95 44.07 0 bottom
TP89  *TP  [TP2050]  21.8 55.6 0 bottom
TP90  *TP  [TP2050]  21.9 54.02 0 bottom
TP92  *TP  [TP2050]  22.91 44.93 0 bottom
TP93  *TP  [TP2050]  26.46 50.23 0 bottom
TP96  *PAD  [TP2050]  23.8 62 0 bottom
TP97  *PAD  [TP2050]  26.09 58.82 0 bottom
TP98  *PAD  [TP2050]  25.07 62 0 bottom
TP99  *PAD  [TP2050]  32.5 63.46 0 bottom
TP100  *PAD  [TP2050]  32.95 62.25 0 bottom
TP101  *PAD  [TP2050]  32.72 58.98 0 bottom
TP102  *PAD  [TP2050]  29.77 57.81 0 bottom
TP103  *PAD  [TP2050]  27.87 56.23 0 bottom
TP104  *PAD  [TP2050]  28.25 57.81 0 bottom
TP2092  *PAD  [TP2050]  31.08 71.16 180 bottom
TP9000  *TP  [TP2050]  96.65 198.16 0 top
TP9011  *  [TP2050]  89.81 121.6 0 top
TP9012  *  [TP2050]  85.59 120.06 0 top
TP9018  *  [TP2050]  83.22 122.84 0 top
TP9023  *  [TP2050]  24.18 38.88 90 bottom
TP9026  *  [TP2050]  77.14 126.49 0 top
TP9027  *  [TP2050]  86.92 137.44 0 top
TP9029  *PAD  [TP2050]  191.3 123.46 0 top
TP9030  *  [TP2050]  115.92 198.96 180 bottom
TP9031  *  [TP2050]  116.61 196.22 180 bottom
TP9032  *  [TP2050]  116.59 194.91 180 bottom
TP9033  *  [TP2050]  116.55 193.58 180 bottom
TP9042  *TP  [TP2050]  94.24 127.12 180 bottom
TP9043  *TP  [TP2050]  95.3 126.39 180 bottom
TP9044  *TP  [TP2050]  94.39 128.44 180 bottom
TP9045  *TP  [TP2050]  149.08 103.83 0 top
TP9046  *HDMI_CRT_P2@PAD  [TP2050]  30.03 157.88 180 top
TP9059  *TP  [TP2050]  17.96 45.87 0 bottom
TP9060  *TP  [TP2050]  13.09 51.65 0 bottom
TP9061  *TP  [TP2050]  25.5 53.91 0 bottom
TP9062  *TP  [TP2050]  18.9 54.12 0 bottom
TP9063  *HDMI_CRT_P2@TP  [TP2650]  9.68 152.09 180 bottom
TP9064  *HDMI_CRT_P2@TP  [TP2650]  30.03 156.61 180 top
TP9066  *P4@TP  [TP2075]  157.07 209.62 0 top
TP9067  *P4@TP  [TP2075]  152.81 210.5 0 top
TP9068  *P4@TP  [TP2075]  155.75 208.13 0 top
TP9069  *P4@TP  [TP2075]  159.27 212.4 0 top
TP9070  *P4@TP  [TP2075]  153.12 217.06 0 top
TP9071  *P4@TP  [TP2075]  153.3 208.51 0 top
TP9072  *P4@TP  [TP2075]  157.99 207.92 0 top
TP9073  *P4@TP  [TP2075]  155.4 217.21 0 top
TP9074  *P4@TP  [TP2075]  157.53 211.5 0 top
TP13152  *  [TP2050]  15.19 171.6 0 top
TP13153  *  [TP2050]  15.17 170.33 0 top
TP13154  *  [TP2050]  13.9 170.33 0 top
TP13155  *  [TP2050]  14.19 167.1 0 top
TP13158  *  [TP2050]  15.12 166.14 180 bottom
TP13159  *  [TP2050]  15.59 163.73 0 top
TP13160  *  [TP2050]  15.57 165.01 0 top
TP13161  *  [TP2050]  15.64 162.26 0 top
TP13162  *  [TP2050]  14.52 165.77 0 top
TP13163  *  [TP2050]  58.59 98.34 0 top
TP13164  *  [TP2050]  66.32 99.03 0 top
TP13165  *  [TP2050]  115.69 115.03 180 bottom
TP13167  *  [TP2050]  61.45 186.3 180 bottom
TP13168  *  [TP2050]  102.47 193.09 180 bottom
TP13169  *TP  [TP2050]  107.5 181.84 180 bottom
TP13170  *P4@TP  [TP2075]  144.6 217.19 0 top
TP13171  *  [TP2050]  33.07 120.79 90 top
TP13172  *  [TP2050]  57.15 189.3 180 bottom
TP13173  *  [TP2050]  55.86 189.3 180 bottom
TP13174  *P4@TP  [TP2075]  149.63 215.92 180 bottom
TP13175  *P4@TP  [TP2075]  143.78 210.89 0 top
TP13176  *P4@TP  [TP2075]  149.58 212.44 180 bottom
TP13177  *  [TP2050]  58.42 188.95 180 bottom
TP13178  *  [TP2050]  54.54 189.07 180 bottom
TP13179  *  [TP2050]  61.15 191.28 180 bottom
TP13180  *TP  [TP2050]  164.63 111.91 180 bottom
TP13181  *TP  [TP2050]  165.9 111.91 180 bottom
U1  CML_U_43E_IL_IP_DDR4  [BGA1528-INTEL-CML-U]  111.55 143.42 270 bottom
U2  G781P8  [MSOP8-4_9-65-G547]  89.59 186.53 270 bottom
U3  *APL3512ABI-TRG  [SOT23-5-2_8-95-5P-G708]  94.03 107.03 90 bottom
U8  EV@N17S-G1-A1  [BGA595-NVIDIA-N13P-GV2-S-A2]  130.52 193.15 90 bottom
U9  EV@NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  107.24 185.19 180 bottom
U11  EV@NL17SZ32DFT2G  [SOT353-2_1-65-5P]  128.27 210.72 180 bottom
U12  PS8743BQFN40GTR-B1  [QFN40-6X4-4-41P-0_8H]  18.72 68.98 90 top
U14  SLGC55544VTR  [QFN16-3X3-5-17P-TPS2546RTER]  18.95 96.97 180 top
U15  G524B2T11U  [SOT23-5-2_8-95-5P-G708]  19.41 93.67 180 bottom
U18  G524B2T11U  [SOT23-5-2_8-95-5P-G708]  217.35 107.59 270 bottom
U19  APL3512ABI-TRG  [SOT23-5-2_8-95-5P-G708]  74.35 194.97 0 top
U20  ALC255-CG  [QFN48-6X6-4-49P-ALC280]  19.61 32.41 270 bottom
U23  HDMI_R_P4@PTN3366BS  [QFN32-5X5-5-37P-0_85H]  23.17 141.63 180 top
U25  GST5009B LF  [TRF-N1010G-25P]  32.5 184 180 bottom
U30  HDMI_CRT_P2@PS8339BQFN56GTR2-A1  [QFN56-7X7-4-69P]  24.82 126.01 180 top
U33  NPCT750AABYX  [QFN32-5X5-5-33P-0_85H]  87.69 98.07 90 top
U35  CNV@NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  188.4 116.61 270 top
U36  CNV@NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  185.86 116.61 270 top
U37  IT8987E/CX  [LQFP128-16X16-4-1_6H]  159.16 103.34 270 top
U40  RTS5170-GRT  [QFN24-4X4-5-25P-ALC5629]  29.01 61.36 0 bottom
U42  HDD_R@SN75LVCP601RTJR  [PWQFN20-4X4-5-26P-0_8H]  229.42 115.72 180 top
U67  HDMI_CRT_P2@RTD2166-CGT  [QFN32-4X4-4-33P-0_9H]  30.28 152.68 90 top
U2014  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  88.86 106.94 90 top
U2015  74AUP1G07GW  [SOT353-1-2_125-65-5P]  85.55 106.94 270 top
U6504  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  112.96 110.13 180 bottom
U6509  SM@AU9560B62-GBS-GR  [SSOP28-7_8-65-2H]  216.97 95.91 90 top
U6510  AP21510FM-7  [DFN2018-6-1_8X2-5-7P]  21.52 57.55 180 bottom
U6511  CYPD4126-40LQXIT  [QFN40-6X6-5-41P-0_6H]  21.77 49.3 0 bottom
U6515  P4@BMA253  [LGA12-2X2-5-1H]  142.55 214.65 0 top
U6516  P4@IT8353VG-128/BX  [BGA25-ITE-IT8353VG]  154.61 214.14 0 top
U6517  G781-1P8  [MSOP8-4_9-65]  197.16 124.86 270 bottom
U6521  SP@RTL8111K-CG  [QFN48-6X6-4-49P-ALC280]  19.99 166.01 90 top
U6523  DPS1113FIA-13  [QFN17-4X4-5-14P]  5.9 49.93 180 bottom
U6525  P4@HGDEDM013A  [SENSOR-1_3X0_9-5-4P]  138.7 211.7 180 top
U6526  *W25Q128JVSIQ  [SOIC8-7_9-1_27-2_16H]  125.27 107.46 270 bottom
U6528  SP@W25Q256JVEIQ  [SON8-8X6-1_27-9P]  125.27 107.46 270 bottom
U6530  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  17.82 91.62 90 top
U6531  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  18.77 107.26 90 top
VC2  TVM0G5R5M220R  [C0402]  16.02 133.83 0 bottom
VRAM1  EV@K4G80325FB-HC28_GDDR5_170P  [BGA170-HYNIX-H5GQ1H24MJR]  158.9 178.02 180 bottom
VRAM2  EV@K4G80325FB-HC28_GDDR5_170P  [BGA170-HYNIX-H5GQ1H24MJR]  158.9 200.42 0 bottom
Y1  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-SMT]  103.82 115.75 0 bottom
Y2  24MHZ/20ppm  [XTL-2X1_6-1_35X1_05]  125.59 113.73 0 bottom
Y3  EV@27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7-0_8H]  126.17 175.79 0 bottom
Y4  25MHZ +-10PPM  [XTL-3_2X2_5-2_2X1_7]  31.6 169.57 90 top

## Library data of the parts
C1 C2 C5-C8 C11-C28 C30-C119 C122-C195 C200-C206 C208 C209 C212-C227 C229-C247 C249-C280 C347-C384 C386-C403 C406-C433 C438-C462 C471-C506 C508-C513 C515-C524 C526-C533 C536 C537 C542 C545-C548 C550-C562 C566 C567 C595 C613 C614 C616 C618 C619 C628 C631-C636 C641 C642 C645 C646 C675 C676 C691 C692 C695-C699 C706-C709 C711 C713-C733 C735 C736 C770-C772 C785 C786 C788-C795 C800-C802 C804 C809 C811-C817 C841 C842 C853 C880-C883 C890 C900 C912 C913 C1189 C1190 C1211 C1214 C1217 C1643-C1653 C1687-C1693 C2336 C2337 C2609 C2611 C2612 C2616 C6550-C6557 C6565 C6569 C6570 C6573-C6575 C6577 C6578 C6586-C6589 C6594-C6602 C6607 C6615 C6618-C6620 C6622 C6623 C6626 C20000 C20003 C20008-C20023 C20039-C20051 C20053 C20055-C20063 C20065-C20078 C20081-C20083 C20085 C20088-C20091 C20130-C20132 C96247-C96249 C96254-C96260 C96265-C96269 C96271 C96300-C96313 C96319 C96320 C96326 C96329 C96332 C96340 C96341 C96343 C96344 C96348-C96350 EC1 EC5 EC6 EC11-EC13 PC1-PC12 PC15-PC20 PC25 PC35-PC37 PC51 PC81-PC83 PC152 PC164-PC168 PC170 PC172 PC217-PC222 PC224 PC225 PC227-PC236 PC242 PC423 PC551 PC561-PC563 PC571 PC572 PC574 PC581 PC756 PC5000-PC5023 PC6000-PC6059 PC6228-PC6231 PC7003-PC7006 PC7010 PC7020 PC7025 PC7027 PC7029-PC7035 PC7037-PC7043 PC7046 PC7047 PC7049-PC7061 PC7063-PC7070 PC7072-PC7093 PC7096 PC7097 PC7099-PC7106 PC8000-PC8003 PC8005-PC8007 PC8009 PC9000-PC9006 PC9008 PC9009 PC9012-PC9020 PC9022-PC9030 PC9053-PC9060 PC9062-PC9069 PC9071-PC9091 PC9097 PC9098 VC2 = CAP_NON-POL_BGM
C3 C228 C248 C282 C463 C464 C543 C544 C563-C565 C568 C569 C572-C578 C580 C581 C583-C594 C596-C599 C601-C604 C638 C639 C669 C670 C680 C689 C734 C737 C740-C745 C749 C750 C752 C753 C805 C844-C846 C1044 C1208 C1210 C2321 C2335 C2374 C2542 C6560 C6562-C6564 C6566 C6568 C6571 C6572 C6580 C6609 C6610 C6616 C20001 C20002 C20064 C20086 C20087 C20099-C20129 C20133-C20143 C96242 C96261-C96264 C96270 C96272 C96322 C96327 C96328 C96331 C96346 EC9 EC10 PC7000 PC7001 PC7007-PC7009 PC7011-PC7019 PC7021-PC7024 PC7026 PC8008 PC8010 PC8011 = CAP NON-POL_BGM
C29 C385 PC7036 PC7044 PC7045 PC7062 PC7094 PC7095 PC9007 PC9010 PC9011 PC9021 = CAP_POL_BGM
C808 C856-C861 C20004-C20006 = C
C6612-C6614 C96333 = C-0603
CN1 CN46 = Header_2P_BGM
CN2 CN3 = USB3_9P_4fix_V3_BGM
CN4 = CON12X1_2
CN8 = RJ45_8P_4fix_V3_BGM
CN10 = USB3_1_24P_8F_V5_BGM
CN11 = Housing_20P_FIX6P_BGM
CN13 = FFCFPC_4P_2F_BGM
CN14 CN33 = FFCFPC_8P_BGM
CN16 = NGFF_79P_MKEY_NAME_BGM
CN17 = NGFF_79P_EKEY_NAME_BGM
CN18 CN19 = FFCFPC_28P_BGM
CN21 = Dsub_17P_V02_BGM
CN29 = FFCFPC_40P_BGM
CN37 = HDMI_19P_10444-19001_BGM
CN48 = FFCFPC_22P_BGM
CN49 = FFCFPC_30P_BGM
CN50 = HEADER_4P_50208-00401-V02_BGM
CN51 = AUDIO_2SJ3127-023111F_6P_BGM
CN52 CN55 = FFCFPC_16P_BGM
CN53 = FFCFPC_10P_2F_BGM
CN58 = FFCFPC_15P_BGM
CN59 = HOUSING_8P_2F_BGM
CN60 = Socket_8P_V2_BGM
CN62 = SDCARD_15P_BGM
CN63 CN64 = HEADER_4P_2F_BGM_0
D3 D11 D6543 PD9001 = DIODE_BGM
D4 D12 D13 D51 D60 D62-D64 D13093 PD8004 PD8005 = Schottky_DIODE_BGM
D10 D22 D33 D50 D13081-D13092 D13094 D13095 EC7 EC8 EC16 EC17 = TVS_DIODE_BGM
D14 = BAT54A_BGM
D16-D19 D65 = Varistor_BGM
D72 = DIODE SCHOTTKY_1
D13096 = TVS_DIODE_UNI_V2_BGM
D13099 D13100 RV1 = TVS_DIODE_DUAL_BGM
D13101 D13102 = VARISTOR_BGM
ESD3 ESD4 RV2 RV3 U6530 U6531 = AZ1045-04F_BGM
F1 F2 = FUSE_BGM
FAN3 = Header_4P_BGM
HE1 = HALL_IC_3P_BGM
HOLE2-HOLE6 HOLE12-HOLE18 HOLE21-HOLE24 HOLE27 HOLE28 HOLE31-HOLE35 = 3x2_1.1
J9007 = OPEN
JDIM1 JDIM02 = DDR4_DIMM_260P_BGM
L2-L8 L11-L13 L15 L16 L22-L24 L27-L31 = BEAD_BGM
L17 = INDUCTOR_0
L4000 = INDUCTOR_BGM_L3_2X2_5-3_2_4.7UH
PD3 PD4 PD8000 PD8001 = ZENER_DIODE_BGM
PD8002 PD8003 PD8006 PD8007 = DIODE SCHOTTKY
PD9002 = BAT54C_BGM
PJ1 = HEADER_8P_2F_BGM
PJ3005 PJ3008 PJ5000 PJ5001 PJ6001 PJ6003 PJ9002 PJ9003 PJ9005 PR1 PR2 PR4-PR6 PR8 PR11 PR17 PR19 PR25 PR26 PR30 PR32 PR208 PR210 PR273 PR274 PR276 PR284 PR566 PR569 PR2060 PR3022 PR5000-PR5003 PR5005 PR5008-PR5011 PR5013 PR5014 PR6002 PR6004 PR6005 PR6008 PR6013 PR6015 PR6016 PR6020 PR6022 PR6023 PR6025-PR6028 PR6414 PR6417 PR7012 PR7020 PR7025 PR7039 PR7044 PR7046 PR7051 PR7053 PR7058 PR7062 PR7067 PR7073 PR7074 PR7077 PR7079 PR7082 PR7083 PR7088 PR7089 PR7096 PR7097 PR7102 PR7105 PR7107 PR7109 PR7111 PR7113 PR7115 PR8010 PR8013-PR8015 PR8020 PR8026 PR8033 PR8034 PR8041 PR8049 PR8051 PR8052 PR8060 PR9008 PR9015-PR9017 PR9028 PR9029 PR9034 PR9067-PR9070 PR9072 PR9078 PR9079 PR9085 PR9090 PR9098 PR9244 PR9245 PR9248 PR9249 PR9256 PR9258 PR9259 PR9263 PR9275-PR9281 = SHORTPAD_V01_BGM
PJ8000 = DCJACK_30706-00042-001_BGM
PL5 PL12 PL14 PL551 PL5000 PL5001 PL6000 PL6001 PL7000-PL7003 PL9000-PL9002 = INDUCTOR_BGM
PQ1 PQ2 PQ29 PQ30 PQ35 PQ7002 PQ9008 PQ9054 = MOS-N_8P_BGM
PQ6 PQ10 PQ12 PQ14 PQ17 PQ19 PQ25 PQ6000 PQ6001 PQ8000 PQ8015 PQ8019 PQ9009-PQ9011 PQ9050 PQ9084-PQ9086 Q9 Q14-Q16 Q19-Q22 Q29 Q33 Q34 Q63 Q81 Q85 Q6509 Q6512 Q6520 Q6531 Q6540 Q6548 Q6555-Q6559 Q6562 Q6565 Q6566 Q6570 = MOS-N_3P_ESD_BGM
PQ7 PQ16 PQ9083 Q31 Q6522 = DTC144EU_BGM
PQ9 PQ11 = MOS-N_3P_BGM
PQ7000 PQ7001 PQ7004 PQ9000 PQ9001 = MOS-N-Dual_10P_BGM
PQ7003 = MOS-N_8P_SCH_BGM
PQ8001 PQ8002 PQ8006 PQ8007 = MOS-P_8P_BGM
PQ8003 PQ8004 PQ8009 PQ8010 PQ8014 PQ8017 Q23 Q30 Q32 = MOS-P_3P_BGM
PQ8005 Q3 Q27 Q6521 Q6535 Q6539 Q6554 Q6564 Q6567-Q6569 = MOS-N_Dual_6P_ESD_BGM
PQ8008 PQ8011 = PNP_BGM
PQ8012 PQ8013 PQ8016 PQ8018 = PNP_Dual_6P_BGM_2
PR3 PR209 R77-R81 = R_Current_SEN_BGM
PR7 PR9 PR10 PR12-PR16 PR18 PR22 PR23 PR28 PR29 PR31 PR33 PR39 PR40 PR59 PR79 PR80 PR98 PR99 PR104-PR106 PR111 PR116 PR118 PR120 PR126 PR191 PR204-PR207 PR211 PR230 PR235 PR268-PR270 PR272 PR275 PR277 PR283 PR551 PR567 PR568 PR3020 PR3021 PR5004 PR5006 PR5007 PR5012 PR6000 PR6001 PR6003 PR6006 PR6007 PR6009-PR6012 PR6014 PR6017-PR6019 PR6021 PR6024 PR6029-PR6031 PR6416 PR6418 PR7000-PR7006 PR7008-PR7011 PR7013-PR7019 PR7022-PR7024 PR7026-PR7031 PR7033-PR7038 PR7040-PR7043 PR7045 PR7047-PR7050 PR7052 PR7054-PR7057 PR7059-PR7061 PR7063-PR7066 PR7068 PR7069 PR7072 PR7075 PR7076 PR7078 PR7080 PR7081 PR7084 PR7085 PR7087 PR7090-PR7092 PR7095 PR7098-PR7100 PR7103 PR7104 PR7106 PR7108 PR7110 PR7112 PR7114 PR7116 PR8000-PR8009 PR8011 PR8012 PR8016-PR8019 PR8021-PR8025 PR8027-PR8032 PR8035-PR8040 PR8042-PR8048 PR8050 PR8053-PR8059 PR8061-PR8064 PR9000-PR9002 PR9004 PR9006 PR9009 PR9011 PR9013 PR9014 PR9018 PR9019 PR9021-PR9027 PR9030-PR9033 PR9073-PR9077 PR9080-PR9082 PR9086-PR9089 PR9091-PR9097 PR9099-PR9105 PR9227 PR9255 PR9268-PR9272 R1 R2 R9-R26 R28-R46 R51 R56 R59-R61 R63-R65 R67 R72-R74 R82 R83 R85-R92 R94-R98 R100 R102-R104 R106-R112 R114-R126 R134-R139 R144-R148 R152-R155 R157-R161 R166-R169 R178-R180 R183 R186-R188 R191 R194 R197 R205 R206 R208 R209 R212 R215-R217 R220-R222 R224-R227 R231-R244 R296 R297 R299 R305-R307 R310-R326 R329-R332 R339 R341-R359 R361-R370 R372-R376 R378 R380 R382-R386 R391 R394-R399 R402-R407 R409-R411 R414-R418 R439-R443 R446 R447 R451 R452 R454 R458 R461 R462 R464 R465 R468 R469 R471-R479 R484 R486 R487 R489-R491 R494 R495 R497-R500 R502-R507 R509 R510 R516-R519 R551 R554 R559 R562 R566 R567 R574-R576 R579 R580 R583 R586 R588 R589 R592 R593 R596-R601 R604-R609 R645-R649 R651-R655 R662-R668 R670-R679 R720 R732 R734 R735 R746-R749 R752-R765 R770 R772 R773 R779 R803 R825 R830 R832 R842-R845 R849 R850 R894 R895 R953 R956 R960 R971 R978 R979 R1234-R1239 R1250-R1253 R1275-R1281 R1616 R2228 R2229 R2257 R2525 R2652-R2667 R4009 R4023 R4024 R9261 R9340 R10880 R25270 R25271 R25282-R25284 R25298 R25300 R25303 R25304 R25306-R25310 R25312 R25314-R25318 R25321-R25323 R25330 R25336 R25343 R25344 R25346-R25348 R25357-R25359 R25362 R25367-R25376 R25378-R25399 R25403 R25413 R25415 R25428-R25431 R25433 R25434 R25436-R25441 R25444-R25446 R25448 R25456 R25466-R25469 R25472 R25474 R25475 R25477 R25481 R25482 R25487-R25490 R25492-R25494 R25501 R25519-R25522 R25524-R25535 R25554-R25576 R25578-R25580 R25596-R25612 R25614 R25615 R25617-R25622 R25624 R25625 R25628 R25630 R25632 R25637-R25639 R25641 R25643 R25645 R25646 R25667 R67358-R67362 R67367-R67370 R67375-R67398 R67401-R67404 R67411-R67415 R67418 R67422 R67447 R67448 R67461 R67462 R67474-R67478 R67481-R67483 R67492 R67493 R67496-R67499 R67504-R67514 R67524-R67526 R67529 R67530 R67532 R67539 R67551 R67555-R67557 R67560-R67575 R67582 R67583 R67586 R67591-R67602 R67604 R67606 R67851-R67861 R67864-R67871 R67873 R67875 R67878-R67885 R67887-R67899 = RES_BGM
PR7007 PR7021 PR7032 PR9274 = Thermistor_BGM
PR7093 PR7101 = 10K-0603-1%: tolerance: 1%
PU1 = BQ24780SRUYR_BGM
PU16 = G5335QT2U_BGM
PU3002 = TMP708_BGM
PU3003 = JW5222RSOTB#TRPBF_6P_V1_BGM
PU3004 = JW5213DFND_8P_BGM
PU5000 = TPS51486XRJER_18P_BGM
PU6000 = RT6256BGQUF_12P_BGM
PU6001 PU6002 PU9002 = AOZ1331DI_BGM
PU6003 = RT6258CGQUF_12P_BGM
PU7000 = RT3602AJGQW_48P_BGM_1
PU7001-PU7004 = RT9610BZQW_BGM
PU8000 PU8001 = AP2204K-ADJTRG1_BGM
PU9000 = RT8813DGQW_BGM
PU9003 = G9336ADJTP1U_BGM
PU9004 = G5335QT2U_V1_BGM
Q13 = 2N7002_3
Q28 Q6523 = NPN_BGM
Q86 = NPN_0
Q6508 = AP2331SA-7-01_BGM
Q6534 = G5250Q1T73U_BGM
Q6544 = NPN_V2_BGM
R3-R7 = RES_BGM: tolerance: CS00001JE18
R27 R47 R66 R68 R69 R84 R210 R211 R213 R228-R230 R421 R422 R424-R430 R432 R436 R445 R449 R459 R460 R463 R467 R470 R511 R512 R558 R560 R572 R573 R614 R736 R738 R1260 R1262 R1264-R1267 R1270 R1271 R1273 R1274 R25288 R25289 R25292 R25295 R25297 R25365 R25366 R25471 R25473 R25479 R25495 R25517 R25518 R67470 R67886 = RES_BGM: tolerance: CS00002JB38
R70 R71 R450 R455 R1272 R25458 R25459 R25462 R25589 = RES_BGM: tolerance: CS00003J951
R821 R822 R25377 = R_3
R890 R25311 R25320 R67484-R67487 = RES_S_BGM
R4008 = R_1
R25623 R25629 R25631 R25633-R25636 R25640 R25642 R25644 R25647 R25648 R25650 R25652 R67862 R67876 R67877 = RES_B_BGM
SW2 = SW_6P_R_BGM
SW4 = SW_6P_BGM
SW5 = SW_4P_BGM
T1 T2 TP1-TP3 TP5-TP7 TP9-TP12 TP14-TP42 TP44-TP48 TP50 TP52 TP54 TP55 TP65-TP73 TP81 TP84 TP88-TP90 TP92 TP93 TP96-TP104 TP2092 TP9000 TP9011 TP9012 TP9018 TP9023 TP9026 TP9027 TP9029-TP9033 TP9042-TP9045 TP9059-TP9064 TP9066-TP9074 TP13152-TP13155 TP13158-TP13165 TP13167-TP13181 = TP_BGM
TP9046 = PAD_0
U1 = CFL_U_43E_IL_IP_DDR4_8
U2 U6517 = G781_BGM
U3 = AP2821KTR-G1_BGM
U8 = GPU_N16S-GTR_595P_BGM
U9 U2014 U6504 = Logic_AND_BGM
U11 = NL17SZ32DFT2G_BGM
U12 = PS8743BQFN40GTR-B0_BGM
U14 = SLGC55544VTR_BGM
U15 U18 = MAX8863_2
U19 = APL3512ABI-TRG_BGM
U20 = ALC255-CG_BGM_0
U23 = PTN3366BS_BGM
U25 = NS680016_0
U30 = PS8339BQFN56GTR2-A1_56P_BGM
U33 = NPCT750AABYX_32P_BGM
U35 U36 = NL17SZ08DFT2G_5P_BGM
U37 = IT8987E/CX_BGM
U40 = RTS5170-GRT_BGM
U42 = SN75LVCP601RTJR_BGM
U67 = RTD2166-CG_BGM
U2015 = 74AUP1G07GW_BGM
U6509 = AU9560B62-GBS-GR_28P_BGM
U6510 = AP21510FM-7_BGM
U6511 = CYPD4225-40LQXIT_40P_BGM
U6515 = BMA253_12P_BGM
U6516 = IT8353VG-128/BX_BGM
U6521 = RTL8111K-CG_48P_BGM
U6523 = DPS1113FIA-13_17P_BGM
U6525 = ME268-002_0
U6526 = W25Q128JVSIQ_8P_BGM
U6528 = W25Q256JVEIQ_8P_BGM
VRAM1 VRAM2 = GDDR5_170P_BGM
Y1 = CRYSTAL_2P_BGM
Y2 Y3 = CRYSTAL_4P_BGM
Y4 = CRYSTAL2_2

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
50208-00401-V02-4P-L
  rect 0.508x0.991 smd: 1(-1.2,1.95) 2(-0.4,1.95) 3(0.4,1.95) 4(1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
50271-0040N-V01-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50271-00201-001-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
50950-0084N-001-8P-SOCKET
  round 0.838 hole 0.838 unplated: (2.5,-2)
  round 1.041 hole 1.041 unplated: (2.5,2)
  rect 0.838x1.397 smd: 1(-1.905,-4.8) 2(-0.635,-4.8) 3(0.635,-4.8) 4(1.905,-4.8) 5(1.905,4.8) 6(0.635,4.8) 7(-0.635,4.8) 8(-1.905,4.8)
50951-0084N-V01-8P-SOCKET
  rect 0.66x1.346 smd: 1(-1.905,-3.825) 2(-0.635,-3.825) 3(0.635,-3.825) 4(1.905,-3.825) 5(1.905,3.825) 6(0.635,3.825) 7(-0.635,3.825) 8(-1.905,3.825)
51540-03001-V01-30P-L
  rect 0.305x0.838 smd: 1(-7.25,3.175) 2(-6.75,3.175) 3(-6.25,3.175) 4(-5.75,3.175) 5(-5.25,3.175) 6(-4.75,3.175) 7(-4.25,3.175) 8(-3.75,3.175) 9(-3.25,3.175) 10(-2.75,3.175) 11(-2.25,3.175) 12(-1.75,3.175) 13(-1.25,3.175) 14(-0.75,3.175) 15(-0.25,3.175) 16(0.25,3.175) 17(0.75,3.175) 18(1.25,3.175) 19(1.75,3.175) 20(2.25,3.175) 21(2.75,3.175) 22(3.25,3.175) 23(3.75,3.175) 24(4.25,3.175) 25(4.75,3.175) 26(5.25,3.175) 27(5.75,3.175) 28(6.25,3.175) 29(6.75,3.175) 30(7.25,3.175)
  rect 0.787x2.007 smd: 31(-8.95,0) 32(8.95,0)
51619-01501-V03-15P-L
  rect 0.305x1.295 smd: 1(-3.5,2.8) 2(-3,2.8) 3(-2.5,2.8) 4(-2,2.8) 5(-1.5,2.8) 6(-1,2.8) 7(-0.5,2.8) 8(0,2.8) 9(0.5,2.8) 10(1,2.8) 11(1.5,2.8) 12(2,2.8) 13(2.5,2.8) 14(3,2.8) 15(3.5,2.8)
  rect 1.803x1.397 smd: 16(-5.15,0) 17(5.15,0)
51619-01601-V01-16P-L
  rect 0.305x1.295 smd: 1(-3.75,2.8) 2(-3.25,2.8) 3(-2.75,2.8) 4(-2.25,2.8) 5(-1.75,2.8) 6(-1.25,2.8) 7(-0.75,2.8) 8(-0.25,2.8) 9(0.25,2.8) 10(0.75,2.8) 11(1.25,2.8) 12(1.75,2.8) 13(2.25,2.8) 14(2.75,2.8) 15(3.25,2.8) 16(3.75,2.8)
  rect 1.803x1.397 smd: 17(-5.4,0) 18(5.4,0)
51653-0100N-V01-10P-L
  rect 0.305x1.295 smd: 1(-4.5,2.65) 2(-3.5,2.65) 3(-2.5,2.65) 4(-1.5,2.65) 5(-0.5,2.65) 6(0.5,2.65) 7(1.5,2.65) 8(2.5,2.65) 9(3.5,2.65) 10(4.5,2.65)
  rect 1.803x1.397 smd: 11(-6.65,0) 12(6.65,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
AUDIO-2SJ3127-023111F-6P
  oval 0.991x1.753 hole 0.508x1.245: 1(-4.55,-2.065) 2(4.15,-3.155) 3(4.15,-0.155) 4(4.15,3.845) 5(-4.55,0.375) 6(-4.55,4.245)
BGA25-ITE-IT8353VG
  round 0.254 smd: A1(-1,-1) A2(-1,-0.5) A3(-1,0) A4(-1,0.5) A5(-1,1) B1(-0.5,-1) B2(-0.5,-0.5) B3(-0.5,0) B4(-0.5,0.5) B5(-0.5,1) C1(0,-1) C2(0,-0.5) C3(0,0) C4(0,0.5) C5(0,1) D1(0.5,-1) D2(0.5,-0.5) D3(0.5,0) D4(0.5,0.5) D5(0.5,1) E1(1,-1) E2(1,-0.5) E3(1,0) E4(1,0.5) E5(1,1)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA595-NVIDIA-N13P-GV2-S-A2
  round 0.381 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A15(-10.7,0.84) A16(-10.7,1.64) A18(-10.7,3.32) A19(-10.7,4.12) A21(-10.7,5.8) A22(-10.7,6.6) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1528-INTEL-CML-U
  round 0.356 smd: A3(-22.315,-10.396) A36(-22.315,10.855) B2(-21.855,-10.855) B37(-21.855,11.315) C1(-21.396,-11.315) CP1(21.855,-11.315) CP37(21.855,11.315) CR2(22.315,-10.855) CR36(22.315,10.855)
  round 0.33 smd: A4(-22.315,-9.746) A35(-22.315,10.205) B3(-21.687,-10.227) B36(-21.687,10.687) C2(-21.227,-10.687) C37(-21.205,11.315) CN1(21.205,-11.315) CN37(21.205,11.315) CP2(21.687,-10.687) CP36(21.687,10.687) CR3(22.315,-10.205) CR35(22.315,10.205) D1(-20.746,-11.315)
  round 0.305 smd: A5(-22.292,-9.096) A6(-22.315,-8.232) A11(-22.315,-5.322) A12(-22.315,-4.38) A14(-22.315,-3.438) A15(-22.315,-2.496) A17(-22.315,-1.554) A18(-22.315,-0.613) A20(-22.315,0.329) A32(-22.315,8.228) A34(-22.315,9.555) AA4(-10.421,-9.365) AA9(-10.624,-6.21) AA24(-10.481,3.679) AA26(-10.481,4.606) AA34(-10.719,9.365) AB3(-9.763,-10.334) AB4(-9.763,-9.325) AB5(-10.162,-8.617) AB6(-10.162,-7.967) AB7(-10.162,-7.317) AB8(-10.162,-6.668) AB9(-9.7,-6.21) AB10(-10.162,-5.753) AB25(-10.025,4.142) AB27(-10.025,5.069) AB28(-10.025,5.719) AB29(-10.025,6.369) AB30(-10.025,7.019) AB31(-10.025,7.669) AB32(-10.025,8.32) AB33(-10.068,9.04) AB34(-10.068,9.69) AC4(-9.106,-9.365) AC5(-9.238,-8.617) AC6(-9.238,-7.967) AC7(-9.238,-7.317) AC8(-9.238,-6.668) AC10(-9.238,-5.753) AC24(-9.57,3.679) AC25(-9.114,4.142) AC26(-9.57,4.606) AC27(-9.114,5.069) AC28(-9.114,5.719) AC29(-9.114,6.369) AC30(-9.114,7.019) AC31(-9.114,7.669) AC32(-9.114,8.32) AC34(-9.417,9.365) AD4(-8.543,-9.69) AD9(-8.776,-6.21) AD24(-8.658,3.679) AD26(-8.658,4.606) AD33(-8.809,9.04) AD35(-8.809,10.245) AE4(-7.98,-9.365) AE5(-8.314,-8.617) AE6(-8.314,-7.967) AE7(-8.314,-7.317) AE8(-8.314,-6.668) AE9(-7.852,-6.21) AE10(-8.314,-5.753) AE24(-7.747,3.679) AE25(-8.203,4.142) AE26(-7.747,4.606) AE27(-8.203,5.069) AE28(-8.203,5.719) AE29(-8.203,6.369) AE30(-8.203,7.019) AE31(-8.203,7.669) AE32(-8.203,8.32) AE34(-8.202,9.365) AF3(-7.322,-10.334) AF4(-7.322,-9.325) AF5(-7.39,-8.617) AF6(-7.39,-7.967) AF7(-7.39,-7.317) AF8(-7.39,-6.668) AF10(-7.39,-5.753) AF25(-7.291,4.142) AF27(-7.291,5.069) AF28(-7.291,5.719) AF29(-7.291,6.369) AF30(-7.291,7.019) AF31(-7.291,7.669) AF32(-7.291,8.32) AF33(-7.551,9.04) AF34(-7.551,9.69) AG4(-6.665,-9.365) AG5(-6.467,-8.617) AG6(-6.467,-7.967) AG7(-6.467,-7.317) AG8(-6.467,-6.668) AG9(-6.929,-6.21) AG10(-6.467,-5.753) AG24(-6.835,3.679) AG26(-6.835,4.606) AG34(-6.9,9.365) AH4(-6.102,-9.69) AH9(-6.005,-6.21) AH24(-5.924,3.679) AH25(-6.38,4.142) AH26(-5.924,4.606) AH27(-6.38,5.069) AH28(-6.38,5.719) AH29(-6.38,6.369) AH30(-6.38,7.019) AH31(-6.38,7.669) AH32(-6.38,8.32) AH33(-6.293,9.04) AH35(-6.293,10.245) AJ4(-5.539,-9.365) AJ5(-5.543,-8.617) AJ6(-5.543,-7.967) AJ7(-5.543,-7.317) AJ8(-5.543,-6.668) AJ10(-5.543,-5.753) AJ25(-5.468,4.142) AJ27(-5.468,5.069) AJ28(-5.468,5.719) AJ29(-5.468,6.369) AJ30(-5.468,7.019) AJ31(-5.468,7.669) AJ32(-5.468,8.32) AJ34(-5.685,9.365) AK3(-4.882,-10.334) AK4(-4.882,-9.325) AK9(-5.081,-6.21) AK24(-5.013,3.679) AK26(-5.013,4.606) AK33(-5.034,9.04) AK34(-5.034,9.69) AL4(-4.224,-9.365) AL5(-4.619,-8.617) AL6(-4.619,-7.967) AL7(-4.619,-7.317) AL8(-4.619,-6.668) AL9(-4.157,-6.21) AL10(-4.619,-5.753) AL24(-4.101,3.679) AL25(-4.557,4.142) AL26(-4.101,4.606) AL27(-4.557,5.069) AL28(-4.557,5.719) AL29(-4.557,6.369) AL30(-4.557,7.019) AL31(-4.557,7.669) AL32(-4.557,8.32) AL34(-4.383,9.365) AM4(-3.661,-9.69) AM5(-3.695,-8.617) AM6(-3.695,-7.967) AM7(-3.695,-7.317) AM8(-3.695,-6.668) AM10(-3.695,-5.753) AM25(-3.646,4.142) AM27(-3.646,5.069) AM28(-3.646,5.719) AM29(-3.646,6.369) AM30(-3.646,7.019) AM31(-3.646,7.669) AM32(-3.646,8.32) AM33(-3.775,9.04) AM35(-3.775,10.245) AN4(-3.098,-9.365) AN5(-2.771,-8.617) AN6(-2.771,-7.967) AN7(-2.771,-7.317) AN8(-2.771,-6.668) AN9(-3.233,-6.21) AN10(-2.771,-5.753) AN24(-3.19,3.679) AN25(-2.734,4.142) AN26(-3.19,4.606) AN27(-2.734,5.069) AN28(-2.734,5.719) AN29(-2.734,6.369) AN30(-2.734,7.019) AN31(-2.734,7.669) AN32(-2.734,8.32) AN34(-3.168,9.365) AP3(-2.441,-10.334) AP4(-2.441,-9.325) AP9(-2.31,-6.21) AP24(-2.278,3.679) AP26(-2.278,4.606) AP33(-2.517,9.04) AP34(-2.517,9.69) AR4(-1.783,-9.365) AR5(-1.848,-8.617) AR6(-1.848,-7.967) AR7(-1.848,-7.317) AR8(-1.848,-6.668) AR10(-1.848,-5.753) AR25(-1.823,4.142) AR27(-1.823,5.069) AR28(-1.823,5.719) AR29(-1.823,6.369) AR30(-1.823,7.019) AR31(-1.823,7.669) AR32(-1.823,8.32) AR34(-1.866,9.365) AT4(-1.22,-9.69) AT9(-1.386,-6.21) AT24(-1.367,3.679) AT26(-1.367,4.606) AT33(-1.259,9.04) AT35(-1.259,10.245) AU4(-0.657,-9.365) AU5(-0.924,-8.617) AU6(-0.924,-7.967) AU7(-0.924,-7.317) AU8(-0.924,-6.668) AU9(-0.462,-6.21) AU10(-0.924,-5.753) AU24(-0.456,3.679) AU25(-0.911,4.142) AU26(-0.456,4.606) AU27(-0.911,5.069) AU28(-0.911,5.719) AU29(-0.911,6.369) AU30(-0.911,7.019) AU31(-0.911,7.669) AU32(-0.911,8.32) AU34(-0.65,9.365) AV3(0,-10.334) AV4(0,-9.325) AV5(0,-8.617) AV6(0,-7.967) AV7(0,-7.317) AV8(0,-6.668) AV10(0,-5.753) AV25(0,4.142) AV27(0,5.069) AV28(0,5.719) AV29(0,6.369) AV30(0,7.019) AV31(0,7.669) AV32(0,8.32) AV33(0,9.04) AV34(0,9.69) AW4(0.657,-9.365) AW5(0.924,-8.617) AW6(0.924,-7.967) AW7(0.924,-7.317) AW8(0.924,-6.668) AW9(0.462,-6.21) AW10(0.924,-5.753) AW24(0.456,3.679) AW25(0.911,4.142) AW26(0.456,4.606) AW27(0.911,5.069) AW28(0.911,5.719) AW29(0.911,6.369) AW30(0.911,7.019) AW31(0.911,7.669) AW32(0.911,8.32) AW34(0.65,9.365) AY4(1.22,-9.69) AY9(1.386,-6.21) AY24(1.367,3.679) AY26(1.367,4.606) AY33(1.259,9.04) AY35(1.259,10.245) B4(-21.707,-9.515) B5(-21.684,-8.866) B11(-21.665,-5.322) B12(-21.665,-4.38) B14(-21.665,-3.438) B15(-21.665,-2.496) B17(-21.665,-1.554) B18(-21.665,-0.613) B20(-21.665,0.329) B33(-22.004,8.901) B34(-21.582,9.396) B35(-21.687,10.037) BA4(1.783,-9.365) BA5(1.848,-8.617) BA6(1.848,-7.967) BA7(1.848,-7.317) BA8(1.848,-6.668) BA10(1.848,-5.753) BA25(1.823,4.142) BA27(1.823,5.069) BA28(1.823,5.719) BA29(1.823,6.369) BA30(1.823,7.019) BA31(1.823,7.669) BA32(1.823,8.32) BA34(1.866,9.365) BB3(2.441,-10.334) BB4(2.441,-9.325) BB9(2.31,-6.21) BB24(2.278,3.679) BB26(2.278,4.606) BB33(2.517,9.04) BB34(2.517,9.69) BC4(3.098,-9.365) BC5(2.771,-8.617) BC6(2.771,-7.967) BC7(2.771,-7.317) BC8(2.771,-6.668) BC9(3.233,-6.21) BC10(2.771,-5.753) BC24(3.19,3.679) BC25(2.734,4.142) BC26(3.19,4.606) BC27(2.734,5.069) BC28(2.734,5.719) BC29(2.734,6.369) BC30(2.734,7.019) BC31(2.734,7.669) BC32(2.734,8.32) BC34(3.168,9.365) BD4(3.661,-9.69) BD5(3.695,-8.617) BD6(3.695,-7.967) BD7(3.695,-7.317) BD8(3.695,-6.668) BD10(3.695,-5.753) BD25(3.646,4.142) BD27(3.646,5.069) BD28(3.646,5.719) BD29(3.646,6.369) BD30(3.646,7.019) BD31(3.646,7.669) BD32(3.646,8.32) BD33(3.775,9.04) BD35(3.775,10.245) BE4(4.224,-9.365) BE5(4.619,-8.617) BE6(4.619,-7.967) BE7(4.619,-7.317) BE8(4.619,-6.668) BE9(4.157,-6.21) BE10(4.619,-5.753) BE24(4.101,3.679) BE25(4.557,4.142) BE26(4.101,4.606) BE27(4.557,5.069) BE28(4.557,5.719) BE29(4.557,6.369) BE30(4.557,7.019) BE31(4.557,7.669) BE32(4.557,8.32) BE34(4.383,9.365) BF3(4.882,-10.334) BF4(4.882,-9.325) BF9(5.081,-6.21) BF24(5.013,3.679) BF26(5.013,4.606) BF33(5.034,9.04) BF34(5.034,9.69) BG4(5.539,-9.365) BG5(5.543,-8.617) BG6(5.543,-7.967) BG7(5.543,-7.317) BG8(5.543,-6.668) BG10(5.543,-5.753) BG25(5.468,4.142) BG27(5.468,5.069) BG28(5.468,5.719) BG29(5.468,6.369) BG30(5.468,7.019) BG31(5.468,7.669) BG32(5.468,8.32) BG34(5.685,9.365) BH4(6.102,-9.69) BH9(6.005,-6.21) BH24(5.924,3.679) BH25(6.38,4.142) BH26(5.924,4.606) BH27(6.38,5.069) BH28(6.38,5.719) BH29(6.38,6.369) BH30(6.38,7.019) BH31(6.38,7.669) BH32(6.38,8.32) BH33(6.293,9.04) BH35(6.293,10.245) BJ4(6.665,-9.365) BJ5(6.467,-8.617) BJ6(6.467,-7.967) BJ7(6.467,-7.317) BJ8(6.467,-6.668) BJ9(6.929,-6.21) BJ10(6.467,-5.753) BJ24(6.835,3.679) BJ26(6.835,4.606) BJ34(6.9,9.365) BK3(7.322,-10.334) BK4(7.322,-9.325) BK5(7.39,-8.617) BK6(7.39,-7.967) BK7(7.39,-7.317) BK8(7.39,-6.668) BK10(7.39,-5.753) BK25(7.291,4.142) BK27(7.291,5.069) BK28(7.291,5.719) BK29(7.291,6.369) BK30(7.291,7.019) BK31(7.291,7.669) BK32(7.291,8.32) BK33(7.551,9.04) BK34(7.551,9.69) BL4(7.98,-9.365) BL5(8.314,-8.617) BL6(8.314,-7.967) BL7(8.314,-7.317) BL8(8.314,-6.668) BL9(7.852,-6.21) BL10(8.314,-5.753) BL24(7.747,3.679) BL25(8.203,4.142) BL26(7.747,4.606) BL27(8.203,5.069) BL28(8.203,5.719) BL29(8.203,6.369) BL30(8.203,7.019) BL31(8.203,7.669) BL32(8.203,8.32) BL34(8.202,9.365) BM4(8.543,-9.69) BM9(8.776,-6.21) BM24(8.658,3.679) BM26(8.658,4.606) BM33(8.809,9.04) BM35(8.809,10.245) BN4(9.106,-9.365) BN5(9.238,-8.617) BN6(9.238,-7.967) BN7(9.238,-7.317) BN8(9.238,-6.668) BN10(9.238,-5.753) BN25(9.114,4.142) BN27(9.114,5.069) BN28(9.114,5.719) BN29(9.114,6.369) BN30(9.114,7.019) BN31(9.114,7.669) BN32(9.114,8.32) BN34(9.417,9.365) BP3(9.763,-10.334) BP4(9.763,-9.325) BP5(10.162,-8.617) BP6(10.162,-7.967) BP7(10.162,-7.317) BP8(10.162,-6.668) BP9(10.162,-6.018) BP11(9.786,-5.093) BP12(9.786,-4.253) BP14(9.786,-3.413) BP15(9.786,-2.574) BP16(9.786,-1.734) BP18(9.786,-0.894) BP19(9.786,-0.054) BP20(9.786,0.786) BP22(9.786,1.626) BP23(9.786,2.465) BP24(9.786,3.305) BP25(9.786,4.145) BP27(10.025,5.069) BP28(10.025,5.719) BP29(10.025,6.369) BP30(10.025,7.019) BP31(10.025,7.669) BP32(10.025,8.32) BP33(10.068,9.04) BP34(10.068,9.69) BR4(10.421,-9.365) BR11(10.436,-5.093) BR12(10.436,-4.253) BR14(10.436,-3.413) BR15(10.436,-2.574) BR16(10.436,-1.734) BR18(10.436,-0.894) BR19(10.436,-0.054) BR20(10.436,0.786) BR22(10.436,1.626) BR23(10.436,2.465) BR24(10.436,3.305) BR25(10.436,4.145) BR34(10.719,9.365) BT4(10.984,-9.69) BT5(11.086,-8.617) BT6(11.086,-7.967) BT7(11.086,-7.317) BT8(11.086,-6.668) BT9(11.086,-6.018) BT11(11.086,-5.093) BT12(11.086,-4.253) BT14(11.086,-3.413) BT15(11.086,-2.574) BT16(11.086,-1.734) BT18(11.086,-0.894) BT19(11.086,-0.054) BT20(11.086,0.786) BT22(11.086,1.626) BT23(11.086,2.465) BT24(11.086,3.305) BT25(11.086,4.145) BT27(10.937,5.069) BT28(10.937,5.719) BT29(10.937,6.369) BT30(10.937,7.019) BT31(10.937,7.669) BT32(10.937,8.32) BT33(11.327,9.04) BT35(11.327,10.245) BU4(11.547,-9.365) BU5(12.009,-8.617) BU6(12.009,-7.967) BU7(12.009,-7.317) BU8(12.009,-6.668) BU9(12.009,-6.018) BU11(11.736,-5.093) BU12(11.736,-4.253) BU14(11.736,-3.413) BU15(11.736,-2.574) BU16(11.736,-1.734) BU18(11.736,-0.894) BU19(11.736,-0.054) BU20(11.736,0.786) BU22(11.736,1.626) BU23(11.736,2.465) BU24(11.736,3.305) BU25(11.736,4.145) BU27(11.848,5.069) BU28(11.848,5.719) BU29(11.848,6.369) BU30(11.848,7.019) BU31(11.848,7.669) BU32(11.848,8.32) BU34(11.934,9.365) BV3(12.204,-10.334) BV4(12.204,-9.325) BV11(12.386,-5.093) BV12(12.386,-4.253) BV14(12.386,-3.413) BV15(12.386,-2.574) BV16(12.386,-1.734) BV18(12.386,-0.894) BV19(12.386,-0.054) BV20(12.386,0.786) BV22(12.386,1.626) BV23(12.386,2.465) BV24(12.386,3.305) BV25(12.386,4.145) BV27(12.76,5.069) BV28(12.76,5.719) BV29(12.76,6.369) BV30(12.76,7.019) BV31(12.76,7.669) BV32(12.76,8.32) BV33(12.585,9.04) BV34(12.585,9.69) BW4(12.861,-9.365) BW5(12.933,-8.617) BW6(12.933,-7.967) BW7(12.933,-7.317) BW8(12.933,-6.668) BW9(12.933,-6.018) BW11(13.036,-5.093) BW12(13.036,-4.253) BW14(13.036,-3.413) BW15(13.036,-2.574) BW16(13.036,-1.734) BW18(13.036,-0.894) BW19(13.036,-0.054) BW20(13.036,0.786) BW22(13.036,1.626) BW23(13.036,2.465) BW24(13.036,3.305) BW25(13.036,4.145) BW34(13.236,9.365) BY4(13.424,-9.69) BY5(13.857,-8.617) BY6(13.857,-7.967) BY7(13.857,-7.317) BY8(13.857,-6.668) BY9(13.857,-6.018) BY11(13.686,-5.093) BY12(13.686,-4.253) BY14(13.686,-3.413) BY15(13.686,-2.574) BY16(13.686,-1.734) BY18(13.686,-0.894) BY19(13.686,-0.054) BY20(13.686,0.786) BY22(13.686,1.626) BY23(13.686,2.465) BY24(13.686,3.305) BY25(13.686,4.145) BY27(13.671,5.069) BY28(13.671,5.719) BY29(13.671,6.369) BY30(13.671,7.019) BY31(13.671,7.669) BY32(13.671,8.32) BY33(13.844,9.04) BY35(13.844,10.245) C3(-21.059,-10.059) C4(-21.132,-9.213) C9(-21.245,-6.305) C11(-21.015,-5.322) C12(-21.015,-4.38) C14(-21.015,-3.438) C15(-21.015,-2.496) C17(-21.015,-1.554) C18(-21.015,-0.613) C20(-21.015,0.329) C21(-21.245,1.275) C25(-21.245,3.792) C29(-21.245,6.309) C33(-21.245,8.826) C34(-20.932,9.396) C35(-21.037,10.037) C36(-21.037,10.687) CA4(13.988,-9.365) CA11(14.336,-5.093) CA12(14.336,-4.253) CA14(14.336,-3.413) CA15(14.336,-2.574) CA16(14.336,-1.734) CA18(14.336,-0.894) CA19(14.336,-0.054) CA20(14.336,0.786) CA22(14.336,1.626) CA23(14.336,2.465) CA24(14.336,3.305) CA25(14.336,4.145) CA27(14.582,5.069) CA28(14.582,5.719) CA29(14.582,6.369) CA30(14.582,7.019) CA31(14.582,7.669) CA32(14.582,8.32) CA34(14.451,9.365) CB3(14.645,-10.334) CB4(14.645,-9.325) CB5(14.781,-8.617) CB6(14.781,-7.967) CB7(14.781,-7.317) CB8(14.781,-6.668) CB9(14.781,-6.018) CB11(14.985,-5.093) CB12(14.985,-4.253) CB14(14.985,-3.413) CB15(14.985,-2.574) CB16(14.985,-1.734) CB18(14.985,-0.894) CB19(14.985,-0.054) CB20(14.985,0.786) CB22(14.985,1.626) CB23(14.985,2.465) CB24(14.985,3.305) CB25(14.985,4.145) CB33(15.102,9.04) CB34(15.102,9.69) CC4(15.302,-9.365) CC5(15.705,-8.617) CC6(15.705,-7.967) CC7(15.705,-7.317) CC8(15.705,-6.668) CC9(15.705,-6.018) CC11(15.635,-5.093) CC12(15.635,-4.253) CC14(15.635,-3.413) CC15(15.635,-2.574) CC16(15.635,-1.734) CC18(15.635,-0.894) CC19(15.635,-0.054) CC20(15.635,0.786) CC22(15.635,1.626) CC23(15.635,2.465) CC24(15.635,3.305) CC25(15.635,4.145) CC27(15.494,5.069) CC28(15.494,5.719) CC29(15.494,6.369) CC30(15.494,7.019) CC31(15.494,7.669) CC32(15.494,8.32) CC34(15.753,9.365) CD4(15.865,-9.69) CD11(16.285,-5.093) CD12(16.285,-4.253) CD14(16.285,-3.413) CD15(16.285,-2.574) CD16(16.285,-1.734) CD18(16.285,-0.894) CD19(16.285,-0.054) CD20(16.285,0.786) CD22(16.285,1.626) CD23(16.285,2.465) CD24(16.285,3.305) CD25(16.285,4.145) CE4(16.428,-9.365) CE5(16.628,-8.617) CE6(16.628,-7.967) CE7(16.628,-7.317) CE8(16.628,-6.668) CE9(16.628,-6.018) CE27(16.405,5.069) CE28(16.405,5.719) CE29(16.405,6.369) CE30(16.405,7.019) CE31(16.405,7.669) CE32(16.405,8.32) CE33(16.36,9.04) CE35(16.36,10.245) CF3(17.086,-10.334) CF4(17.086,-9.325) CF11(17.115,-5.37) CF12(17.115,-4.368) CF14(17.115,-3.33) CF15(17.115,-2.292) CF17(17.115,-1.254) CF19(17.115,-0.216) CF20(17.115,0.822) CF22(17.115,1.86) CF23(17.115,2.898) CF25(17.115,3.936) CF27(17.317,5.069) CF28(17.317,5.719) CF29(17.317,6.369) CF30(17.317,7.019) CF31(17.317,7.669) CF32(17.317,8.32) CF34(16.968,9.365) CG4(17.743,-9.365) CG5(17.552,-8.617) CG6(17.552,-7.967) CG7(17.552,-7.317) CG8(17.552,-6.668) CG9(17.552,-6.018) CG11(17.765,-5.37) CG12(17.765,-4.368) CG14(17.765,-3.33) CG15(17.765,-2.292) CG17(17.765,-1.254) CG19(17.765,-0.216) CG20(17.765,0.822) CG22(17.765,1.86) CG23(17.765,2.898) CG25(17.765,3.936) CG33(17.619,9.04) CG34(17.619,9.69) CH4(18.306,-9.69) CH5(18.476,-8.617) CH6(18.476,-7.967) CH7(18.476,-7.317) CH8(18.476,-6.668) CH9(18.476,-6.018) CH11(18.415,-5.37) CH12(18.415,-4.368) CH14(18.415,-3.33) CH15(18.415,-2.292) CH17(18.415,-1.254) CH19(18.415,-0.216) CH20(18.415,0.822) CH22(18.415,1.86) CH23(18.415,2.898) CH25(18.415,3.936) CH27(18.228,5.069) CH28(18.228,5.719) CH29(18.228,6.369) CH30(18.228,7.019) CH31(18.228,7.669) CH32(18.228,8.32) CH34(18.27,9.365) CJ4(18.869,-9.365) CJ11(19.065,-5.37) CJ12(19.065,-4.368) CJ14(19.065,-3.33) CJ15(19.065,-2.292) CJ17(19.065,-1.254) CJ19(19.065,-0.216) CJ20(19.065,0.822) CJ22(19.065,1.86) CJ23(19.065,2.898) CJ25(19.065,3.936) CJ27(19.139,5.069) CJ28(19.139,5.719) CJ29(19.139,6.369) CJ30(19.139,7.019) CJ31(19.139,7.669) CJ32(19.139,8.32) CJ33(18.833,9.04) CJ35(18.878,10.245) CK1(19.561,-11.315) CK3(19.83,-9.895) CK4(19.518,-9.325) CK5(19.4,-8.617) CK6(19.4,-7.967) CK7(19.4,-7.317) CK8(19.4,-6.668) CK9(19.4,-6.018) CK11(19.715,-5.37) CK12(19.715,-4.368) CK14(19.715,-3.33) CK15(19.715,-2.292) CK17(19.715,-1.254) CK19(19.715,-0.216) CK20(19.715,0.822) CK22(19.715,1.86) CK23(19.715,2.898) CK25(19.715,3.936) CK33(19.504,9.15) CK34(19.326,9.775) CK36(19.462,10.612) CK37(19.374,11.315) CL2(20.058,-10.896) CL35(19.91,10.061) CL36(20.019,10.948) CM1(20.555,-11.315) CM3(20.383,-10.333) CM4(20.343,-9.496) CM5(20.365,-8.782) CM6(20.371,-8.132) CM7(20.69,-7.565) CM8(20.371,-6.999) CM9(20.365,-6.305) CM10(20.371,-5.61) CM11(20.69,-5.044) CM12(20.371,-4.478) CM13(20.365,-3.783) CM14(20.371,-3.088) CM15(20.69,-2.522) CM16(20.371,-1.956) CM17(20.365,-1.261) CM18(20.371,-0.566) CM19(20.69,0) CM20(20.371,0.566) CM21(20.365,1.261) CM22(20.371,1.956) CM23(20.69,2.522) CM24(20.371,3.088) CM25(20.365,3.783) CM26(20.371,4.478) CM27(20.69,5.044) CM28(20.371,5.61) CM29(20.365,6.305) CM30(20.365,6.955) CM31(20.814,7.531) CM32(20.365,8.176) CM33(20.365,8.826) CM34(20.286,9.471) CM35(20.433,10.447) CM37(20.555,11.315) CN2(20.88,-10.752) CN3(20.946,-10.007) CN4(20.978,-9.358) CN5(21.367,-8.794) CN9(21.245,-6.305) CN13(21.245,-3.783) CN17(21.245,-1.261) CN21(21.245,1.261) CN25(21.245,3.783) CN29(21.245,6.305) CN33(21.245,8.826) CN34(20.932,9.396) CN35(21.037,10.037) CN36(21.037,10.687) CP3(21.687,-10.037) CP4(21.627,-9.39) CP5(22.099,-8.942) CP33(21.968,8.871) CP34(21.582,9.396) CP35(21.687,10.037) CR4(22.315,-9.555) CR6(22.315,-8.232) CR32(22.315,8.321) CR34(22.315,9.555) D2(-20.579,-10.64) D4(-20.605,-9.594) D5(-20.365,-8.782) D6(-20.371,-8.132) D7(-20.69,-7.565) D8(-20.371,-6.999) D9(-20.505,-6.305) D11(-20.365,-5.322) D12(-20.365,-4.38) D14(-20.365,-3.438) D15(-20.365,-2.496) D17(-20.365,-1.554) D18(-20.365,-0.613) D20(-20.365,0.329) D21(-20.595,1.275) D22(-20.365,1.883) D23(-20.69,2.534) D24(-20.365,3.184) D25(-20.595,3.792) D26(-20.365,4.4) D27(-20.69,5.051) D28(-20.365,5.701) D30(-20.365,6.917) D31(-20.69,7.568) D32(-20.365,8.218) D34(-20.282,9.396) D35(-20.433,10.447) D37(-20.555,11.315) E1(-20.096,-11.315) E3(-20.089,-10.008) E4(-19.995,-9.365) E9(-19.862,-6.21) E23(-20.04,2.621) E27(-20.04,5.051) E29(-20.04,6.309) E31(-20.04,7.568) E33(-20.04,8.781) E35(-19.91,10.061) E36(-20.019,10.948) F2(-19.527,-11.001) F3(-19.527,-10.334) F4(-19.432,-9.69) F5(-19.4,-8.617) F6(-19.4,-7.967) F7(-19.4,-7.317) F8(-19.4,-6.668) F11(-19.715,-5.322) F12(-19.715,-4.38) F14(-19.715,-3.438) F15(-19.715,-2.496) F17(-19.715,-1.554) F18(-19.715,-0.613) F20(-19.715,0.329) F21(-19.715,1.149) F22(-19.715,2.058) F24(-19.715,3.184) F25(-19.715,4.093) F33(-19.504,9.15) F34(-19.326,9.775) F36(-19.462,10.612) F37(-19.374,11.315) G1(-18.844,-11.315) G4(-18.869,-9.365) G9(-18.938,-6.21) G11(-19.065,-5.322) G12(-19.065,-4.38) G14(-19.065,-3.438) G15(-19.065,-2.496) G17(-19.065,-1.554) G18(-19.065,-0.613) G20(-19.065,0.329) G21(-19.065,1.149) G22(-19.065,2.058) G24(-19.065,3.184) G25(-19.065,4.093) G27(-19.139,5.069) G28(-19.139,5.719) G29(-19.139,6.369) G30(-19.139,7.019) G31(-19.139,7.669) G32(-19.139,8.32) G33(-18.833,9.04) G35(-18.878,10.245) H4(-18.306,-9.69) H5(-18.476,-8.617) H6(-18.476,-7.967) H7(-18.476,-7.317) H8(-18.476,-6.668) H9(-18.014,-6.21) H11(-18.415,-5.322) H12(-18.415,-4.38) H14(-18.415,-3.438) H15(-18.415,-2.496) H17(-18.415,-1.554) H18(-18.415,-0.613) H20(-18.415,0.329) H21(-18.415,1.149) H22(-18.415,2.058) H24(-18.415,3.184) H25(-18.415,4.093) H27(-18.228,5.069) H28(-18.228,5.719) H29(-18.228,6.369) H30(-18.228,7.019) H31(-18.228,7.669) H32(-18.228,8.32) H34(-18.27,9.365) J4(-17.743,-9.365) J5(-17.552,-8.617) J6(-17.552,-7.967) J7(-17.552,-7.317) J8(-17.552,-6.668) J11(-17.765,-5.322) J12(-17.765,-4.38) J14(-17.765,-3.438) J15(-17.765,-2.496) J17(-17.765,-1.554) J18(-17.765,-0.613) J20(-17.765,0.329) J21(-17.765,1.149) J22(-17.765,2.058) J24(-17.765,3.184) J25(-17.765,4.093) J33(-17.619,9.04) J34(-17.619,9.69) K3(-17.086,-10.334) K4(-17.086,-9.325) K9(-17.09,-6.21) K11(-17.115,-5.322) K12(-17.115,-4.38) K14(-17.115,-3.438) K15(-17.115,-2.496) K17(-17.115,-1.554) K18(-17.115,-0.613) K20(-17.115,0.329) K21(-17.115,1.149) K22(-17.115,2.058) K24(-17.115,3.184) K25(-17.115,4.093) K27(-17.317,5.069) K28(-17.317,5.719) K29(-17.317,6.369) K30(-17.317,7.019) K31(-17.317,7.669) K32(-17.317,8.32) K34(-16.968,9.365) L4(-16.428,-9.365) L5(-16.628,-8.617) L6(-16.628,-7.967) L7(-16.628,-7.317) L8(-16.628,-6.668) L10(-16.628,-5.753) L25(-16.405,4.142) L27(-16.405,5.069) L28(-16.405,5.719) L29(-16.405,6.369) L30(-16.405,7.019) L31(-16.405,7.669) L32(-16.405,8.32) L33(-16.36,9.04) L35(-16.36,10.245) M4(-15.865,-9.69) M9(-16.167,-6.21) M24(-15.949,3.679) M26(-15.949,4.606) N4(-15.302,-9.365) N5(-15.705,-8.617) N6(-15.705,-7.967) N7(-15.705,-7.317) N8(-15.705,-6.668) N9(-15.243,-6.21) N10(-15.705,-5.753) N25(-15.494,4.142) N27(-15.494,5.069) N28(-15.494,5.719) N29(-15.494,6.369) N30(-15.494,7.019) N31(-15.494,7.669) N32(-15.494,8.32) N34(-15.753,9.365) P3(-14.645,-10.334) P4(-14.645,-9.325) P5(-14.781,-8.617) P6(-14.781,-7.967) P7(-14.781,-7.317) P8(-14.781,-6.668) P10(-14.781,-5.753) P24(-15.038,3.679) P26(-15.038,4.606) P33(-15.102,9.04) P34(-15.102,9.69) R4(-13.988,-9.365) R9(-14.319,-6.21) R24(-14.127,3.679) R25(-14.582,4.142) R26(-14.127,4.606) R27(-14.582,5.069) R28(-14.582,5.719) R29(-14.582,6.369) R30(-14.582,7.019) R31(-14.582,7.669) R32(-14.582,8.32) R34(-14.451,9.365) T4(-13.424,-9.69) T5(-13.857,-8.617) T6(-13.857,-7.967) T7(-13.857,-7.317) T8(-13.857,-6.668) T9(-13.395,-6.21) T10(-13.857,-5.753) T25(-13.671,4.142) T27(-13.671,5.069) T28(-13.671,5.719) T29(-13.671,6.369) T30(-13.671,7.019) T31(-13.671,7.669) T32(-13.671,8.32) T33(-13.844,9.04) T35(-13.844,10.245) U4(-12.861,-9.365) U5(-12.933,-8.617) U6(-12.933,-7.967) U7(-12.933,-7.317) U8(-12.933,-6.668) U10(-12.933,-5.753) U24(-13.215,3.679) U26(-13.215,4.606) U34(-13.236,9.365) V3(-12.204,-10.334) V4(-12.204,-9.325) V9(-12.471,-6.21) V24(-12.304,3.679) V25(-12.76,4.142) V26(-12.304,4.606) V27(-12.76,5.069) V28(-12.76,5.719) V29(-12.76,6.369) V30(-12.76,7.019) V31(-12.76,7.669) V32(-12.76,8.32) V33(-12.585,9.04) V34(-12.585,9.69) W4(-11.547,-9.365) W5(-12.009,-8.617) W6(-12.009,-7.967) W7(-12.009,-7.317) W8(-12.009,-6.668) W9(-11.548,-6.21) W10(-12.009,-5.753) W25(-11.848,4.142) W27(-11.848,5.069) W28(-11.848,5.719) W29(-11.848,6.369) W30(-11.848,7.019) W31(-11.848,7.669) W32(-11.848,8.32) W34(-11.934,9.365) Y4(-10.984,-9.69) Y5(-11.086,-8.617) Y6(-11.086,-7.967) Y7(-11.086,-7.317) Y8(-11.086,-6.668) Y10(-11.086,-5.753) Y24(-11.392,3.679) Y25(-10.937,4.142) Y26(-11.392,4.606) Y27(-10.937,5.069) Y28(-10.937,5.719) Y29(-10.937,6.369) Y30(-10.937,7.019) Y31(-10.937,7.669) Y32(-10.937,8.32) Y33(-11.327,9.04) Y35(-11.327,10.245)
  oval 0.343x0.254 smd: A8(-22.315,-6.915) A22(-22.315,1.883) A24(-22.315,3.184) A26(-22.315,4.4) A28(-22.315,5.701) A30(-22.315,6.917) B6(-21.665,-8.216) B7(-21.99,-7.565) B8(-21.665,-6.915) B9(-21.895,-6.305) B21(-21.895,1.275) B22(-21.665,1.883) B23(-21.99,2.534) B24(-21.665,3.184) B25(-21.895,3.792) B26(-21.665,4.4) B27(-21.99,5.051) B28(-21.665,5.701) B29(-21.895,6.309) B30(-21.665,6.917) B31(-21.99,7.568) B32(-21.665,8.218) C6(-21.015,-8.216) C7(-21.34,-7.565) C8(-21.021,-6.999) C22(-21.015,1.883) C23(-21.34,2.534) C24(-21.015,3.184) C26(-21.015,4.4) C27(-21.34,5.051) C28(-21.015,5.701) C30(-21.015,6.917) C31(-21.34,7.568) C32(-21.015,8.218) CN6(21.015,-8.216) CN7(21.34,-7.565) CN8(21.021,-6.999) CN10(21.021,-5.61) CN11(21.34,-5.044) CN12(21.021,-4.478) CN14(21.021,-3.088) CN15(21.34,-2.522) CN16(21.021,-1.956) CN18(21.021,-0.566) CN19(21.34,0) CN20(21.021,0.566) CN22(21.021,1.956) CN23(21.34,2.522) CN24(21.021,3.088) CN26(21.021,4.478) CN27(21.34,5.044) CN28(21.021,5.61) CN30(21.014,6.912) CN31(21.461,7.605) CN32(21.014,8.219) CP6(21.665,-8.216) CP7(21.99,-7.565) CP8(21.665,-6.915) CP9(21.895,-6.305) CP10(21.665,-5.694) CP11(21.99,-5.044) CP12(21.665,-4.393) CP13(21.895,-3.783) CP14(21.665,-3.172) CP15(21.99,-2.522) CP16(21.665,-1.871) CP17(21.895,-1.261) CP18(21.665,-0.65) CP19(21.99,0) CP20(21.665,0.65) CP21(21.895,1.261) CP22(21.665,1.871) CP23(21.99,2.522) CP24(21.665,3.172) CP25(21.895,3.783) CP26(21.665,4.393) CP27(21.99,5.044) CP28(21.665,5.694) CP29(21.895,6.305) CP30(21.669,6.983) CP31(22.19,7.605) CP32(21.665,8.296) CR8(22.315,-6.915) CR10(22.315,-5.694) CR12(22.315,-4.393) CR14(22.315,-3.172) CR16(22.315,-1.871) CR18(22.315,-0.65) CR20(22.315,0.65) CR22(22.315,1.871) CR24(22.315,3.172) CR26(22.315,4.393) CR28(22.315,5.694) CR30(22.315,6.912)
  oval 0.254x0.343 smd: AA1(-10.421,-11.315) AA2(-10.421,-10.665) AA3(-10.421,-10.015) AA35(-10.719,10.015) AA36(-10.719,10.665) AA37(-10.719,11.315) AB2(-9.763,-10.99) AB35(-10.068,10.34) AB36(-10.068,10.99) AC1(-9.106,-11.315) AC2(-9.106,-10.665) AC3(-9.106,-10.015) AC35(-9.417,10.015) AC36(-9.417,10.665) AC37(-9.417,11.315) AD3(-8.543,-10.34) AD36(-8.809,10.895) AE1(-7.98,-11.315) AE2(-7.98,-10.665) AE3(-7.98,-10.015) AE35(-8.202,10.015) AE36(-8.202,10.665) AE37(-8.202,11.315) AF2(-7.322,-10.99) AF35(-7.551,10.34) AF36(-7.551,10.99) AG1(-6.665,-11.315) AG2(-6.665,-10.665) AG3(-6.665,-10.015) AG35(-6.9,10.015) AG36(-6.9,10.665) AG37(-6.9,11.315) AH3(-6.102,-10.34) AH36(-6.293,10.895) AJ1(-5.539,-11.315) AJ2(-5.539,-10.665) AJ3(-5.539,-10.015) AJ35(-5.685,10.015) AJ36(-5.685,10.665) AJ37(-5.685,11.315) AK2(-4.882,-10.99) AK35(-5.034,10.34) AK36(-5.034,10.99) AL1(-4.224,-11.315) AL2(-4.224,-10.665) AL3(-4.224,-10.015) AL35(-4.383,10.015) AL36(-4.383,10.665) AL37(-4.383,11.315) AM3(-3.661,-10.34) AM36(-3.775,10.895) AN1(-3.098,-11.315) AN2(-3.098,-10.665) AN3(-3.098,-10.015) AN35(-3.168,10.015) AN36(-3.168,10.665) AN37(-3.168,11.315) AP2(-2.441,-10.99) AP35(-2.517,10.34) AP36(-2.517,10.99) AR1(-1.783,-11.315) AR2(-1.783,-10.665) AR3(-1.783,-10.015) AR35(-1.866,10.015) AR36(-1.866,10.665) AR37(-1.866,11.315) AT3(-1.22,-10.34) AT36(-1.259,10.895) AU1(-0.657,-11.315) AU2(-0.657,-10.665) AU3(-0.657,-10.015) AU35(-0.65,10.015) AU36(-0.65,10.665) AU37(-0.65,11.315) AV2(0,-10.99) AV35(0,10.34) AV36(0,10.99) AW1(0.657,-11.315) AW2(0.657,-10.665) AW3(0.657,-10.015) AW35(0.65,10.015) AW36(0.65,10.665) AW37(0.65,11.315) AY3(1.22,-10.34) AY36(1.259,10.895) BA1(1.783,-11.315) BA2(1.783,-10.665) BA3(1.783,-10.015) BA35(1.866,10.015) BA36(1.866,10.665) BA37(1.866,11.315) BB2(2.441,-10.99) BB35(2.517,10.34) BB36(2.517,10.99) BC1(3.098,-11.315) BC2(3.098,-10.665) BC3(3.098,-10.015) BC35(3.168,10.015) BC36(3.168,10.665) BC37(3.168,11.315) BD3(3.661,-10.34) BD36(3.775,10.895) BE1(4.224,-11.315) BE2(4.224,-10.665) BE3(4.224,-10.015) BE35(4.383,10.015) BE36(4.383,10.665) BE37(4.383,11.315) BF2(4.882,-10.99) BF35(5.034,10.34) BF36(5.034,10.99) BG1(5.539,-11.315) BG2(5.539,-10.665) BG3(5.539,-10.015) BG35(5.685,10.015) BG36(5.685,10.665) BG37(5.685,11.315) BH3(6.102,-10.34) BH36(6.293,10.895) BJ1(6.665,-11.315) BJ2(6.665,-10.665) BJ3(6.665,-10.015) BJ35(6.9,10.015) BJ36(6.9,10.665) BJ37(6.9,11.315) BK2(7.322,-10.99) BK35(7.551,10.34) BK36(7.551,10.99) BL1(7.98,-11.315) BL2(7.98,-10.665) BL3(7.98,-10.015) BL35(8.202,10.015) BL36(8.202,10.665) BL37(8.202,11.315) BM3(8.543,-10.34) BM36(8.809,10.895) BN1(9.106,-11.315) BN2(9.106,-10.665) BN3(9.106,-10.015) BN35(9.417,10.015) BN36(9.417,10.665) BN37(9.417,11.315) BP2(9.763,-10.99) BP35(10.068,10.34) BP36(10.068,10.99) BR1(10.421,-11.315) BR2(10.421,-10.665) BR3(10.421,-10.015) BR35(10.719,10.015) BR36(10.719,10.665) BR37(10.719,11.315) BT3(10.984,-10.34) BT36(11.327,10.895) BU1(11.547,-11.315) BU2(11.547,-10.665) BU3(11.547,-10.015) BU35(11.934,10.015) BU36(11.934,10.665) BU37(11.934,11.315) BV2(12.204,-10.99) BV35(12.585,10.34) BV36(12.585,10.99) BW1(12.861,-11.315) BW2(12.861,-10.665) BW3(12.861,-10.015) BW35(13.236,10.015) BW36(13.236,10.665) BW37(13.236,11.315) BY3(13.424,-10.34) BY36(13.844,10.895) CA1(13.988,-11.315) CA2(13.988,-10.665) CA3(13.988,-10.015) CA35(14.451,10.015) CA36(14.451,10.665) CA37(14.451,11.315) CB2(14.645,-10.99) CB35(15.102,10.34) CB36(15.102,10.99) CC1(15.302,-11.315) CC2(15.302,-10.665) CC3(15.302,-10.015) CC35(15.753,10.015) CC36(15.753,10.665) CC37(15.753,11.315) CD3(15.865,-10.34) CE1(16.428,-11.315) CE2(16.428,-10.665) CE3(16.428,-10.015) CE36(16.36,10.895) CF2(17.086,-10.99) CF35(16.968,10.015) CF36(16.968,10.665) CF37(16.968,11.315) CG1(17.743,-11.315) CG2(17.743,-10.665) CG3(17.743,-10.015) CG35(17.619,10.34) CG36(17.619,10.99) CH3(18.306,-10.34) CH35(18.27,10.015) CH36(18.27,10.665) CH37(18.27,11.315) CJ1(18.869,-11.315) CJ2(18.869,-10.665) CJ3(18.869,-10.015) CJ36(18.878,10.895) CK2(19.555,-10.485) G2(-18.869,-10.665) G3(-18.869,-10.015) G36(-18.878,10.895) H3(-18.306,-10.34) H35(-18.27,10.015) H36(-18.27,10.665) H37(-18.27,11.315) J1(-17.743,-11.315) J2(-17.743,-10.665) J3(-17.743,-10.015) J35(-17.619,10.34) J36(-17.619,10.99) K2(-17.086,-10.99) K35(-16.968,10.015) K36(-16.968,10.665) K37(-16.968,11.315) L1(-16.428,-11.315) L2(-16.428,-10.665) L3(-16.428,-10.015) L36(-16.36,10.895) M3(-15.865,-10.34) N1(-15.302,-11.315) N2(-15.302,-10.665) N3(-15.302,-10.015) N35(-15.753,10.015) N36(-15.753,10.665) N37(-15.753,11.315) P2(-14.645,-10.99) P35(-15.102,10.34) P36(-15.102,10.99) R1(-13.988,-11.315) R2(-13.988,-10.665) R3(-13.988,-10.015) R35(-14.451,10.015) R36(-14.451,10.665) R37(-14.451,11.315) T3(-13.424,-10.34) T36(-13.844,10.895) U1(-12.861,-11.315) U2(-12.861,-10.665) U3(-12.861,-10.015) U35(-13.236,10.015) U36(-13.236,10.665) U37(-13.236,11.315) V2(-12.204,-10.99) V35(-12.585,10.34) V36(-12.585,10.99) W1(-11.547,-11.315) W2(-11.547,-10.665) W3(-11.547,-10.015) W35(-11.934,10.015) W36(-11.934,10.665) W37(-11.934,11.315) Y3(-10.984,-10.34) Y36(-11.327,10.895)
