# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_OVT#_EC: length 2.7
  BOTTOM w0.114: Q15.3 107.05,181.84 TP13169.1 107.5,182.15 107.34,182.31 107.34,182.69 107.4,182.76 R385.1
DGPU_PROCHOT_EC#: length 18.6
  IN4 w0.089: v2(125.17,185.27) 125.57,184.87 126.36,184.87 126.43,184.8 126.43,183.87 127.57,182.72 127.57,181.54 129.02,180.1 129.02,179.85 131.43,177.43 131.73,177.43 132.48,176.69 132.48,175.65 131.57,174.73 v1(130.49,174.73)
  BOTTOM w0.102: U8.D7 124.75,184.85 v2(125.17,185.27)
  BOTTOM w0.114: v1(130.49,174.73) 129.98,175.24 Q6512.1 129.55,175.35 R25322.1
DGPU_PSI: length 37.7
  TOP w0.254: v2(96.02,198.35) 96.2,198.53 PR9016.1
  IN4 w0.089: v2(96.02,198.35) 95.76,198.35 94.71,197.29 94.71,192.33 96.8,190.23 97.69,190.23 99.59,188.34 101.54,188.34 102.25,187.64 105,187.64 105.82,186.82 110.74,186.82 111.21,187.28 112.25,187.28 112.98,186.56 112.98,185.72 113.79,184.91 113.79,180.47 v1(114.46,179.79)
  BOTTOM w0.114: R391.1 114.08,179.98 114.26,179.79 v1(114.46,179.79) 115.01,180.34 R376.2
DGPU_PW_CTRL#: length 27.4
  TOP w0.114: v2(99.93,128.31) 99.93,127.95 100.08,127.8 100.08,126.94 99.75,126.61 98.93,126.61 97.64,125.31 94.46,125.31 93.87,124.72 92.95,124.72 92.19,123.96 91.06,123.96 90.57,123.47 90.17,123.47 89.14,122.45 88.4,122.45 87.74,121.79 85.31,121.79 85.25,121.73 82.73,121.73 82.59,121.59 82.23,121.59 v1(81.82,121.18) 81.1,121.18 R25375.2 80.51,120.59 79.73,120.59 R25377.2
  BOTTOM w0.089: v2(99.93,128.31) 100.22,128.6 101.58,128.6 U1.CB34
DGPU_PWR_EN: length 160.5
  TOP w0.079: v2(106.17,127.43) 106.7,126.9 106.7,126.68 107.51,125.87 107.51,124.58 107.33,124.41 107.33,123.24 106.4,122.31 106.4,122.09
  TOP w0.114: PR9070.2 87.85,183.16 87.13,183.88 v1(87.13,184.16) ; R25429.2 104.77,111.55 104.77,112.3 105.24,112.78 R25403.1 105.24,113.17 106.58,114.5 106.58,119.47 106.4,119.65 106.4,122.09
  IN1 w0.089: v1(121.87,205.87) 122.21,205.54 122.21,204.32 121.54,203.66 121.54,197.54 120.69,196.69 120.69,195.05 118.47,192.83 118.47,190.78 119.25,189.99 119.25,186.48 118.1,185.33 117.43,185.33 115.3,183.19 110.76,183.19 110.29,182.72 109.52,182.72 109.4,182.85 108.29,182.85 108.04,183.09 107.11,183.09 106.77,182.75 104.17,182.75 103.53,183.39 101.52,183.39 100.11,184.8 100.11,185.66 98.69,187.08 97.82,187.08 97.75,187.02 93.79,187.02 90.05,183.27 88.02,183.27 v1(87.13,184.16)
  IN3 w0.102: v2(106.17,127.43) 106.67,127.43 106.98,127.74 108.25,127.74 109.25,128.74 109.25,154.85 109.7,155.3 109.7,160.94 109.93,161.18 109.93,172.33 108.29,173.97 106.92,173.97 106.47,174.42 106.47,175.08 106.08,175.47 104.83,175.47 99.39,180.91 91.25,180.91 89.2,182.96 88.14,182.96 87.13,183.98 v1(87.13,184.16)
  BOTTOM w0.079: U1.CE27 106.48,127.12 v2(106.17,127.43)
  BOTTOM w0.114: R323.1 120.32,209.12 120.32,208.81 120.81,208.33 v1(120.93,208.33) 120.93,206.24 121.3,205.87 v1(121.87,205.87)
DGPU_PWROK: length 133.3
  TOP w0.079: v2(103,128.34) 102.33,128.34 101.42,127.43 101.42,127.07 100.74,126.39
  TOP w0.114: v1(77.74,119.81) 77.93,119.63 78.77,119.63 78.92,119.48 R25468.2 79.71,119.16 v1(79.81,119.25) 80.39,119.83 R25376.1 80.82,120.49 81.86,120.49 82.84,121.47 84.92,121.47 85.58,120.81 87.52,120.81 88.62,121.92 89.36,121.92 90.39,122.94 90.79,122.94 91.28,123.43 92.41,123.43 92.64,123.65 94.44,123.65 95.57,124.78 99.13,124.78 100.74,126.39
  IN4 w0.089: v1(109.33,184.65) 108.43,183.75 104.95,183.75 100.74,179.54 96.32,179.54 92.56,175.79 82.68,175.79 82.27,176.19 74.66,176.19 v1(73.56,177.29)
  BOTTOM w0.079: U1.CA31 103.38,128.34 v2(103,128.34)
  BOTTOM w0.114: v1(73.56,177.29) 73.56,177.22 74.22,176.56 74.51,176.56 77.74,173.33 v1(77.74,119.81) ; v1(109.33,184.65) 109.33,185.02 109.97,185.65 Q9.2
DISP_ON: length 3.5
  TOP w0.114: U19.3 76.73,195.92 v1(76.97,195.68) 77.59,195.05 R445.1 77.59,193.9 R446.2
DMIC_CLK: length 2.9
  BOTTOM w0.102: 23.88,33.81 v1(23.9,33.83)
  BOTTOM w0.114: U20.3 23.88,33.81 ; R461.2 24.96,34 24.79,33.83 v1(23.9,33.83)
DMIC_CLK_L: length 226.9
  IN3 w0.102: v1(27.52,35.55) 28.98,37.01 28.98,38.51 26.59,40.9 26.59,45.47 25.34,46.72 25.34,50.29 25.96,50.91 25.96,53.24 25.51,53.69 18.63,53.69 16.6,55.72 15.1,55.72 13.36,57.46 13.36,61.84 14.58,63.06 14.58,64.58 15.67,65.67 15.67,69.03 14.33,70.37 14.33,71.46 14.09,71.7 12.93,71.7 12.32,72.3 11.61,72.3 10.94,72.97 10.94,75.42 16.16,80.65 16.16,86.6 16.95,87.39 16.95,88.01 17.28,88.34 17.28,92.27 16.19,93.36 16.19,101.7 15.96,101.92 15.96,107.98 17.53,109.55 17.53,112.6 16.5,113.63 16.5,116.55 14.83,118.23 14.83,129.66 15.43,130.26 15.43,133.06 18.15,135.78 18.15,141.85 13.68,146.31 11.69,146.31 10.3,147.7 10.3,159.78 9.45,160.63 9.45,162.02 9.79,162.36 9.79,165.83 15.02,171.07 15.02,174.73 17.88,177.59 23.45,177.59 25.92,175.12 35.93,175.12 36.24,175.43 36.24,178.08 37.29,179.13 39.98,179.13 41.73,180.88 41.73,189.75 42.17,190.19 42.38,190.19 v1(42.52,190.34)
  BOTTOM w0.114: v1(27.52,35.55) 27.81,35.84 C583.2 28.24,35.56 27.69,35.01 27.69,34.67 27.03,34 R461.1 ; L12.2 51.13,190.46 50.71,190.03 v1(47.54,190.03) 46.78,189.28 45.61,189.28 44.98,188.65 43.97,188.65 42.8,189.82 42.8,190.06 v1(42.52,190.34)
DMIC_CLK_L_C: length 7
  BOTTOM w0.114: L12.1 51.13,192.78 v1(51.18,192.83) 51.44,193.09 53.24,193.09 53.61,192.72 C548.1 55.15,192.53 55.36,192.31 55.97,192.31 56.15,192.49 CN29.1
DMIC_DAT: length 7.6
  BOTTOM w0.102: 25.12,34.43 24.88,34.43 24.71,34.26 23.55,34.26 23.5,34.21 U20.2
  BOTTOM w0.114: 25.12,34.43 26.64,34.43 v1(27.18,34.97) 27.18,35.12 26.97,35.33 26.97,35.77 28.18,36.97 R459.1
DMIC_DAT_L: length 222
  IN3 w0.102: v1(29.44,37.74) 29.44,38.63 27,41.07 27,45.64 25.75,46.89 25.75,50.12 26.37,50.74 26.37,53.4 25.67,54.1 18.8,54.1 16.77,56.13 15.27,56.13 13.77,57.63 13.77,61.67 14.99,62.89 14.99,64.41 16.08,65.5 16.08,69.2 14.73,70.54 14.73,71.63 14.26,72.1 13.1,72.1 12.49,72.71 11.78,72.71 11.35,73.14 11.35,75.26 16.64,80.55 16.64,86.5 17.36,87.22 17.36,87.85 17.69,88.17 17.69,92.44 16.59,93.53 16.59,101.89 16.37,102.11 16.37,107.81 17.94,109.38 17.94,112.77 16.91,113.79 16.91,116.72 15.23,118.4 15.23,129.48 15.84,130.08 15.84,132.89 18.56,135.61 18.56,142.01 13.85,146.72 11.86,146.72 10.71,147.87 10.71,159.94 9.86,160.79 9.86,161.85 10.19,162.19 10.19,165.66 15.43,170.9 15.43,174.56 18.05,177.19 23.28,177.19 25.75,174.72 36.1,174.72 36.65,175.26 36.65,177.91 37.45,178.72 40.15,178.72 42.14,180.71 42.14,189.49 v1(42.34,189.69)
  BOTTOM w0.114: R459.2 29.44,37.27 v1(29.44,37.74) ; L13.2 53.33,189.81 v1(51.57,189.81) 51.37,189.61 47.74,189.61 46.98,188.86 45.79,188.86 45.16,188.23 43.79,188.23 v1(42.34,189.69)
DMIC_DAT_L_C: length 5.8
  BOTTOM w0.114: CN29.2 56.65,192.41 56.29,192.05 54.71,192.05 v1(54.66,192) 53.72,192 C547.1 L13.1
DNBSWON#: length 75.7
  TOP w0.114: v1(157.24,105.98) 156.15,107.06 156.15,108.92 154.96,110.11 U37.123
  IN4 w0.089: v2(105.51,131.17) 105.94,131.6 106.72,131.6 107.58,130.74 107.96,130.74 108.33,130.37 108.33,128.44 108.74,128.03 108.74,127.68 109.5,126.92 109.83,126.92 110.59,126.16 110.59,125.62 110.87,125.34 111.69,125.34 112.42,124.61 112.42,123.69 113.08,123.04 113.7,123.04 114.05,122.68 116.82,122.68 116.87,122.74 119.63,122.74 120.63,121.73 120.97,121.73 123.12,119.58 123.41,119.58 124.39,118.6 124.39,118.15 125.36,117.18 125.36,116.56 125.57,116.36 125.57,115.75 126.36,114.95 126.89,114.95 127.62,114.23 127.62,113.43 127.46,113.28 127.46,112.11 128.27,111.31 129.13,111.31 131.01,109.43 131.01,108.57 131.62,107.95 132.49,107.95 134.75,105.69 136.73,105.69 137.27,105.15 138.11,105.15 138.66,104.59 140.19,104.59 140.48,104.89 147.81,104.89 148.07,104.63 148.77,104.63 149.15,105.01 151.99,105.01 152.02,105.05 154.99,105.05 155.92,105.98 v1(157.24,105.98)
  BOTTOM w0.079: U1.BU28 105.51,131.25 v2(105.51,131.17)
DP_AUXN: length 32.9
  TOP w0.102: C20014.1 35.85,150.97 36.36,150.97 v1(36.51,151.12) ; U30.54 28.81,127.81 28.89,127.89 29.71,127.89 29.86,127.74 30.32,127.74 R25525.2 31.27,127.75 32.62,127.75 v1(32.9,127.48)
  IN1 w0.102: v1(32.9,127.48) 33.18,127.75 33.4,127.75 33.71,128.06 33.71,132.33 33.97,132.58 33.97,134.12 33.71,134.38 33.71,142.34 33.3,142.76 33.3,145.12 37.25,149.08 37.25,150.66 37.01,150.9 36.72,150.9 v1(36.51,151.12)
DP_AUXP: length 32.9
  TOP w0.102: U30.55 28.76,128.21 28.87,128.1 29.79,128.1 29.95,127.94 30.31,127.94 R770.2 31.24,127.96 32.62,127.96 v1(32.9,128.24) ; v1(36.51,150.35) 36.51,150.45 36.19,150.77 35.74,150.77 35.58,150.6 C20015.1
  IN1 w0.102: v1(36.51,150.35) 36.51,150.54 36.66,150.7 36.92,150.7 37.04,150.58 37.04,149.16 33.09,145.21 33.09,142.68 33.51,142.26 33.51,134.29 33.76,134.04 33.76,132.67 33.51,132.41 33.51,128.15 33.32,127.96 33.18,127.96 v1(32.9,128.24)
DP_CA_DET: length 2.9
  TOP w0.114: U30.42 27.42,122.09 v1(28.22,121.28) 29.05,120.45 R773.1
DP_CFG0: length 9.7
  TOP w0.114: v1(32.46,117.14) 32.03,117.57 32.03,118.26 32.5,118.73 R843.1 32.06,118.74 R845.2 30.98,119.83 30.28,119.83 28.96,121.14 28.96,123.56 28.72,123.81 U30.44
DP_CFG1: length 3.2
  TOP w0.114: U30.29 22.22,122.08 22.07,121.93 22.07,121.35 22.56,120.86 R844.2 R842.1
DP_D0N: length 76.9
  TOP w0.102: C20017.1 35.85,154.01 36.3,154.01 v1(36.45,154.16) ; v1(26.78,120.72) 26.52,120.98 26.3,120.98 26.05,121.22 26.05,121.82 26.22,121.99 U30.39
  IN1 w0.102: v1(36.45,154.16) 36.45,153.94 36.63,153.76 42.29,153.76 42.51,153.54 42.51,152.86 42.26,152.61 37.35,152.61 37.17,152.43 37.17,151.94 37.31,151.8 42.28,151.8 42.5,151.58 42.5,151.09 42.24,150.83 38.07,150.83 37.98,150.73 37.98,150.27 38.08,150.18 42.25,150.18 42.47,149.96 42.47,149.25 42.23,149.01 38.07,149.01 37.88,148.82 37.88,148.49 38.05,148.33 40.07,148.33 40.27,148.13 40.27,147.61 40.02,147.37 37.51,147.37 37.14,147.73 36.79,147.73 34.96,145.9 34.96,143.48 34.52,143.04 34.52,138.65 34.92,138.26 34.92,131.29 34.39,130.76 34.39,127.65 32.88,126.14 32.88,125.74 29.15,122.01 28.31,122.01 27.23,120.93 26.99,120.93 v1(26.78,120.72)
DP_D0P: length 76.9
  TOP w0.102: v1(36.45,153.4) 36.45,153.49 36.13,153.81 35.54,153.81 35.39,153.66 35.39,153.46 C20016.1 ; v1(26.78,121.48) 26.78,121.25 26.71,121.18 26.38,121.18 26.26,121.31 26.26,121.74 26.62,122.1 U30.40
  IN1 w0.102: v1(36.45,153.4) 36.61,153.55 42.2,153.55 42.31,153.45 42.31,152.94 42.18,152.81 37.26,152.81 36.97,152.52 36.97,151.86 37.23,151.6 42.2,151.6 42.3,151.5 42.3,151.18 42.15,151.03 37.99,151.03 37.78,150.82 37.78,150.19 37.99,149.97 42.16,149.97 42.26,149.87 42.26,149.34 42.14,149.22 37.99,149.22 37.68,148.91 37.68,148.41 37.96,148.12 39.98,148.12 40.07,148.04 40.07,147.7 39.94,147.57 37.59,147.57 37.23,147.94 36.71,147.94 34.76,145.99 34.76,143.57 34.32,143.13 34.32,138.57 34.72,138.17 34.72,131.38 34.19,130.84 34.19,127.73 32.67,126.22 32.67,125.82 29.07,122.22 28.23,122.22 27.14,121.14 26.84,121.14 26.78,121.19 v1(26.78,121.48)
DP_D1N: length 77.4
  TOP w0.102: v1(36.34,156.19) 36.19,156.03 35.49,156.03 C20019.1 ; U30.36 25.02,121.99 24.79,121.76 24.79,120.65 25.05,120.39 25.26,120.39 v1(25.54,120.11)
  IN1 w0.102: v1(36.34,156.19) 36.52,156.01 42.24,156.01 42.5,155.75 42.5,154.82 42.28,154.6 36.11,154.6 35.92,154.41 35.92,150.14 33,147.22 33,146.24 32.56,145.79 32.56,130.85 32.07,130.36 32.07,129.13 31.85,128.91 31.85,127.75 31.48,127.39 28.03,127.39 27.93,127.29 27.93,126.95 28.04,126.84 31.81,126.84 32.1,126.56 32.1,126.04 31.88,125.81 27.9,125.81 27.78,125.69 27.78,125.38 27.88,125.28 29.52,125.28 29.79,125.01 29.79,124.55 29.57,124.33 27.47,124.33 27.33,124.19 27.33,123.96 27.44,123.85 28.12,123.85 28.33,123.64 28.33,123.24 28.07,122.98 24.13,122.98 24.01,122.86 24.01,122.52 24.14,122.39 26.05,122.39 26.31,122.12 26.31,120.64 26.06,120.39 25.82,120.39 v1(25.54,120.11)
DP_D1P: length 77.4
  TOP w0.102: v1(25.54,120.87) 25.26,120.59 25.14,120.59 25,120.73 25,121.68 25.22,121.9 25.42,122.1 U30.37 ; C20018.1 35.07,155.43 35.07,155.69 35.21,155.83 36.05,155.83 36.34,155.54 v1(36.34,155.43)
  IN1 w0.102: v1(36.34,155.43) 36.34,155.6 36.54,155.8 42.16,155.8 42.3,155.67 42.3,154.9 42.19,154.8 36.02,154.8 35.72,154.5 35.72,150.22 32.8,147.31 32.8,146.32 32.35,145.88 32.35,130.93 31.86,130.44 31.86,129.21 31.64,128.99 31.64,127.83 31.4,127.59 27.95,127.59 27.73,127.37 27.73,126.86 27.95,126.64 31.73,126.64 31.9,126.47 31.9,126.12 31.79,126.02 27.82,126.02 27.58,125.78 27.58,125.3 27.8,125.08 29.43,125.08 29.59,124.93 29.59,124.63 29.48,124.53 27.39,124.53 27.13,124.27 27.13,123.88 27.36,123.65 28.04,123.65 28.13,123.56 28.13,123.32 27.99,123.18 24.04,123.18 23.81,122.95 23.81,122.44 24.06,122.19 25.96,122.19 26.11,122.04 26.11,120.73 25.97,120.59 25.82,120.59 v1(25.54,120.87)
DP_HPD: length 33.6
  TOP w0.114: v1(31.63,144.58) 31.64,144.57 v1(32.34,144.57) 32.36,144.6 34.38,144.6 35.5,145.72 R61.1 ; v1(23.2,121.61) 23.42,121.84 U30.32
  IN1 w0.089: v1(31.63,144.58) 31.63,134.33 26.97,129.66 26.97,124.97 25.88,123.88 23.75,123.88 23.2,123.32 v1(23.2,121.61)
DP_HPD_R: length 7.1
  TOP w0.114: U67.32 31.68,149.89 31.97,149.6 v1(32.46,149.6) 32.97,149.6 33.96,148.61 33.96,147.54 34.47,147.03 R25534.1 34.61,146.46 35.18,147.03 R61.2
DRAM_RESET#: length 29.4
  TOP w0.079: v2(103.53,131.21) 103.21,130.89 102.16,130.89 101.23,131.82 100.74,131.82
  TOP w0.114: R26.1 77.81,129.66 R27.2 79.09,129.66 80,128.75 84.38,128.75 84.82,128.3 87.19,128.3 v1(87.75,128.87) 91.21,128.87 91.61,129.28 92.84,129.28 93.19,129.63 94.92,129.63 97.86,132.57 99.87,132.57 100.62,131.82 100.74,131.82
  BOTTOM w0.079: U1.BU31 103.88,131.56 v2(103.53,131.21)
DRVEN_SET: length 3.6
  TOP w0.508: PR7103.1 160.77,143.49 PR7104.2 160.56,142.56 160.33,142.79 v1(160.08,142.79)
  BOTTOM w0.114: v1(159.74,143.41) 159.74,143.12 v1(160.08,142.79)
  BOTTOM w0.203: v1(160.08,142.79) 160.26,142.61 PU7000.18
DSWROK_EC: length 2
  TOP w0.114: R41.2 77.11,126.46 TP9026.1 77.24,126.59 R51.2
DSWROK_EC_R: length 32.2
  TOP w0.079: 100.74,130.96 101.5,130.96 101.86,130.6 103.34,130.6 103.41,130.67 104.9,130.67 105.15,130.92 105.15,131.52 104.83,131.84 v2(104.83,131.98)
  TOP w0.114: R51.1 79,126.55 R47.1 80.74,126.55 R46.1 81.76,126.54 83.7,126.54 C8.1 84.86,126.72 86.87,126.72 v1(87.23,126.36) 87.25,126.39 90.99,126.39 92.21,127.61 93.35,127.61 93.8,128.07 95.46,128.07 98.24,130.85 98.7,130.85 98.81,130.96 100.74,130.96
  BOTTOM w0.089: U1.BP30 104.89,133.03 104.89,132.05 v2(104.83,131.98)
DWL_REQ: length 69.1
  TOP w0.114: v1(69.47,93.04) 69.47,93.53 69.75,93.81 R67567.1 69.52,94.06 69.25,93.79 R67569.1 68.64,93.79 68.56,93.71 R67556.2 68.27,94 68.13,94.13 Q6558.3
  IN4 w0.089: v1(69.47,93.04) 69.7,92.81 73.8,92.81 75.86,94.87 78.09,94.87 78.87,95.65 92.52,95.65 93.02,96.15 97.77,96.15 97.89,96.03 v1(99.1,96.03)
  BOTTOM w0.079: 106.59,115.72 106.59,115.95 106.4,116.14 106.4,118.26 106.67,118.53 106.67,120.3 106.11,120.86 106.11,121.2 106.06,121.34 U1.CP28
  BOTTOM w0.114: 106.59,115.72 106.59,114.5 105.88,113.79 103.15,113.79 102.58,113.22 102.58,112.78 102.17,112.38 102.17,111.28 101.9,111.01 101.9,110.28 100.33,108.7 98.88,108.7 v1(98.38,108.2) 98.02,107.84 98.02,100.72 99.28,99.46 99.28,97.08 99.1,96.91 v1(99.1,96.03)
EC_FPBACK#: length 276.5
  TOP w0.114: v1(169.17,106.09) 168.61,105.54 U37.86 ; v1(206.45,106.21) 206.45,107.04 208.58,109.17 208.58,112.28 211.23,114.92 211.23,120.65 213.13,122.55 v1(213.52,122.55) v1(214.99,122.55)
  IN1 w0.089: v1(206.45,106.21) 204.94,106.21 202.82,104.09 199.48,104.09 199,103.61 191.91,103.61 189.92,105.6 189.57,105.6 189.39,105.78 188.71,105.78 188.59,105.66 182.7,105.66 178.71,109.65 175.49,109.65 172.66,106.82 170.28,106.82 169.96,106.5 169.57,106.5 v1(169.17,106.09)
  IN3 w0.102: v1(81.86,188.1) 82.3,188.1 82.75,187.65 84.54,187.65 85.02,188.13 87.01,188.13 88.13,187.01 88.87,187.01 89.58,187.72 91.12,187.72 92.47,186.37 92.47,184.63 93.63,183.47 96.15,183.47 96.55,183.87 99.35,183.87 100.84,182.38 103.48,182.38 104.54,181.32 104.54,180.85 105.61,179.78 106.7,179.78 108.63,177.84 111.88,177.84 116.5,173.23 116.5,171.05 117.94,169.61 117.94,166.96 119.27,165.64 120.43,165.64 122.25,163.82 122.25,155.14 122.91,154.48 126.72,154.48 128.66,152.53 128.66,151.88 129.45,151.1 129.45,143.23 130.72,141.96 130.72,141.6 131.61,140.71 131.61,140.56 132.54,139.63 133.42,139.63 136.53,136.51 136.53,131.54 137.4,130.67 137.4,129.47 136.46,128.52 135.47,128.52 133.88,126.93 133.88,123.21 132.96,122.29 132.96,117.72 135.58,115.1 135.58,112.15 137.5,110.24 139.95,110.24 140.36,110.65 146.91,110.65 149.62,113.36 151.28,113.36 152.15,114.22 153.3,114.22 154.88,115.8 156.63,115.8 157.65,116.83 160.28,116.83 160.95,117.5 163.65,117.5 164.33,118.18 164.33,118.99 167.02,121.68 167.98,121.68 168.3,121.36 169.21,121.36 169.5,121.65 174.39,121.65 174.68,121.94 176.06,121.94 176.87,121.14 176.87,120.9 177.93,119.84 183.86,119.84 184.3,119.4 188.87,119.4 189.6,120.13 190.7,120.13 190.96,120.4 203.52,120.4 206.31,123.19 209.64,123.19 211.01,121.81 214.63,121.81 v1(214.99,122.55)
  BOTTOM w0.114: Q6522.2 v1(81.86,188.1)
EC_PECI: length 70.1
  TOP w0.114: v1(166.51,122.61) 166.89,122.23 166.89,119.87 166.23,119.21 166.23,118.86 164.88,117.51 164.76,117.51 164.4,117.15 164.4,115.48 163.77,114.86 162.33,114.86 162.27,114.8 160.94,114.8 159.71,113.56 R380.2
  IN1 w0.089: v1(166.51,122.61) 162.66,122.61 162.42,122.85 156.87,122.85 155.33,124.39 151.26,124.39 149.63,126.03 149.63,126.93 147.71,128.85 146.5,128.85 145.59,129.76 145.59,129.98 145.44,130.13 138.82,130.13 137.2,131.76 135.6,131.76 134.93,132.43 134.93,133.83 134.56,134.2 134.56,134.68 132.17,137.08 131.18,137.08 129.98,138.27 129.98,139.47 129.38,140.07 128.58,140.07 124.2,144.44 v1(124.2,145.19)
  BOTTOM w0.079: U1.AR1 124.19,145.2 v1(124.2,145.19)
EC_PECR_R: length 4.5
  TOP w0.114: U37.117 157.36,112.17 156.81,112.71 156.81,113.4 157.23,113.82 158.34,113.82 R380.1
EC_PWROK: length 67.7
  TOP w0.114: U37.33 152.96,96.36 154.42,97.82 154.57,97.82 155.6,98.85 155.6,99.87 155.72,99.98 155.72,101.91 156.39,102.59 v1(157.08,102.59)
  IN1 w0.089: v1(110.46,109.39) 111.39,109.39 111.92,109.92 117.65,109.92 120.62,106.95 127.24,106.95 130.06,104.14 133.27,104.14 133.87,103.54 137.42,103.54 138.24,102.72 143.89,102.72 144.17,102.44 144.17,102.44 144.76,101.86 147.51,101.86 147.63,101.97 151.05,101.97 151.32,102.24 151.64,102.24 152.06,102.66 157,102.66 v1(157.08,102.59)
  BOTTOM w0.114: v1(110.46,109.39) 110.46,108.76 v1(110.52,108.71) 110.54,108.68 110.93,108.68 110.96,108.72 R25358.2 111.3,109.28 111.51,109.48 U6504.1 112.94,109.48 113.38,109.93 114.63,109.93 115.05,109.51 116.13,109.51 116.36,109.74 R25362.2
EC_SIM_DET: length 65.4
  TOP w0.114: v1(168.18,109.04) 167.88,108.74 U37.94
  IN1 w0.089: v1(221.08,123.85) 221.01,123.92 215.78,123.92 214.54,122.69 214.54,121.36 213.7,120.52 206.76,120.52 204.98,118.74 199.75,118.74 196.6,115.59 195.99,115.59 195.79,115.39 186.78,115.39 186.33,115.84 183.94,115.84 v1(183.38,116.4)
  IN4 w0.089: v1(168.18,109.04) 168.68,109.54 169.46,109.54 170.79,110.87 171.04,110.87 173.66,113.49 176.89,113.49 178.53,115.13 182.12,115.13 v1(183.38,116.4)
  BOTTOM w0.114: v1(221.08,123.85) 220.58,123.85 v1(220.37,123.64) 220.37,123.44 220.53,123.29 220.83,123.29 221.08,123.03 221.08,122.77 221.35,122.51 221.35,122.5 221.41,122.44 221.41,122.43 221.59,122.25 CN49.12
EC_SIM_SW#: length 88.9
  TOP w0.114: U37.3 v1(152.56,108.74)
  IN3 w0.102: v1(201.95,108.86) 201.19,108.11 201.19,106.62 200.8,106.23 198.13,106.23 197.16,105.26 195.48,105.26 195,105.74 191.33,105.74 189.82,107.25 182.26,107.25 178.97,110.54 175.6,110.54 171.59,106.52 168.15,106.52 167.28,105.65 159.78,105.65 158.83,106.6 153.66,106.6 152.56,107.71 v1(152.56,108.74)
  BOTTOM w0.114: v1(201.95,108.86) 201.95,108.38 203.18,107.14 206.21,107.14 207.39,108.31 209.66,108.31 212.93,111.58 212.93,116.06 217.64,120.77 219.91,120.77 v1(220.53,121.38) 220.66,121.52 221.27,121.52 221.5,121.75 CN49.13
EC_VOLDN_BTN_ODL: length 67.4
  TOP w0.114: v1(200.74,107.24) 200.79,107.19 v1(200.79,106.58) ; U37.2 152.15,109.14 152.25,109.24 152.72,109.24 v1(153.22,108.74)
  IN3 w0.102: v1(153.22,108.74) 154.26,107.69 155.01,107.69 155.87,106.83 158.93,106.83 159.88,105.88 167.18,105.88 168.06,106.75 171.49,106.75 175.5,110.77 179.07,110.77 182.36,107.48 189.91,107.48 191.42,105.97 195.09,105.97 195.57,105.49 197.06,105.49 198.03,106.46 199.95,106.46 v1(200.74,107.24)
  BOTTOM w0.114: CN52.6 207.85,103.02 205.07,105.8 203.66,105.8 203.1,106.36 201.62,106.36 v1(200.74,107.24)
EC_VOLUP_BTN_ODL: length 46.8
  TOP w0.114: v1(169.01,102.36) 168.23,103.14 U37.80 ; v1(208.28,101.37) 208.28,102.03 v1(208.35,102.1)
  IN1 w0.089: v1(169.01,102.36) 169.01,101.97 170.19,100.79 181.6,100.79 181.95,100.44 183.01,100.44 184.31,99.14 192.23,99.14 193.86,100.77 195.84,100.77 196.65,101.58 198.14,101.58 198.62,101.1 207.35,101.1 v1(208.35,102.1)
  BOTTOM w0.114: CN52.5 v1(208.35,102.1)
EC_VSTBY_FSPI: length 5.6
  TOP w0.114: PU8000.5 18.96,116.69 17.83,116.69 PC8006.1 17.59,116.38 PD8004.2 16.59,115.5 16.59,116.38 16.48,116.49 PR8036.2 15.87,116.95 v1(15.57,116.66)
ECAGND: length 20
  TOP w0.114: C6564.1 172.93,95.45 v1(173.33,95.86) ; U37.75 168.48,101.14 168.82,101.48 169.61,101.48 170.01,101.88 C6566.2 171.28,101.88 L11.1 171.88,101.52 173.38,101.52 v1(173.97,100.94) 174.32,100.59 175.9,100.59 176.59,99.9 176.59,97.8 177.53,96.86 v1(177.53,96.58)
  BOTTOM w0.114: v1(177.53,96.58) 176.8,95.86 v1(173.33,95.86)
EDP_RCOMP: length 7.3
  BOTTOM w0.079: U1.AM6 119.8,146.83 120.28,146.83 120.81,147.36 122.2,147.36 122.45,147.11 123.05,147.11 123.61,146.55 124.04,146.55 124.18,146.41 126.09,146.41
  BOTTOM w0.127: R2.2 126.09,146.41
EDRAM_OPIO_RCOMP: length 9.2
  BOTTOM w0.079: U1.L5 120.42,160.31 120.42,160.81 120.46,160.85 120.46,161.61 120.62,161.77 120.62,162.43 120.94,162.74 120.94,162.98 121.13,163.17 121.63,163.17 121.72,163.25 122.7,163.25 122.75,163.2 123.01,163.2 123.15,163.34 123.75,163.34 123.98,163.11
  BOTTOM w0.102: R20.1 126.16,162.71 125.76,163.11 123.98,163.11
EEDI: length 4
  TOP w0.114: R4008.1 13.61,167.1 TP13155.1 14.84,166.46 15.98,166.46 16.23,166.21 U6521.30
EMMC_RCOMP: length 3.2
  TOP w0.102: R147.1 115.61,122.17 v1(115.02,122.76) 114.72,123.06 114.72,123.63 v2(114.3,124.05)
  BOTTOM w0.079: U1.CK15 113.91,123.71 114.25,124.05 v2(114.3,124.05)
EN: length 3.4
  TOP w0.114: U42.7 226.88,116.22 R1236.2 226.42,116.82 226.15,117.08 226.09,117.15 225.24,117.15 224.89,116.8 R1238.1
EN1_CORE: length 1.1
  BOTTOM w0.305: PU7002.1 154.8,160.9 PR7107.2
EN2_CORE: length 2.8
  BOTTOM w0.114: v1(157,145.77) 155.99,144.76 PU7001.1
  BOTTOM w0.254: PU7001.1 155.72,145 155.31,145.4 PR7079.2
EN_3V_DX_LTE: length 90
  TOP w0.114: R67871.2 171.17,104.46 171.68,103.95 v1(171.68,103.63) 171.68,103.17 170.9,102.39 169.87,102.39 169.33,101.85 168.87,101.85 v1(168.35,102.36) 167.94,101.94 U37.77
  IN1 w0.089: v1(223.83,124.94) 224.37,124.4 224.37,123.62 225.94,122.04 226.95,121.04 226.95,120.56 227.28,120.22 227.28,113.45 224.42,110.58 224.42,109.12 221.16,105.86 218.51,105.86 216.34,103.69 211.72,103.69 208.94,100.91 198.55,100.91 198.07,101.39 196.73,101.39 195.92,100.58 193.94,100.58 192.31,98.95 184.23,98.95 182.93,100.25 181.87,100.25 181.52,100.6 170.11,100.6 v1(168.35,102.36)
  BOTTOM w0.114: CN49.7 223.64,124.75 v1(223.83,124.94)
EN_GT: length 2.1
  BOTTOM w0.254: v1(153.7,163.19) 153.39,163.5 PR7111.2 153.39,164.53 153.66,164.8 PU7003.1
EN_SA: length 0.9
  TOP w0.114: v1(166.96,128.7) 166.96,129.5 PR7115.2
ENSWREG: length 10.7
  TOP w0.114: U6521.6 23.59,165.81 23.71,165.69 24.95,165.69 25.43,166.18 26.84,166.18 v1(27.18,166.52) 28,167.34 28.89,167.34 29.33,166.9 R67513.2 R67476.1 31.3,165.1 R67475.2
EOPIO_RCOMP: length 9.4
  BOTTOM w0.079: U1.N5 120.17,159.43 arc(120.19,159.55) 120.26,159.65 120.58,159.97 arc(120.59,159.99) 120.59,160.01 120.59,160.67 arc(120.59,160.67) 120.6,160.67 120.62,160.7 arc(120.63,160.71) 120.63,160.73 120.63,161.55 arc(120.63,161.55) 120.64,161.55 121.21,162.12 121.21,162.4 121.4,162.59 123.11,162.59 123.14,162.56 123.6,162.56
  BOTTOM w0.102: R21.2 126.29,161.95 125.5,162.73 123.77,162.73 123.6,162.56
EQ1: length 3.9
  TOP w0.114: R498.1 234.65,115.2 234.31,115.55 233.45,115.55 233.13,115.22 R497.2 232.8,115.08 232.67,115.22 U42.17
EQ2: length 3.9
  TOP w0.114: U42.19 232.99,116.22 R1234.2 233.13,116.51 233.44,116.82 234.31,116.82 234.65,116.47 R495.1
EXT_PWR_GATE#: length 17.5
  TOP w0.114: R40.1 85.77,122.36 86.08,122.06 87.63,122.06 88.29,122.72 89.03,122.72 90.06,123.74 90.46,123.74 90.95,124.23 92.08,124.23 92.83,124.98 93.83,124.98 94.37,125.53 97.51,125.53 v1(99.03,127.06)
  BOTTOM w0.079: U1.CC37 100.1,127.54 99.51,127.54 v1(99.03,127.06)
FAN1_RPM: length 107.6
  TOP w0.114: v1(206.32,125.08) 206.32,124.81 v1(205.92,124.41) 205.63,124.11 205.35,124.11 202.46,121.22 202.46,110.16 203.17,109.46 203.17,107.4 200.89,105.12 200.89,103.54 201.25,103.17 201.25,101.92 199.74,100.4 199.74,96.7 198.42,95.38 197.32,95.38 196.45,94.51 158.68,94.51 158.56,94.63 U37.47
  IN3 w0.102: v1(206.32,125.08) 205.68,125.72 201.83,125.72 197.19,121.08 190.68,121.08 190.41,120.82 188.28,120.82 188.02,121.08 183.04,121.08 v1(182.69,120.73)
  BOTTOM w0.114: v1(182.69,120.73) 182.13,121.3 R25372.2 181.63,121.02 181.63,117.4 181.4,117.18 FAN3.2
FAN_PWM: length 131.2
  TOP w0.114: v1(196.96,104.66) 197.69,105.39 197.69,106.01 198.36,106.68 198.36,116.94 198.85,117.42 198.85,119.85 197.96,120.74 197.96,122.61 197.81,122.76 197.81,124.52 v1(197.49,124.84) 197.08,125.25 v1(197.08,125.37) ; v1(146.97,95.98) 148.09,94.87 150.29,94.87 150.9,95.48 150.9,96.95 151.1,97.14 U37.32
  IN4 w0.089: v1(163.91,121.95) 163.91,120.43 164.1,120.24 164.1,118.8 164.97,117.93 165.8,117.93 166.04,117.69 168.29,117.69 168.8,118.21 169.12,118.21 169.61,118.69 171.84,118.69 173.12,119.97 175.75,119.97 176.8,121.02 176.8,122.52 177.37,123.09 180.2,123.09 182.48,125.37 188.27,125.37 188.56,125.66 191.41,125.66 191.96,126.2 196.24,126.2 v1(197.08,125.37)
  BOTTOM w0.114: v1(196.96,104.66) 196.96,101.84 196.15,101.04 196.15,100.16 196.21,100.1 196.21,99.68 195.47,98.93 195.47,98.27 194.85,97.65 192.99,97.65 190.53,95.19 153.39,95.19 152.71,95.86 151.89,95.86 151.22,95.19 147.77,95.19 v1(146.97,95.98) ; v1(163.91,121.95) 163.62,121.95 163.34,122.23 163.34,123.14 163.84,123.65 163.84,124.12 163.92,124.21 Q6523.1
FAN_PWM_C: length 17.7
  BOTTOM w0.114: Q6523.3 166.59,123.59 166.76,123.41 R25373.2 167.67,123.88 168.53,123.88 169.69,122.73 171.96,122.73 172.44,123.21 v1(172.52,123.21) 172.72,123.01 172.72,122.65 174.26,121.11 176.34,121.11 179.02,118.43 FAN3.3
FB_CAL_PD_VDDQ: length 11.5
  TOP w0.381: v1(144.96,182.8) 144.96,182.14 v1(145.54,181.56) R318.2
  IN1 w0.381: v1(144.96,182.8) 144.96,183.03 144.63,183.36 142.22,183.36 141.79,183.79 139.91,183.79 139.47,184.22 139.32,184.22 138.84,184.71 137.77,184.71 v2(137.52,184.45)
  BOTTOM w0.381: v2(137.52,184.45) 137.12,184.85 U8.D22
FB_CAL_PU_GND: length 8.4
  TOP w0.114: v1(144.3,182.8) 144.3,182.9 144.86,183.46 v1(145.06,183.46) 145.44,183.08 145.44,183.05 145.91,182.59 R319.2
  IN1 w0.089: v2(139.22,183.64) 139.55,183.64 139.93,183.26 141.53,183.26 142.04,182.75 144.2,182.75 144.25,182.8 v1(144.3,182.8)
  BOTTOM w0.102: U8.C24 139.22,183.65 v2(139.22,183.64)
FB_CAL_TERM_GND: length 5.7
  BOTTOM w0.203: 142.31,183.16 141.99,183.16 141.49,183.65 140.03,183.65 U8.B25
  BOTTOM w0.508: 144.8,183.51 144.07,183.51 143.72,183.16 142.31,183.16
  vias: v1(145.08,183.51)
FB_CORE: length 7
  BOTTOM w0.152: PC7010.2 164.81,134.53 164.81,135.5 PR7047.1
  BOTTOM w0.203: PU7000.3 165.5,138.41 165.95,137.96 PR7048.1 165.95,136.95 PC7011.2 166.26,136.65 PR7049.2 166.25,135.98 PR7047.1
FB_GT: length 10.6
  BOTTOM w0.203: PC7016.1 PR7054.1 160.17,148.95 PR7055.1 ; PU7000.24 160.8,145.01 160.57,145.23 160.57,146.33 160.03,146.88 159.18,146.88 PR7056.2 158.5,147.56 v1(158.5,147.93) 158.6,148.03 158.6,148.67 158.81,148.87 158.81,149.23 159.08,149.5 159.69,149.5 160.16,149.03 PR7055.1 ; PR7055.1 PC7017.2
FB_SA: length 7.3
  BOTTOM w0.114: PU7000.45 167.96,141.81 168.06,141.71 168.39,141.71 168.43,141.68 PC7021.2 169.35,141.68 169.35,141.68 PR7060.1 169.82,141.19 169.81,141.19 PC7020.1 169.81,140 169.8,140 PR7059.1 169.8,139.25 170.34,138.72 PR7063.1 170.7,138.52 171.17,138.05 v1(171.17,137.89)
FBA_CMD0: length 26.5
  IN1 w0.127: v2(160.9,182.02) 160.5,182.42 160.5,184.19 156.5,188.19 146.19,188.19 144.93,186.93 v2(144.93,186.81)
  BOTTOM w0.127: U8.C27 141.6,184.05 141.79,183.86 142.45,183.86 142.58,183.99 ; v2(160.9,182.02) 160.5,181.62 VRAM1.G12
  BOTTOM w0.178: v2(144.93,186.81) 144.93,185.59 143.33,183.99 142.58,183.99
FBA_CMD1: length 31.4
  IN1 w0.127: v2(160.1,179.62) 160.49,180.02 160.49,180.66 160.65,180.82 161.16,180.82 161.3,180.96 161.3,184.07 156.69,188.68 145.92,188.68 144.3,187.06 v2(144.3,186.81)
  BOTTOM w0.127: 142.65,184.43 142.58,184.43 142.43,184.27 141.81,184.27 141.66,184.42 140.8,184.42 U8.C26 ; v2(160.1,179.62) 159.71,180.02 VRAM1.H10
  BOTTOM w0.178: 142.65,184.43 143.01,184.43 144.3,185.71 v2(144.3,186.81)
FBA_CMD2: length 28.9
  IN1 w0.127: v2(160.1,180.42) 159.64,180.88 159.64,184.36 156.3,187.71 147.2,187.71 145.88,186.38 141.16,186.38 140.45,185.67 139.39,185.67 139.35,185.71 138.88,185.71 v2(138.46,185.29)
  BOTTOM w0.127: v2(138.46,185.29) 138.82,185.65 U8.E24 ; VRAM1.H11 159.71,180.82 v2(160.1,180.42)
FBA_CMD3: length 28.2
  IN3 w0.127: v2(138.42,186.97) 138.81,187.36 140.15,187.36 140.99,188.2 142.13,188.2 142.77,188.84 144.77,188.84 144.97,189.05 146.8,189.05 147.52,188.32 154.27,188.32 159.02,183.57 159.02,180.94 v2(158.5,180.42)
  BOTTOM w0.127: VRAM1.K11 158.11,180.82 v2(158.5,180.42) ; U8.F24 138.82,186.57 v2(138.42,186.97)
FBA_CMD4: length 22.6
  IN1 w0.127: v2(158.5,179.62) 158.11,180.02 158.11,183.79 157.32,184.58 150.15,184.58 149.91,184.81 142.92,184.81 v2(142.82,184.91)
  BOTTOM w0.127: 142.65,184.85 142.3,184.5 141.91,184.5 141.56,184.85 U8.D27 ; VRAM1.K10 158.11,180.02 v2(158.5,179.62)
  BOTTOM w0.14: 142.65,184.85 142.7,184.91 v2(142.82,184.91)
FBA_CMD5: length 22.5
  IN1 w0.127: v2(142.14,184.91) 142.14,184.57 142.41,184.3 145.22,184.3 145.98,183.54 150.49,183.54 150.62,183.4 150.93,183.4 151.03,183.5 151.03,183.96 151.15,184.08 157.06,184.08 157.3,183.84 157.3,182.42 v2(157.7,182.02)
  BOTTOM w0.127: v2(157.7,182.02) 157.3,181.62 VRAM1.L12 ; U8.D26 140.42,185.19 140.79,185.57 142.36,185.57 142.49,185.44 142.49,185.26 v2(142.14,184.91)
FBA_CMD6: length 26.5
  IN3 w0.127: v2(143.03,186.79) 143.03,186.67 144.75,184.95 149.76,184.95 150.95,183.75 150.95,180.71 153.38,178.28 154.88,178.28 155.8,177.36 156.53,177.36 157.31,176.59 157.31,176.02 v2(157.7,175.62)
  BOTTOM w0.102: 140.83,186.7 140.59,186.95 140.02,186.95 U8.F25
  BOTTOM w0.127: 142.65,186.32 142.44,186.11 141.09,186.11 140.83,186.38 140.83,186.7 ; VRAM1.K4 158.1,175.23 v2(157.7,175.62)
  BOTTOM w0.14: v2(143.03,186.79) 143.03,186.7 142.65,186.32
FBA_CMD7: length 26.1
  IN3 w0.127: v2(143.66,186.79) 143.66,186.72 144.95,185.43 151.83,185.43 153.3,183.96 153.3,179.33 153.87,178.76 155.14,178.76 156.08,177.82 156.53,177.82 157.7,176.65 v2(157.7,176.42)
  BOTTOM w0.127: VRAM1.K5 158.1,176.03 v2(157.7,176.42) ; 142.65,185.8 140.87,185.8 140.42,186.24 U8.F26
  BOTTOM w0.178: 142.65,185.8 142.93,185.8 143.66,186.53 v2(143.66,186.79)
FBA_CMD8: length 31.6
  IN3 w0.127: v2(158.5,175.62) 158.9,176.02 158.9,177.39 157.1,179.19 156.72,179.19 156.5,179.41 156.5,183.75 153.38,186.88 146.92,186.88 146.15,187.65 142.85,187.65 142.63,187.43 141.52,187.43 141.02,186.93 141.02,186.54 140.18,185.69 138.89,185.69 v2(138.43,186.15)
  BOTTOM w0.127: v2(138.43,186.15) 138.03,186.55 U8.F23 ; v2(158.5,175.62) 158.9,175.23 VRAM1.J4
FBA_CMD9: length 33.4
  IN3 w0.127: v2(158.5,176.42) 158.5,177.14 156.91,178.74 156.36,178.74 155.65,179.44 155.65,179.76 155.71,179.82 155.71,183.86 153.18,186.39 146.72,186.39 145.91,187.21 141.62,187.21 141.25,186.84 141.25,185.92 140.18,184.86 138.25,184.86 138.01,185.1 138.01,185.54 137.88,185.67 137.48,185.67 137.23,185.91 137.23,186.55 v2(136.81,186.97)
  BOTTOM w0.127: VRAM1.J5 158.9,176.03 v2(158.5,176.42) ; v2(136.81,186.97) 137.18,187.34 U8.G22
FBA_CMD10: length 32.8
  IN3 w0.127: v2(137.6,186.97) 137.66,186.97 138.07,186.56 140.32,186.56 141.43,187.66 142.48,187.66 142.93,188.11 146.37,188.11 147.12,187.36 153.78,187.36 157.3,183.84 157.3,181 157.63,180.67 157.63,179.31 159.7,177.24 159.7,176.02 v2(159.3,175.62)
  BOTTOM w0.127: VRAM1.H4 159.7,175.23 v2(159.3,175.62) ; U8.G23 137.98,187.35 v2(137.6,186.97)
FBA_CMD11: length 30.9
  IN3 w0.127: v2(160.1,176.42) 160.1,177.46 158.11,179.45 158.11,183.8 154.07,187.84 147.32,187.84 146.6,188.57 142.87,188.57 142.2,187.89 141.33,187.89 140.41,186.97 v2(139.22,186.97)
  BOTTOM w0.102: U8.G24 138.84,187.35 v2(139.22,186.97)
  BOTTOM w0.127: VRAM1.H5 159.7,176.02 v2(160.1,176.42)
FBA_CMD12: length 28.8
  IN3 w0.127: v2(142.39,186.79) 142.39,186.62 144.55,184.46 149.56,184.46 150.47,183.55 150.47,180.51 153.18,177.8 154.74,177.8 155.5,177.03 156.11,177.03 156.24,176.91 156.24,175.51 156.51,175.23 157.86,175.23 158.1,174.99 158.1,174.56 158.25,174.42 160.49,174.42 v2(160.9,174.82)
  BOTTOM w0.127: v2(160.9,174.82) 160.5,174.42 VRAM1.G3 ; 142.34,186.74 141.95,186.34 141.43,186.34 U8.F27
  BOTTOM w0.14: 142.34,186.74 v2(142.39,186.79)
FBA_CMD13: length 35.2
  IN3 w0.127: v2(159.3,174.82) 159.71,175.23 160.27,175.23 160.5,175.46 160.5,178.35 159.68,179.18 159.68,180.7 159.54,180.84 159.54,183.73 154.47,188.81 147.72,188.81 146.57,189.96 145.91,189.96 v1(145.44,189.48)
  BOTTOM w0.127: U8.G25 139.63,187.35 140.11,187.83 141.76,187.83 142.05,188.12 142.14,188.12 ; v2(159.3,174.82) 159.3,174.02 VRAM1.J2
  BOTTOM w0.178: 142.14,188.12 143.52,188.12 143.87,188.46 R315.2 145.44,189.23 v1(145.44,189.48)
FBA_CMD14: length 26.9
  IN3 w0.127: v2(145.58,186.79) 146.45,185.91 152.81,185.91 154.9,183.82 154.9,180.17 155.02,180.05 155.02,179.53 156.27,178.28 156.72,178.28 158.1,176.9 158.1,175.43 158.5,175.02 v2(158.5,174.82)
  BOTTOM w0.127: 142.14,187.45 141.32,187.45 U8.G27 ; VRAM1.J3 158.9,174.43 v2(158.5,174.82)
  BOTTOM w0.178: v2(145.58,186.79) 145.58,187.3 R316.2 142.14,187.45
FBA_CMD15: length 25.7
  IN3 w0.127: v2(141.76,186.79) 141.76,186.58 144.96,183.37 149.13,183.37 149.99,182.52 149.99,180.31 152.98,177.31 154.49,177.31 155.09,176.71 155.09,175.64 155.7,175.03 155.7,174.54 155.82,174.42 157.3,174.42 v2(157.7,174.82)
  BOTTOM w0.102: 141.14,186.94 140.74,187.35 U8.G26
  BOTTOM w0.127: VRAM1.L3 157.3,174.42 v2(157.7,174.82) ; 141.14,186.94 141.6,186.94 v2(141.76,186.79)
FBA_CMD16: length 26.5
  IN1 w0.127: v2(157.68,197.23) 158.1,197.65 158.1,199.17 157.92,199.35 152.99,199.35 147.57,193.93 147.57,192.77 146.23,191.43 142.95,191.43 142.8,191.58 142.22,191.58 142.1,191.46 139.67,191.46 v2(139.22,191.91)
  BOTTOM w0.127: v2(157.68,197.23) 157.3,196.85 VRAM2.G12 ; U8.M24 138.82,191.54 139.19,191.91 v2(139.22,191.91)
FBA_CMD17: length 24.8
  IN1 w0.127: v2(157.7,198.88) 157.28,198.46 152.8,198.46 148.07,193.72 148.07,192.57 146.44,190.94 142.63,190.94 142.38,191.19 139.12,191.19 v2(138.41,191.9)
  BOTTOM w0.127: v2(157.7,198.88) 157.7,198.82 158.1,198.43 VRAM2.H10 ; v2(138.41,191.9) 138.02,191.51 U8.M23
FBA_CMD18: length 26
  IN3 w0.127: v2(140.02,190.26) 140.66,189.62 142.16,189.62 142.41,189.87 143.77,189.87 145.31,191.41 145.6,191.41 146.39,192.2 153.56,192.2 155.16,193.8 157.38,193.8 158.11,194.53 158.11,197.63 v2(157.7,198.04)
  BOTTOM w0.102: U8.K24 139.13,189.83 139.55,190.24 139.99,190.24 v2(140.02,190.26)
  BOTTOM w0.127: VRAM2.H11 158.1,197.63 157.7,198.02 v2(157.7,198.04)
FBA_CMD19: length 29.7
  IN3 w0.127: v2(159.26,198.04) 158.97,197.74 158.97,196.77 158.6,196.4 158.6,193.37 157.73,192.49 154.54,192.49 153.76,191.71 146.59,191.71 145.8,190.93 145.51,190.93 144.12,189.53 142.46,189.53 142.3,189.37 140,189.37 139.63,189 139.63,188.37 139.47,188.21 138.99,188.21 138.84,188.37 138.84,188.84 138.42,189.26 v2(138.42,189.43)
  BOTTOM w0.102: U8.K23 v2(138.42,189.43)
  BOTTOM w0.127: VRAM2.K11 159.67,197.62 159.26,198.02 v2(159.26,198.04)
FBA_CMD20: length 23.7
  IN1 w0.127: v2(159.3,198.88) 159.25,198.88 158.29,199.83 152.78,199.83 147.07,194.13 147.07,192.98 146.12,192.02 143.59,192.02 143.11,192.49 142.13,192.49 141.74,192.11 v2(141.74,192.03)
  BOTTOM w0.127: VRAM2.K10 159.7,198.43 159.3,198.82 v2(159.3,198.88) ; U8.M27 v2(141.74,192.03)
FBA_CMD21: length 27.9
  IN1 w0.127: v2(140.82,191.97) 141.38,192.53 141.38,192.56 141.8,192.98 143.35,192.98 143.81,192.51 145.91,192.51 146.58,193.18 146.58,194.34 152.56,200.32 159.02,200.32 160.08,199.25 160.08,198.08 v2(160.94,197.22)
  BOTTOM w0.127: v2(140.82,191.97) 140.42,191.57 U8.M26 ; v2(160.94,197.22) 160.54,196.82 VRAM2.L12
FBA_CMD22: length 27.9
  IN3 w0.127: v2(140,191.88) 140.45,191.44 142.9,191.44 143.41,191.94 143.41,193.39 143.71,193.69 143.71,193.81 151.04,201.14 155.64,201.14 155.67,201.16 157.25,201.16 157.76,201.67 157.76,202.69 158.28,203.21 159.71,203.21 160.1,202.82 v2(160.1,202.81)
  BOTTOM w0.127: v2(160.1,202.81) 160.1,202.82 159.71,203.22 VRAM2.K4
  BOTTOM w0.14: U8.M25 139.99,191.88 v2(140,191.88)
FBA_CMD23: length 26.2
  IN3 w0.127: v2(160.1,202.03) 160.1,201.09 158.31,199.3 156.53,199.3 155.69,198.46 154.01,198.46 153.99,198.48 151.99,198.48 145.4,191.89 145.2,191.89 143.61,190.3 142.41,190.3 142,189.9 141.4,189.9 v2(141,190.3)
  BOTTOM w0.127: U8.K26 140.48,189.83 140.95,190.3 v2(141,190.3) ; VRAM2.K5 159.71,202.42 160.1,202.03 v2(160.1,202.03)
FBA_CMD24: length 30.5
  IN3 w0.127: v2(137.6,189.43) 137.19,189.84 137.19,190.42 137.42,190.66 137.86,190.66 138.8,191.61 138.8,192.11 139.04,192.35 139.8,192.35 140.8,193.35 140.8,193.99 141.47,194.65 143.19,194.65 150.72,202.18 155.34,202.18 155.69,202.52 155.69,203.16 156.54,204.01 158.12,204.01 v2(158.5,203.63)
  BOTTOM w0.127: v2(137.6,189.43) 137.2,189.83 U8.K22 ; v2(158.5,203.63) 158.5,203.62 158.9,203.23 VRAM2.J4
FBA_CMD25: length 30.9
  IN3 w0.127: v2(159.3,202.03) 159.3,202.03 158.91,202.42 158.25,202.42 158.08,202.24 158.08,201.35 157.43,200.71 155.89,200.71 155.84,200.66 151.24,200.66 144.26,193.67 144.26,193.31 144.35,193.22 144.35,192.64 143.8,192.09 143.8,191.92 143.09,191.21 138.79,191.21 138,190.42 138,189.03 v2(138.42,188.61)
  BOTTOM w0.127: VRAM2.J5 158.91,202.42 159.3,202.03 v2(159.3,202.03) ; v2(138.42,188.61) 138.02,189.01 U8.J23
FBA_CMD26: length 29.8
  IN3 w0.127: v2(158.5,202.81) 158.51,202.82 159.15,202.82 159.7,202.27 159.7,201.46 158.03,199.78 156.33,199.78 155.89,199.34 151.29,199.34 145.22,193.27 145.22,192.51 143.4,190.69 139.61,190.69 139.22,190.3 v2(139.22,189.43)
  BOTTOM w0.102: v2(139.22,189.43) U8.J25
  BOTTOM w0.127: VRAM2.H4 158.11,203.22 158.5,202.82 v2(158.5,202.81)
FBA_CMD27: length 28.8
  IN3 w0.127: v2(158.5,201.99) 158.5,200.9 157.84,200.25 156.12,200.25 155.74,199.87 151.14,199.87 144.74,193.47 144.74,192.54 143.14,190.94 139.37,190.94 138.82,190.4 138.82,189.24 139.24,188.82 v2(139.24,188.61)
  BOTTOM w0.127: v2(158.5,201.99) 158.49,201.99 158.1,202.39 VRAM2.H5 ; v2(139.24,188.61) U8.J24
FBA_CMD28: length 25.1
  IN3 w0.127: v2(142.93,192.02) 142.93,193.59 143.23,193.89 143.23,194.01 150.84,201.62 155.44,201.62 157.07,201.62 157.3,201.85 157.3,203.02 156.9,203.42 v2(156.9,203.61)
  BOTTOM w0.127: VRAM2.G3 157.3,204.01 156.91,203.61 v2(156.9,203.61) ; 142.14,190.24 141.72,189.83 U8.K27
  BOTTOM w0.178: v2(142.93,192.02) 142.93,191.03 142.14,190.24
FBA_CMD29: length 29
  TOP w0.178: R317.1 158.56,204.46 v2(158.5,204.41)
  IN1 w0.127: v2(143.92,193.04) 144.99,193.04 145.52,193.56 145.59,193.56 146.08,194.05 146.08,194.54 152.34,200.8 156.55,200.8 158.06,202.31 158.06,203.78 158.5,204.22 v2(158.5,204.41)
  BOTTOM w0.127: VRAM2.J2 158.9,204.82 158.5,204.42 v2(158.5,204.41) ; U8.K25 139.99,189.45 141.86,189.45 142.12,189.71
  BOTTOM w0.178: v2(143.92,193.04) 143.47,192.59 143.47,190.7 142.49,189.71 142.12,189.71
FBA_CMD30: length 34.6
  IN3 w0.127: v2(159.3,203.63) 159.46,203.63 159.87,204.03 161.11,204.03 161.31,203.84 161.31,200.77 160.48,199.95 160.48,193.6 158.3,191.42 154.83,191.42 154.16,190.75 v2(146.99,190.75)
  BOTTOM w0.127: 142.14,189.15 141.35,189.15 U8.J27 ; v2(159.3,203.63) 159.29,203.63 VRAM2.J3
  BOTTOM w0.178: 142.14,189.15 143.87,189.15 144.19,189.47 R314.1 144.79,189.47 145.25,189.93 145.66,189.93 146.23,190.5 146.74,190.5 v2(146.99,190.75)
FBA_CMD31: length 32.9
  IN3 w0.127: v2(140.79,188.63) 141.23,189.06 142.39,189.06 142.52,189.2 144.19,189.2 144.95,189.95 145.22,189.95 145.71,190.44 146,190.44 146.79,191.23 153.96,191.23 154.74,192.01 158,192.01 159.7,193.71 159.7,195.91 159.6,196.01 159.6,197.59 159.7,197.69 159.7,199.92 160.81,201.02 160.81,201.42 160.5,201.72 160.5,203.22 160.1,203.62 v2(160.1,203.63)
  BOTTOM w0.127: v2(140.79,188.63) 140.79,188.65 U8.J26 ; v2(160.1,203.63) 160.1,203.63 160.49,204.02 VRAM2.L3
FBA_DBI0: length 36.9
  IN1 w0.127: v2(163.3,173.22) 162.65,173.22 161.99,173.88 152.63,173.88 151.9,174.61 151.9,176.88 149.27,179.51 139.71,179.51 138.45,180.77 137.42,180.77 136.19,182 136.19,182.17 135.46,182.91 135.46,183.53 135.16,183.83 135.16,185.06 v2(134.99,185.24)
  BOTTOM w0.165: VRAM1.D2 162.91,173.62 v2(163.3,173.22) ; v2(134.99,185.24) 134.96,185.24 134.64,184.91 U8.D19
FBA_DBI1: length 37.7
  IN4 w0.127: v2(130.94,185.29) 131.3,185.65 131.96,185.65 132.16,185.85 132.16,186.43 132.26,186.53 134.65,186.53 134.7,186.47 135.35,186.47 135.43,186.56 140.52,186.56 141.21,187.24 142.74,187.24 143.55,188.06 157.77,188.06 158.23,187.6 158.99,187.6 161,185.59 161.26,185.59 162.9,183.96 162.9,183.22 v2(162.5,182.82)
  BOTTOM w0.165: U8.D14 130.52,184.87 v2(130.94,185.29) ; v2(162.5,182.82) 162.9,182.42 VRAM1.D13
FBA_DBI2: length 28
  IN4 w0.127: v2(154.5,182.02) 154.31,181.83 153.57,181.83 152.72,180.97 150.35,180.97 148.5,179.12 135.35,179.12 134.54,179.93 133.23,179.93 132.5,180.66 v2(132.5,180.99)
  BOTTOM w0.102: U8.C17 133,183.73 132.66,183.39 132.66,183.11 132.71,183.06 132.71,181.2 v2(132.5,180.99)
  BOTTOM w0.165: VRAM1.P13 154.9,182.42 v2(154.5,182.02)
FBA_DBI3: length 23.9
  BOTTOM w0.079: 152.17,174.24 152.31,174.1 153.83,174.1 153.95,173.99 154.53,173.99 VRAM1.P2
  BOTTOM w0.165: 137.5,181.32 137.5,181.92 137.76,182.18 137.76,182.88 137.57,183.08 137.57,183.51 137.12,183.96 U8.C22
  BOTTOM w0.178: 152.17,174.24 151.69,174.72 151.69,175.14 147.47,179.36 139.46,179.36 137.5,181.32
FBA_DBI4: length 28
  IN4 w0.127: v2(163.3,195.62) 163.71,195.22 163.71,194.57 162.88,193.74 151.98,193.74 151.73,193.49 143.79,193.49 142.86,192.56 140.8,192.56 140.2,193.16 139.54,193.16 v2(139.22,193.48)
  BOTTOM w0.165: U8.P24 138.88,193.15 v2(139.22,193.48) ; VRAM2.P13 162.91,196.02 v2(163.3,195.62)
FBA_DBI5: length 28
  IN4 w0.127: v2(163.3,204.42) 162.9,204.02 162.14,204.02 161.34,203.22 154.05,203.22 154.03,203.24 150.83,203.24 145.4,197.81 141.12,197.81 141.02,197.71 v2(140,197.71)
  BOTTOM w0.165: v2(163.3,204.42) 163.29,204.42 VRAM2.P2 ; U8.W24 139.26,197.71 v2(140,197.71)
FBA_DBI6: length 17.7
  IN1 w0.127: v2(154.5,204.41) 154.35,204.41 153.77,203.83 151.86,203.83 148.57,200.54 141.77,200.54 140.57,199.35 v2(140.02,199.35)
  BOTTOM w0.165: v2(140.02,199.35) U8.AA25 ; v2(154.5,204.41) 154.5,204.42 154.9,204.82 VRAM2.D2
FBA_DBI7: length 16.7
  BOTTOM w0.079: 152.12,196.62 152.23,196.51 153.83,196.51 153.95,196.39 154.46,196.39 154.83,196.02 VRAM2.D13
  BOTTOM w0.165: 141.91,195.72 140.98,195.72 140.64,196.06 140.05,196.06 U8.U25
  BOTTOM w0.178: 152.12,196.62 151.56,197.18 144.52,197.18 143.06,195.72 141.91,195.72
FBA_EDC0: length 37.1
  IN1 w0.127: v2(135.03,186.07) 135.44,185.66 135.44,183.94 135.74,183.65 135.74,183.17 137.71,181.2 138.62,181.2 139.89,179.94 149.45,179.94 152.33,177.06 152.33,174.79 152.78,174.35 162.15,174.35 162.23,174.43 162.9,174.43 v2(163.3,174.02)
  BOTTOM w0.165: VRAM1.C2 163.7,173.62 v2(163.3,174.02) ; U8.E19 134.64,185.67 v2(135.03,186.07)
FBA_EDC1: length 37.4
  IN4 w0.127: v2(163.3,182.82) 162.9,182.42 161.53,182.42 161.3,182.65 161.3,183.88 160.54,184.64 159.68,184.64 157.28,187.04 147.11,187.04 145.95,185.87 141.36,185.87 140.33,184.84 136.21,184.84 136.18,184.81 135.5,184.81 135.5,184.82 133.2,184.82 133.18,184.84 131.93,184.84 131.58,184.49 v2(130.95,184.49)
  BOTTOM w0.165: v2(163.3,182.82) 163.7,182.42 VRAM1.C13 ; U8.C15 131.36,184.07 v2(130.95,184.49)
FBA_EDC2: length 28
  IN4 w0.127: v2(131.88,181.22) 132.13,181.48 132.74,181.48 132.99,181.22 132.99,180.89 133.44,180.44 134.75,180.44 135.56,179.62 148.29,179.62 150.58,181.92 152.99,181.92 153.49,182.42 154.1,182.42 v2(154.5,182.82)
  BOTTOM w0.102: v2(131.88,181.22) 132.5,181.85 132.5,182.6 132.16,182.95 U8.B16
  BOTTOM w0.165: VRAM1.R13 154.1,182.42 v2(154.5,182.82)
FBA_EDC3: length 23.8
  BOTTOM w0.079: 152.16,173.94 153.62,173.94 153.94,173.62 VRAM1.R2
  BOTTOM w0.165: 137.21,180.95 137.21,182.01 137.49,182.29 137.49,182.69 137.12,183.07 U8.B22
  BOTTOM w0.178: 137.21,180.95 139.53,178.62 140.21,178.62 140.35,178.49 140.35,178.26 140.5,178.11 140.91,178.11 141.08,178.29 141.08,178.51 141.2,178.62 141.72,178.62 141.86,178.49 141.86,178.29 142.03,178.11 142.42,178.11 142.6,178.29 142.6,178.48 142.74,178.62 147.16,178.62 151.84,173.94 152.16,173.94
FBA_EDC4: length 27
  IN4 w0.127: v2(140.06,193.57) 140.25,193.57 140.81,193.01 142.57,193.01 143.48,193.92 151.44,193.92 151.77,194.25 162.59,194.25 162.9,194.57 162.9,196.02 v2(163.3,196.42)
  BOTTOM w0.165: VRAM2.R13 163.7,196.02 v2(163.3,196.42) ; v2(140.06,193.57) 139.99,193.57 139.62,193.94 U8.R25
FBA_EDC5: length 29.3
  IN4 w0.127: v2(163.3,205.22) 162.9,204.82 162.2,204.82 162.1,204.72 158.99,204.72 158.9,204.81 151.68,204.81 145.69,198.82 141.42,198.82 140.72,198.12 139.07,198.12 138.72,197.78 138.42,197.78 v2(138.41,197.76)
  BOTTOM w0.165: VRAM2.R2 163.7,204.82 v2(163.3,205.22) ; U8.W23 138.02,197.37 v2(138.41,197.76)
FBA_EDC6: length 16.2
  IN1 w0.127: v2(153.7,205.22) 153.33,204.85 151.88,204.85 148.1,201.06 v2(143.76,201.06)
  BOTTOM w0.165: v2(153.7,205.22) 153.7,205.21 VRAM2.C2 ; 142.9,200.15 141,200.15 140.6,199.75 U8.AB26
  BOTTOM w0.178: 142.9,200.15 143,200.15 143.76,200.91 v2(143.76,201.06)
FBA_EDC7: length 14.7
  BOTTOM w0.079: 152.09,196.34 153.62,196.34 153.94,196.02 VRAM2.C13
  BOTTOM w0.165: U8.T26 140.42,195.1 140.76,195.44 141.91,195.44
  BOTTOM w0.178: 152.09,196.34 151.84,196.34 151.73,196.45 144.26,196.45 143.25,195.44 141.91,195.44
FBA_VREFC_1: length 5.4
  TOP w0.508: v1(158.14,189.61) 158.14,189.99 158.65,190.5 R411.2 R407.2 R410.2 159.05,188.44 159.05,187.47 C505.1 159.02,186.94 159.29,186.67 v1(159.3,186.67)
FBA_VREFC_2: length 6.5
  TOP w0.508: C506.1 159.03,192.5 159.05,192.53 R25283.2 R25284.2 ; C506.1 R25282.2 158.53,194.05 v2(159.3,194.82) ; C506.1 v1(158.53,191.54)
  BOTTOM w0.33: v2(159.3,194.82) 158.91,195.22 VRAM2.J14
FBVDD_EN: length 8.5
  BOTTOM w0.114: R25469.1 R325.2 v1(125.37,209.97) 125.73,210.34 126.47,210.34 126.76,210.05 126.76,209.86 127.17,209.45 128.11,209.45 128.31,209.65 128.31,211.04 128.64,211.37 U11.4
FBVDDQ_EN: length 97.8
  TOP w0.114: v1(126.22,206.9) 126.17,206.96 v1(126.17,208.05)
  IN1 w0.089: v1(170.06,155.61) 169.59,155.61 169.27,155.93 169.27,156.3 168.59,156.98 168.59,158.99 166.97,160.6 166.97,164.81 167.93,165.77 167.93,167.65 166.99,168.6 166.37,168.6 166.06,168.29 160.3,168.29 158.51,170.07 151.72,170.07 151.35,170.45 143.53,170.45 140.51,173.47 140.51,175.06 138.99,176.59 136.06,176.59 134.22,178.43 129.27,178.43 125.98,181.72 v2(125.98,184.42)
  IN3 w0.102: v2(125.98,184.42) 125.59,184.03 124.75,184.03 124.2,184.58 124.2,186.54 123.8,186.94 123.8,189.25 122.89,190.16 122.89,194.31 122.17,195.03 122.17,201.25 123.85,202.93 123.85,203.61 124.89,204.65 124.89,205.41 125.54,206.07 125.54,206.56 125.88,206.9 v1(126.22,206.9)
  BOTTOM w0.114: v1(126.22,206.9) 125.7,207.43 124.39,207.43 124.1,207.72 R25469.2 ; v1(170.06,155.61) 169.75,155.3 PR9095.2
G5335-AGND-1: length 12.1
  TOP w0.114: v1(148.31,128.37) 147.64,128.37 v1(147.63,128.36)
  IN3 w0.203: v1(144.51,129.73) 144.51,129.53 145.24,128.8 146.04,128.8 146.48,128.36 v1(147.63,128.36)
  BOTTOM w0.203: PU16.4 147.14,125.15 PR270.2 PR273.1 148.42,125.91 148.39,125.93 PR272.1 148.39,126.47 148.15,126.71 147.89,126.71 147.75,126.85 147.75,128.24 v1(147.63,128.36) 147.61,128.36 147.33,128.08 PC228.2 ; PC232.2 144.71,129.22 144.51,129.42 v1(144.51,129.73)
G5335-AGND-2: length 1.8
  BOTTOM w0.203: v3(169.5,157.01) 169.27,157.01 169.17,157.1 PC9091.2
  BOTTOM w0.508: v3(169.5,157.01) 169.5,156.99 169.5,156.99 169.5,156.46 PC9090.2
  vias: v1(169.29,154.25) v2(168.16,153.73)
G5335-BST-1: length 3
  BOTTOM w0.254: PU16.20 143.69,127.98 143.55,128.13 143.55,128.5 PR277.2 143,129.85 v1(142.8,130.04)
G5335-BST-2: length 2.1
  BOTTOM w0.254: 164.78,157.26 PU9004.20
  BOTTOM w0.508: PR9089.2 165.51,158 164.78,157.26
G5335-EN-1: length 3.2
  BOTTOM w0.203: PR274.2 146.67,128.08 PC228.1 146.66,127.5 146.59,127.43 146.59,126.41 146.56,126.38 146.56,126.35 146.35,126.15 PU16.2
G5335-EN-2: length 29
  TOP w0.508: v1(158.04,167.23) 158.04,166.63 PQ9086.2
  IN3 w0.508: v1(158.04,167.23) 158.04,167.36 158.85,168.17 163.85,168.17 165.72,166.3 165.72,160.61 167.75,158.58 167.75,156.72 168.64,155.83 168.64,154.63 v1(168.4,154.38)
  BOTTOM w0.254: PU9004.2 167.47,155.16 167.8,155.49 167.8,156.01 168.06,156.27 PC9090.1 PR9095.1 168.52,154.51 v1(168.4,154.38) 168.58,154.38 v1(168.99,153.97) 169.4,153.57 PR9096.2
G5335-FB-1: length 3.5
  BOTTOM w0.203: PU16.5 147.37,124.65 147.4,124.61 ; 147.4,124.61 147.4,124.01 PC225.1 PR269.2 ; 147.4,124.61 PR270.1
G5335-FB-2: length 6
  BOTTOM w0.114: v1(171.07,152.73) 171.07,152.36 PR9094.2
  BOTTOM w0.254: PU9004.5 167.48,153.66 167.91,153.24 167.91,152.71 168.31,152.31 PR9097.1 169.15,152.31 169.42,152.05 PC9089.1 PR9094.2
G5335-LX-1:
  vias: v1(139.68,128.29)
G5335-LX-2: length 1.1
  TOP w0.508: PR9092.1 161.19,157.86 v1(161.67,157.37)
  vias: v1(161.85,156.46)
G5335-PFM-1: length 2.3
  BOTTOM w0.203: PR272.2 147.67,126.27 147.58,126.18 PR98.1 147.14,126.18 146.6,125.65 PU16.3
G5335-PFM-2: length 3.5
  TOP w0.114: v1(167.57,154.35) 167.57,154.54 v2(167.94,154.91)
  TOP w0.203: v2(167.94,154.91) 168.49,155.46 PR9093.2 168.46,155.78 PR9091.1
  BOTTOM w0.254: v2(167.94,154.91) 167.8,154.91 167.55,154.66 PU9004.3
