# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AC_PRESENT_EC: length 241.7
  TOP w0.114: v2(98,128.59) 97.43,128.59 95.77,126.93 94.11,126.93 93.49,126.32 92.25,126.32 91.49,125.56 90.39,125.56 89.91,125.07 89.15,125.07 R35.1 88.12,124.05 86.99,124.05 86.55,124.49 84.52,124.49 84.28,124.73 78.87,124.73 76.38,122.23 76.38,119.24 76.59,119.04 76.59,116.74 76.28,116.43 76.28,106.55 73.85,104.12 73.85,100.07 73.04,99.26 73.04,97.8 72.43,97.2 72.43,93.74 v1(72.83,93.35) ; v1(201.92,102.21) 201.92,101.71 v1(201.7,101.5) 201.53,101.32 201.04,101.32 200,100.29 200,96.59 198.28,94.87 v1(198.25,94.87) ; U37.84 v1(165.82,104.74)
  IN1 w0.089: v1(198.25,94.87) 197.8,95.32 154.6,95.32 152.86,97.06 139.15,97.06 138.46,97.75 134.13,97.75 133.06,98.82 114.79,98.82 113.7,97.73 108.45,97.73 106.62,95.9 102.62,95.9 101.5,97.02 98.53,97.02 98.13,96.61 92.91,96.61 92.22,95.93 78.11,95.93 77.57,96.47 75.56,96.47 74.95,95.86 74.55,95.86 72.83,94.14 v1(72.83,93.35) ; v1(201.92,102.21) 201.79,102.08 199.04,102.08 198.54,102.58 196.27,102.58 195.43,101.75 192.8,101.75 191.85,100.8 184.03,100.8 183.42,101.42 182.35,101.42 182,101.77 170.6,101.77 170.24,102.13 170.24,102.82 169.17,103.88 166.68,103.88 v1(165.82,104.74)
  BOTTOM w0.079: v2(98,128.59) 98,129.62 99.6,131.22 100.33,131.22 100.4,131.26 100.72,131.26 100.79,131.23 101.28,131.23 U1.BU35
ACCEL_INTA: length 230.8
  TOP w0.114: v2(115.18,113.2) 115.14,113.16 v1(115.14,112.54)
  IN1 w0.089: v1(106.09,181.33) 106.47,180.9 106.95,180.9 107.52,181.46 107.94,181.46 108.1,181.3 112.24,181.3 113.01,180.54 120.13,180.54 121.97,182.38 121.97,185.12 122.39,185.54 122.39,186.62 121.97,187.04 121.97,196.05 124.01,198.09 124.56,198.09 124.79,198.32 126.41,198.32 126.97,198.87 126.97,202.58 128.22,203.83 128.88,203.83 129.47,203.24 135.03,203.24 136.9,205.11 140.2,205.11 141.12,206.02 148.23,206.02 150.51,208.31 150.51,208.7 v1(150.85,209.04)
  IN3 w0.102: v1(80.11,101.48) 81.03,101.48 81.31,101.77 82.15,101.77 82.78,101.13 83.87,101.13 84.28,101.55 84.65,101.55 84.93,101.28 87.39,101.28 87.78,101.66 89.99,101.66 90.98,100.67 97.5,100.67 98.33,101.5 100.74,101.5 101.5,102.26 103.64,102.26 106.14,104.76 106.14,105.2 109.34,108.39 109.34,109.41 109.86,109.94 110.55,109.94 111.43,110.82 111.43,112.07 112.36,112.99 112.68,112.99 112.86,112.81 113.42,112.81 114.28,113.67 114.83,113.67 115.18,113.32 v2(115.18,113.2)
  IN4 w0.089: v1(82.1,175.7) 82.21,175.6 92.64,175.6 96.4,179.35 102.98,179.35 104.99,181.36 v1(106.09,181.33)
  BOTTOM w0.079: U1.CR14 114.82,121.01 114.82,120.23 114.54,119.96 114.54,119.56 114.93,119.17 115.44,119.17 116.19,118.42 116.19,118.37
  BOTTOM w0.102: 116.19,117.52 116.19,118.37
  BOTTOM w0.114: v1(82.1,175.7) 82.1,173.42 79.41,170.72 79.41,135.63 80.39,134.64 80.39,131.52 80.1,131.22 80.1,123.13 80.46,122.78 80.46,116.58 82.64,114.39 82.64,113.31 81.69,112.35 81.69,107.74 82.63,106.79 82.63,105.55 81.86,104.78 81.86,103.23 v1(80.11,101.48) ; R25628.2 152.46,210.01 152.45,210 R67862.1 150.91,210 R25641.2 150.85,209.96 v1(150.85,209.04) ; 116.19,117.52 116.19,114.88 115.37,114.05 R25474.1 115.37,113.39 v2(115.18,113.2)
ACCEL_INTA_R: length 22.3
  TOP w0.079: 153.14,215.43 153.33,215.43 U6516.A5
  TOP w0.114: v1(153.13,215.43) 153.14,215.43
  TOP w0.254: v1(147.1,217.19) 147.1,217 146.54,216.45 146.54,214.83 146.12,214.4 U6515.5
  IN3 w0.102: v1(147.1,217.19) 147.1,216.63 147.74,215.98 148.8,215.98 149.42,216.6 150.47,216.6 151.64,215.43 v1(153.13,215.43)
  BOTTOM w0.114: R25641.1 150.91,210.78 R67862.2 151.99,211.31 151.71,211.59 R25640.1 152.06,211.82 152.25,211.63 153.44,211.63 v1(153.5,211.68) 153.5,212.89 153.61,213.01 153.61,214.94 v1(153.13,215.43)
ACCEL_INTA_SUB: length 2.8
  BOTTOM w0.114: TP13176.1 149.33,212.7 149.33,214.37 149.44,214.48 R25643.2
ACCEL_INTA_SUB_R: length 4.6
  TOP w0.079: U6516.B4 153.86,214.39 153.45,214.39 153.29,214.55 153.14,214.55
  TOP w0.114: v1(152.47,214.15) 152.88,214.55 153.14,214.55
  BOTTOM w0.114: R25643.1 R25642.1 151.83,214.63 151.99,214.63 v1(152.47,214.15)
ACIN: length 102.8
  TOP w0.114: v1(199.25,112.23) 199.7,111.78 199.7,110.98 v1(199.62,110.89) 199.16,110.44 199.16,106.65 199.82,106 199.82,104.61 198.59,103.38 198.59,98.57 195.87,95.84 175.13,95.84 173.86,97.12 173.52,97.12 173.36,97.28 173.36,99.69 172.95,100.1 168.99,100.1 168.83,99.94 U37.72 ; v1(162.82,116.46) 162.59,116.69 162.59,118.61 162.28,118.92 161.29,118.92 160.76,119.46 160.76,120.94 160.48,121.22 159.61,121.22 159.46,121.07 PR30.1
  TOP w0.203: PR39.2 156.38,120.17 156.8,120.59 156.8,120.89 157.71,121.81 PR40.1 158.08,121.81 158.5,121.39 158.5,121.2 158.63,121.07 PR30.1
  IN3 w0.102: v1(162.82,116.46) 163.25,116.03 163.89,116.03 164.16,115.76 171.31,115.76 172.78,114.29 177.6,114.29 178.25,114.94 186.1,114.94 186.38,114.66 190.48,114.66 194.78,110.36 197.38,110.36 v1(199.25,112.23)
ACZ_BCLK: length 10.6
  TOP w0.114: R187.2 v1(92.1,130.83) 92.26,130.83 92.57,131.14 94.51,131.14 95,131.63 95,132.4 95.75,133.15 v1(96.35,133.15)
  BOTTOM w0.079: U1.BN37 97.21,134 v1(96.35,133.15)
ACZ_RST#: length 19.1
  TOP w0.114: R194.2 84.76,133.4 85.06,133.69 C217.2 C214.2 86.65,133.69 86.95,133.4 v1(87.66,133.4) 88.3,132.76 93.18,132.76 93.97,133.54 v1(94.04,133.54)
  BOTTOM w0.079: U1.BL35 101.2,135.55 99.72,135.55 99.01,134.85 96.96,134.85
  BOTTOM w0.114: 96.96,134.85 96.76,134.85 95.38,133.47 94.12,133.47 v1(94.04,133.54)
ACZ_SDIN0: length 175.3
  TOP w0.114: v1(97.01,133.15) 97.01,133.36 96.63,133.75 95.71,133.75 95.37,133.41 94.56,133.41 94.23,133.08 93.85,133.08 93.16,132.39 87.11,132.39 86.34,133.16 85.04,133.16 84.76,132.89 82.33,132.89 82.09,133.13 80.24,133.13 79.55,132.44 75.6,132.44 71.49,128.33 71.49,127.5 v1(71.12,127.12) 70.77,126.77 70.77,109.94 68.28,107.46 68.28,103.51 66.01,101.24 59.95,101.24 59.02,100.31 57.66,100.31 56.02,98.67 54.54,98.67 54.11,98.24 54.11,93.63 v1(54.07,93.59)
  IN3 w0.102: v1(24.39,31.52) 24.58,31.71 24.58,33.22 25.13,33.77 27.14,33.77 27.8,33.11 30.77,33.11 31.36,33.71 31.36,38.98 28.6,41.74 28.6,45.24 29.24,45.88 29.24,55.06 26.96,57.33 26.96,62.01 29.24,64.29 29.24,84.24 30.43,85.43 31.5,85.43 34.81,88.74 34.81,89.11 35.04,89.34 35.04,89.65 37.89,92.5 52.98,92.5 v1(54.07,93.59)
  BOTTOM w0.079: U1.BN35 101.31,133.78 101.06,133.78 101.01,133.75 100.78,133.75 100.72,133.78 100.41,133.78 100.25,133.71 97.57,133.71 v1(97.01,133.15)
  BOTTOM w0.114: v1(24.39,31.52) 24.49,31.42 C215.2 25.14,31.76 24.77,32.13 R191.2
ACZ_SDOUT: length 23.3
  TOP w0.114: v1(94.24,131.76) 92.42,131.76 92.2,131.54 90.57,131.54 90.38,131.34 C213.2 89.62,131.87 86.67,131.87 86.36,131.57 83.81,131.57 C218.2 82.9,131.2 82.9,131.64 82.63,131.91 R117.1 81.57,131.91 81.23,131.56 R118.2 81.06,131.95 81.07,131.95 R25374.2
  BOTTOM w0.079: 95.01,132.52 95.17,132.52 96.9,134.26 100.35,134.26 100.78,134 U1.BN36
  BOTTOM w0.114: v1(94.24,131.76) 95.01,132.52
ACZ_SPKR: length 176.8
  IN2 w0.102: v1(24.46,23.68) 24.46,24.26 27.51,27.31 27.93,27.31 28.19,27.06 30.83,27.06 31.61,27.83 31.61,29.44 32,29.83 32,31.79 32.28,32.07 32.28,36.26 31.04,37.5 31.04,53.61 31.74,54.31 31.74,63.5 31.04,64.2 31.04,76.49 32.83,78.28 32.83,84.86 35.48,87.51 35.48,88.61 38.36,91.49 56.48,91.49 57.28,92.29 67.6,92.29 68.41,91.49 73.81,91.49 75.09,92.76 v1(76.48,92.76)
  IN4 w0.089: v1(90.5,117.76) 89.49,117.76 88.87,117.13 85.26,117.13 80.72,112.59 80.06,112.59 76.55,109.09 v1(74.2,109.09)
  BOTTOM w0.079: U1.CF35 101.37,126.28 100.96,126.2 100.78,126.2 100.72,126.22 100.42,126.22 100.31,126.18 99.34,126.18 99.2,126.04 98.21,126.04 97.46,125.29 96.57,125.29 96.48,125.19 95.69,125.19 R116.2 95.02,124.55
  BOTTOM w0.114: v1(90.5,117.76) 90.5,120.93 94.12,124.55 v1(94.24,124.55) 95.02,124.55 ; v1(76.48,92.76) 75.61,93.63 75.61,95.69 74.14,97.15 73.53,97.15 72.74,97.95 72.74,100.75 74.29,102.31 75.63,102.31 77.69,104.37 77.69,106.1 76.97,106.82 76.47,106.82 v1(74.2,109.09) ; D11.2 v1(24.46,23.68)
ACZ_SYNC: length 19.9
  TOP w0.114: R188.2 84.48,132.25 84.66,132.08 v1(84.66,132.03) 84.74,131.95 85.78,131.95 85.96,132.13 R186.2 91.89,132.13 92.02,132 93.61,132 v1(93.97,132.36)
  BOTTOM w0.079: U1.BN34 101.9,134.29 100.63,134.29 100.39,134.43 96.74,134.43 95.49,133.18 95.29,133.18
  BOTTOM w0.114: v1(93.97,132.36) 93.97,132.59 94.56,133.18 95.29,133.18
ADOGND: length 19.8
  TOP w0.381: R447.1 17.06,27.82 v1(16.8,28.08) ; C564.2 15.48,26.58 v1(15.95,26.58)
  TOP w0.508: v1(19.05,24.17) 18.43,24.78 C96268.2 ; C590.1 v1(7.76,14.75)
  BOTTOM w0.203: U20.38 17.81,36.04 17.58,36.28 v2(17.58,36.5) ; U20.25 16.51,29.99 v1(16.84,29.67)
  BOTTOM w0.254: C572.1 17.09,37.01 17.58,36.52 v2(17.58,36.5) ; R469.1 15.6,36.97 v1(15.49,37.07) 14.87,37.07 C845.2
  BOTTOM w0.381: C569.2 16.5,28.08 v1(16.8,28.08) ; C96267.2 8.11,29.08 v1(8.11,29.52) ; v1(14.41,25.14) 14.8,25.54 C599.2 ; R467.2 v1(12.31,33.51) ; C96265.2 v1(7.29,29.36) ; C598.1 13.2,32.12 13.34,32.26 v1(13.64,32.26) 13.86,32.04 C563.1 ; R463.2 13.35,38.06 v1(13.35,37.67) ; v1(8.85,29.54) 9.31,29.08 C593.1 ; C96266.2 C592.1 15.66,19.27 15.22,18.83 v1(14.89,18.83) ; C568.2 16.07,26.71 v1(15.95,26.58)
  vias: v1(4.76,28.33) v1(5.04,29.25) v1(7.17,25.63) v1(11.03,16.79) v1(12.75,22.9) v1(12.75,21.42) v1(12.75,20.44) v1(12.98,19.15) v1(13.25,17.91) v1(14.1,15.44) v1(16.07,17.29) v1(16.32,20.14) v1(17.3,21.13) v1(17.55,18.75) v1(19.74,22.35) v1(19.86,20.95) v1(21.18,22.25) v1(21.87,26.49) v1(22.05,25.01) v2(21.78,28.18)
ADP_DET: length 208.6
  TOP w0.114: v1(59.59,195.02) 59.59,193.7 59.71,193.58 v1(59.71,193.28) 58.9,192.47 PR8025.1 PR8026.2
  IN1 w0.089: v1(12.03,73.95) 12.03,75.06 16.61,79.64 16.61,83.46 16.08,83.98 16.08,88.45 16.08,90.56 16.16,90.63 16.16,97.96 18.23,100.04 18.23,112.17 15.29,115.11 15.29,115.8 13.82,117.27 13.82,120.47 14.43,121.08 14.43,122.53 13.44,123.52 13.44,127.82 14.43,128.8 14.43,133.42 14.33,133.51 14.33,135.09 14.81,135.57 16.34,135.57 v1(16.6,135.83)
  IN4 w0.089: v1(12.03,73.95) 12.51,73.47 12.51,70.54 13.29,69.76 14.51,69.76 15.67,68.6 15.67,67.27 16.24,66.71 16.24,64.7 16.94,64 16.94,55.84 18.39,54.38 18.39,46 19.15,45.23 22.76,45.23 v1(23.73,44.27) ; v1(16.6,135.83) 16.84,136.07 17.25,136.07 18.36,137.17 18.36,141.91 14.83,145.44 14.83,150.86 15.47,151.5 15.47,154.31 14.66,155.11 14.66,157.76 15.47,158.57 15.47,163.39 16.74,164.66 16.74,167.57 20.23,171.06 20.23,173.64 24.82,178.23 29.46,178.23 30.68,179.45 40.06,179.45 41.46,180.85 41.46,184.31 43.88,186.72 43.88,187.5 44.87,188.5 47.73,188.5 50.41,191.18 51.15,191.18 51.42,190.9 55.68,190.9 57.59,192.81 57.86,192.81 59.59,194.54 v1(59.59,195.02)
  BOTTOM w0.114: v1(23.73,44.27) 24.79,43.2 R67602.2 25.9,43.2 Q6548.1
ADP_EN: length 197.4
  TOP w0.114: PR8013.1 48.27,196.94 47.63,196.3 v1(47.63,195.96) 47.63,195.35 43.42,191.14 42.57,191.14 41.57,190.14 41.57,180.87 39.84,179.13 39.84,178.2 38.96,177.33 34.02,177.33 33.06,178.29 24.32,178.29 v1(24.2,178.18)
  IN1 w0.089: v1(15.96,136.01) 15.72,135.76 14.73,135.76 14.14,135.17 14.14,133.44 14.24,133.34 14.24,128.88 13.25,127.9 13.25,123.44 14.24,122.46 14.24,121.16 13.63,120.55 13.63,117.19 15.1,115.72 15.1,115.03 18.04,112.09 18.04,100.11 15.97,98.04 15.97,90.71 15.89,90.64 15.89,83.91 16.42,83.38 16.42,79.72 13.3,76.59 11.62,74.92 11.62,73.7 v1(12.03,73.29)
  IN4 w0.089: v1(14.71,43.1) 14.72,43.1 15.22,42.61 17.57,42.61 18.2,43.24 18.2,54.3 16.75,55.76 16.75,63.92 16.04,64.62 16.04,66.63 15.48,67.19 15.48,68.52 14.43,69.57 13.22,69.57 12.32,70.46 12.32,72.99 v1(12.03,73.29) ; v1(15.96,136.01) 16.22,136.26 17.18,136.26 18.17,137.25 18.17,141.83 14.64,145.36 14.64,150.94 15.28,151.58 15.28,154.23 14.47,155.03 14.47,157.84 15.28,158.64 15.28,163.47 16.55,164.74 16.55,167.65 20.04,171.14 20.04,173.71 23.65,177.33 23.65,177.38 24.2,177.93 v1(24.2,178.18)
  BOTTOM w0.114: v1(14.71,43.1) 14.39,42.78 R67600.2
ADP_ID: length 379.5
  TOP w0.114: PR9276.1 160.96,123.03 161.38,122.62 161.38,121.9 161.02,121.54 161.02,119.57 161.39,119.2 162.41,119.2 162.87,118.74 162.87,117.55 v1(163.25,117.17) 163.48,116.93 v1(163.48,116.46)
  IN3 w0.102: PJ8000.3 11.05,196.8 14.58,193.27 17.73,193.27 18.49,194.03 38.47,194.03 41.25,191.25 41.25,181.08 39.78,179.61 37.09,179.61 35.61,178.14 v1(35.61,175.61) ; v1(112.97,96.16) 114.21,97.41 119.52,97.41 120.61,98.5 122.2,98.5 123.78,100.08 130.35,100.08 130.85,100.59 139.73,100.59 140.04,100.28 141.13,100.28 142.3,99.11 150.14,99.11 153.6,95.65 165.55,95.65 166.37,96.47 169.11,96.47 169.69,95.88 171.92,95.88 172.55,96.52 174.76,96.52 175.39,95.88 194.19,95.88 195.84,97.53 201.37,97.53 202.87,99.03 202.87,100.23 203.74,101.09 203.74,102.56 205.79,104.61 205.79,107.47 206.68,108.36 206.68,108.86 205.88,109.66 204.94,109.66 200.38,114.22 199.48,114.22 197.91,112.64 193.78,112.64 191.08,115.35 186.66,115.35 186.38,115.63 176.49,115.63 175.95,115.08 172.31,115.08 171.4,115.99 164.26,115.99 163.99,116.26 163.69,116.26 v1(163.48,116.46)
  IN4 w0.089: v1(112.97,96.16) 112.13,95.33 101.97,95.33 100.56,96.73 98.19,96.73 97.99,96.54 92.87,96.54 92.36,96.03 79.6,96.03 78.81,96.82 77.1,96.82 76.15,95.87 74.92,95.87 73.93,96.87 71.87,96.87 71.09,96.08 68.52,96.08 67.44,95.01 58.26,95.01 57.04,96.22 54.69,96.22 49.4,101.51 43.05,101.51 42.42,100.88 39.29,100.88 37.59,102.58 37.59,113.17 33.66,117.1 33.66,121.09 34.35,121.77 34.35,124.05 33.16,125.24 33.16,126.91 33.63,127.37 33.63,134.32 33.52,134.43 33.52,135.17 31.95,136.74 31.95,141.74 32.87,142.67 32.87,160.56 34.85,162.54 34.85,165 36.63,166.78 36.63,168.12 36.25,168.5 36.25,174.97 v1(35.61,175.61)
ADP_IN_CCG4: length 3.7
  BOTTOM w0.114: Q6548.3 26.35,45.54 R67478.1 26.35,46.2 25.81,46.73 25.81,47.19 25.45,47.55 U6511.19
ADP_IN_EC: length 212.8
  TOP w0.114: v1(179.68,96.9) 180.6,96.9 v1(180.62,96.92) 181.59,96.92 181.9,97.24 182.55,97.24 183.39,98.08 183.39,99.29 183.29,99.39 R67886.2
  IN2 w0.102: v1(24.39,44.27) 25.4,43.25 27.65,43.25 30.02,45.62 30.02,53.88 30.83,54.69 30.83,63.12 30.02,63.93 30.02,76.76 31.91,78.66 31.91,85.24 34.56,87.89 34.56,88.99 37.98,92.4 56.1,92.4 56.9,93.2 68.23,93.2 69.32,94.29 73.95,94.29 74.19,94.06 75.09,94.06 75.57,94.54 78.11,94.54 78.87,95.3 92.31,95.3 92.94,95.93 98.38,95.93 98.91,96.47 100.67,96.47 100.77,96.36 103.81,96.36 104.9,97.45 117.78,97.45 118.13,97.1 120.69,97.1 122.53,98.94 133.66,98.94 134.32,98.28 138.95,98.28 140.06,97.18 150.32,97.18 150.5,97 152.73,97 154,95.73 165.38,95.73 165.99,96.34 168.94,96.34 169.47,95.81 170.67,95.81 171.17,96.31 176.39,96.31 176.56,96.15 178.92,96.15 v1(179.68,96.9)
  BOTTOM w0.114: v1(24.39,44.27) 24.67,43.98 R67602.1
ADP_IN_EN_CCG4: length 5.9
  BOTTOM w0.114: U6511.27 21.02,45.45 21.44,45.03 21.44,43.15 v1(21.8,42.8) 22.3,42.8 22.41,42.9 23.18,42.9 Q6566.1
ADP_IN_EN_EC: length 276.3
  TOP w0.114: v1(168.51,106.09) 168.35,105.94 U37.87 ; v1(193.62,96.68) 193.92,96.38 195.34,96.38 198.06,99.1 v1(198.06,103.94) 198.06,104.07 198.35,104.36 v1(198.35,104.61)
  IN1 w0.089: v1(168.51,106.09) 168.95,106.53 169.34,106.53 169.49,106.69 169.89,106.69 170.2,107.01 172.58,107.01 175.41,109.84 178.79,109.84 182.78,105.85 188.51,105.85 188.63,105.97 189.47,105.97 189.65,105.79 190,105.79 191.99,103.8 197.54,103.8 v1(198.35,104.61)
  IN2 w0.102: v1(193.62,96.68) 193.08,96.13 183.52,96.13 182.63,97.02 182.22,97.02 179.81,94.61 153.34,94.61 152.63,95.32 152.05,95.32 151.57,94.84 144.46,94.84 144.12,95.19 144.12,95.58 143.85,95.84 138.41,95.84 137.83,96.43 121.85,96.43 120.52,95.09 98.71,95.09 98.1,95.7 93.04,95.7 92.4,95.07 78.97,95.07 78.21,94.31 75.67,94.31 75.19,93.83 74.09,93.83 73.86,94.07 69.42,94.07 68.33,92.98 57,92.98 56.19,92.17 38.07,92.17 34.79,88.89 34.79,87.8 32.14,85.15 32.14,78.56 30.24,76.67 30.24,64.03 31.05,63.22 31.05,54.59 30.24,53.78 30.24,45.33 27.79,42.88 22.62,42.88 22.28,42.55 16.12,42.55 v1(15.45,43.22)
  BOTTOM w0.114: R67601.2 15.66,43.01 v1(15.45,43.22)
ALERT: length 16.5
  TOP w0.102: v2(125.11,186.93) 124.75,186.57 124.75,184.71 123.79,183.74 123.14,183.74
  TOP w0.114: 123.14,183.74 122.61,183.74 120.25,181.39 116.54,181.39 116.39,181.53 v1(115.55,181.53) 115.55,181.28 115.06,180.79 113.21,180.79 R397.1
  BOTTOM w0.102: U8.F8 v2(125.11,186.93)
AMP_MUTE#: length 259
  TOP w0.114: U37.108 160.96,109.8 160.81,109.65 160.81,108.05 161.42,107.44 163.94,107.44 164.82,108.33 164.82,108.53 166.32,110.03 168.08,110.03 169.1,111.05 170.89,111.05 171.28,110.66 171.28,109.95 v1(171.73,109.49) 171.73,104.28 175.16,100.85 176.01,100.85 176.92,99.95 176.92,97.85 178.39,96.38 182.24,96.38 v1(182.45,96.59)
  IN2 w0.102: v1(27.78,26.76) 30.92,26.76 31.83,27.68 31.83,29.35 32.22,29.74 32.22,31.69 32.5,31.98 32.5,36.36 31.27,37.59 31.27,53.52 31.97,54.21 31.97,63.6 31.27,64.3 31.27,76.4 33.06,78.19 33.06,84.77 35.71,87.42 35.71,88.51 38.41,91.21 73.91,91.21 74.53,91.83 77.18,91.83 77.64,92.29 77.64,92.77 79.25,94.38 92.69,94.38 93.32,95.02 97.82,95.02 98.43,94.41 120.81,94.41 122.14,95.74 137.55,95.74 138.27,95.02 142.2,95.02 142.83,94.38 180.24,94.38 v1(182.45,96.59)
  BOTTOM w0.114: D13.1 28.28,26.76 v1(27.78,26.76)
BAT-V: length 33.9
  TOP w0.114: PR208.2 138.74,112.23 138.69,112.27 138.69,114.06 138.56,114.2 PR209.2
  TOP w0.381: PD9002.1 155.52,123.6 155.02,123.11 v1(155.02,122.71)
  IN2 w0.381: v1(148.03,112.58) 150.51,112.58 151.86,113.93 152.11,113.93 154.83,116.65 156.06,116.65 156.73,117.31 156.73,117.95 156.43,118.26 156.43,120.97 155.02,122.37 v1(155.02,122.71)
  IN3 w0.381: v1(148.03,112.58) 147.12,111.67 139.53,111.67 136.99,114.21 v3(136.99,114.86)
  vias: v1(101.68,101.83) v1(101.68,101.16) v1(102.34,101.83) v1(102.34,101.16) v1(103,101.83) v1(103,101.16) v1(103.66,101.83) v1(103.66,101.16) v1(105.34,96.44) v3(136.23,115.63) v3(136.23,114.86) v3(136.99,115.63)
BATLED0#: length 112.3
  TOP w0.114: v1(153.58,99.14) 153.58,98.76 153.16,98.34 U37.29 150.14,98.34 149.79,97.99 149.79,96.85 149.48,96.54 R67487.1 ; v1(204.67,109.17) v1(204.67,108.42)
  IN1 w0.089: v1(204.67,108.42) 204.67,108.11 205.24,107.54 213.85,107.54 214.64,108.33 218.67,108.33 224.67,114.32 224.67,117.75 225.39,118.48 225.45,118.48 225.71,118.74 225.71,119.11 v1(225.28,119.54)
  IN3 w0.102: v1(153.58,99.14) 155.36,97.35 160.25,97.35 161.03,96.57 165.17,96.57 165.99,97.38 169.1,97.38 169.98,98.26 175.74,98.26 176.16,98.68 179.19,98.68 179.35,98.83 193.44,98.83 193.83,98.45 196.35,98.45 197.02,99.12 199.9,99.12 200.15,98.87 200.87,98.87 201.15,99.14 201.15,100.01 v1(201.38,100.24) 201.38,101.61 201.26,101.73 201.26,103.11 201.83,103.68 203.06,103.68 203.92,104.55 203.92,105.96 204.67,106.7 v1(204.67,108.42)
  BOTTOM w0.114: CN55.12 227.37,119.46 227.3,119.4 225.42,119.4 v1(225.28,119.54) ; CN52.14 203.85,100.19 203.69,100.03 201.89,100.03 201.69,100.24 v1(201.38,100.24) ; v1(204.67,108.42) 204.2,107.95 203.51,107.95 202.95,108.5 202.95,109.26 201.45,110.77 CN48.22
BATLED1#: length 109.5
  TOP w0.114: R67485.1 149.46,99.59 149.81,99.94 U37.25 152.7,99.94 153.48,100.72 v1(153.48,100.81) ; v1(205.18,107.77) 205.18,108.27 v1(205.34,108.42)
  IN1 w0.089: v1(205.34,108.42) 205.34,108.23 205.84,107.73 213.77,107.73 214.57,108.52 218.6,108.52 224.48,114.4 224.48,118.07 v1(225.28,118.88)
  IN3 w0.102: v1(205.34,108.42) 205.34,107.99 205.11,107.75 205.11,104.89 203.52,103.3 203.2,103.3 v1(202.84,102.94) 202.42,102.52 202.42,100.74 202.19,100.51 202.19,100.02 201.58,99.41 201.58,99.05 200.75,98.22 193.74,98.22 193.35,98.61 179.45,98.61 179.29,98.45 176.25,98.45 175.84,98.03 170.08,98.03 169.19,97.15 166.08,97.15 165.27,96.34 160.94,96.34 160.15,97.13 154.91,97.13 153.09,98.95 153.09,100.42 v1(153.48,100.81)
  BOTTOM w0.114: v1(225.28,118.88) 225.38,118.96 CN55.13 ; v1(202.84,102.94) 203.35,102.43 CN52.15 ; v1(205.34,108.42) 205.6,108.15 206.18,108.15 208.95,110.93 CN48.7
BI: length 154.4
  IN1 w0.089: v1(22.5,121.62) 22.5,121.17 23.71,119.96 23.71,119.38 24.27,118.82 27.92,118.82 29.25,120.15 34.97,120.15 35.79,119.33 36.89,119.33 38.34,120.78 v1(43.31,120.78)
  IN4 w0.089: v1(18.08,150.53) 18.08,150.27 20.28,148.06 20.28,144.86 21.13,144.01 21.13,140.55 23.36,138.31 23.36,132.67 21.96,131.27 21.96,129.05 21.51,128.6 21.51,122.61 v1(22.5,121.62) ; v1(43.31,120.78) 43.75,120.34 43.75,116.18 42.88,115.32 42.88,109.19 45.02,107.05 45.02,105.01 46.02,104.01 46.48,104.01 48.04,102.45 49.54,102.45 52.06,99.93 53.05,99.93 53.42,100.31 53.42,101.45 54.23,102.26 63.61,102.26 64.87,103.52 65.79,103.52 66.56,104.29 79.76,104.29 80.17,104.71 82.27,104.71 84.01,106.45 92.86,106.45 94.12,105.18 102.2,105.18 v1(102.61,104.77)
  BOTTOM w0.114: R25321.1 11.59,155.27 11.89,154.97 14.24,154.97 SW2.2 SW2.1 16.67,150.15 v1(16.67,148.18) 17.4,148.92 17.4,149.86 v1(18.08,150.53) ; v1(102.61,104.77) 102.61,105.15 PR10.1 103.11,104.98 103.11,104.59 103.62,104.08 PJ1.6
BIOS_WP#: length 16.9
  BOTTOM w0.114: R110.2 120.87,99.29 R112.1 122.88,99.73 TP18.1 127.1,103.96 130.03,103.96 131.04,104.97 131.04,106.58 130.79,106.83 CN59.3 U6528.3 CN60.3 U6526.3
BL#: length 3
  BOTTOM w0.114: R25368.1 87.55,189.36 87.4,189.22 Q6521.2 86.3,189.22 86.15,189.06 86.15,188.7 86.29,188.57 Q6521.3
BL_ON: length 23.3
  IN3 w0.102: v1(68.65,191.95) 69.6,191 77.72,191 78.59,190.14 80.54,190.14 v1(80.56,190.12)
  BOTTOM w0.114: v1(80.56,190.12) 80.56,190.21 Q6522.3 81.21,191.81 80.88,192.14 R25367.1 81.32,192.81 D3.2 83.99,192.47 85.26,191.21 v1(85.44,191.21) 85.44,190.05 85.25,189.87 Q6521.6 ; CN29.26 v1(68.65,191.95)
BOARD_ID0: length 13
  BOTTOM w0.079: 95.02,121.88 95.54,122.39 97.21,122.39 98.32,123.5 98.32,123.81 99.34,124.83 100.22,124.83 100.58,125.01 100.75,125.01 U1.CH36
  BOTTOM w0.114: R25395.1 R25392.2 92.39,119.69 92.39,120.38 v1(93.89,121.88) 95.02,121.88
BOARD_ID1: length 18.6
  BOTTOM w0.079: 96.3,119.93 96.3,120.04 96.32,120.06 96.32,120.72 96.88,121.28 97.36,121.28 98.98,122.9 99.19,122.9 99.88,123.59 100.37,123.59 100.54,123.69 100.75,123.69 100.92,123.53 101.47,123.53 U1.CL35
  BOTTOM w0.114: R25396.1 93.61,111.27 93.12,111.76 93.12,112.07 92.69,112.5 v1(92.69,112.57) 92.61,112.65 92.61,116.25 94.18,117.82 94.33,117.82 95.35,118.84 95.49,118.84 R73.2 95.86,119.16 96.3,119.61 96.3,119.93
BOARD_ID2: length 19.1
  BOTTOM w0.079: 96.57,119.93 96.57,120.17 96.57,120.17 96.57,120.52 97.08,121.03 97.41,121.03 98.88,122.5 99.18,122.5 100.02,123.34 100.54,123.34 U1.CL36
  BOTTOM w0.114: R25397.1 94.06,110.02 94.06,111.2 93.39,111.87 93.39,112.18 93.17,112.39 93.17,112.75 92.92,113 92.92,115.87 v1(93.09,116.05) 93.49,116.44 93.49,116.75 94.29,117.55 94.44,117.55 95.46,118.58 96.54,118.58 R25393.2 96.7,119.39 96.69,119.39 96.57,119.52 96.57,119.93
BOARD_ID3: length 20.4
  TOP w0.114: R25399.1 86.68,112.8 87.57,112.8 R25394.2 89.27,113.48 v1(90.17,113.48) 90.5,113.81 90.5,113.89 92.51,115.9 92.51,116.43 96.3,120.22 97.04,120.22 v2(97.29,120.47)
  BOTTOM w0.079: 99.87,122.86 99.87,122.93 100.12,123.17 100.4,123.17 100.59,122.99 U1.CM35
  BOTTOM w0.102: v2(97.29,120.47) 97.33,120.67 97.33,120.67 98.96,122.3 99.31,122.3 99.87,122.86
BOARD_ID4: length 112.7
  TOP w0.079: v2(101.63,123.01) 100.98,122.36
  TOP w0.114: 100.98,122.36 100.35,121.73 98.57,121.73 97.81,120.98 97.18,120.98 96.64,120.44 96.21,120.44 92.29,116.52 92.29,116.15 90.31,114.17 89.15,114.17 v1(88.93,113.94) 88.8,113.81 88.32,113.81 R59.2 87.74,113.23 87.74,113.22 87.62,113.1 86.97,113.1 86.96,113.1 86.63,113.1 R25398.1 86.16,113.56 85.65,114.07 81.63,114.07 v1(81.39,113.83) ; R25521.1 C20001.2 65.43,186.72 v1(64.88,187.28)
  IN4 w0.089: v1(74.53,177.32) 74.53,177.99 73.51,179.01 71.85,179.01 70.93,179.92 70.93,185.14 70.2,185.87 69.42,185.87 69.22,186.08 69.22,186.89 68.18,187.93 66.38,187.93 65.73,187.28 v1(64.88,187.28)
  BOTTOM w0.079: v2(101.63,123.01) 101.51,122.9 U1.CN35
  BOTTOM w0.114: v1(74.53,177.32) 78.28,173.57 78.28,121.39 79.06,120.61 79.06,116.16 v1(81.39,113.83)
BOARD_ID5: length 11.4
  BOTTOM w0.079: U1.CH35 101.22,124.83 100.6,124.83 100.26,124.66 99.41,124.66 98.49,123.74 98.49,123.43 97.28,122.23 95.94,122.23 v1(95.69,121.97) 95.3,121.59 95.02,121.59
  BOTTOM w0.114: R25390.1 R25391.2 94.36,120.56 94.36,121.36 94.58,121.59 95.02,121.59
BOARD_ID6: length 141.9
  TOP w0.114: v1(67.31,187.45) 67.31,186.9 C20002.2 67.87,187.1 67.87,187.88 R25522.1 ; v2(97.21,121.66) 97.21,121.3 96.55,120.65 95.79,120.65 91.84,116.7 91.84,116.11 90.16,114.43 88.12,114.43 R25386.2 R25388.1 85.51,115.85 82.25,115.85 82.04,116.06 v1(81,116.06) 79.74,114.81 v1(79.74,112.91)
  IN4 w0.089: v1(74.04,177.8) 74.04,178.06 73.29,178.81 71.77,178.81 70.74,179.85 70.74,181.75 68.31,184.18 68.31,185.36 69.03,186.07 69.03,186.81 68.39,187.45 v1(67.31,187.45) ; v2(97.21,121.66) 97.21,121.36 98.86,119.71 100.02,119.71 101.8,121.49 103.79,121.49 104.04,121.24 105.42,121.24 107.87,118.79 107.87,117.58 108.68,116.77 v2(108.68,113.65)
  BOTTOM w0.079: 98.91,123.16 98.91,123.16 99.21,123.16 99.81,123.76 100.32,123.76 100.65,123.96 U1.CK36 ; 109.51,117.9 109.51,118.37 109.78,118.64 109.78,119.7 109.89,119.8 109.89,120.75 109.68,120.96 U1.CR22 109.45,121.33 109.45,121.59 109.42,121.64 109.42,121.87 109.45,121.98 109.45,122.26 U1.CN22
  BOTTOM w0.102: 98.91,123.16 98.7,123.16 v2(97.21,121.66)
  BOTTOM w0.114: v2(108.68,113.65) 109.25,114.22 109.25,116.68 109.51,116.95 109.51,117.9 ; v1(79.74,112.91) 78.8,113.86 78.8,120.5 78.01,121.28 78.01,173.44 74.62,176.83 74.33,176.83 74.04,177.11 v1(74.04,177.8)
BOARD_ID7: length 9.6
  BOTTOM w0.079: 95.1,121 95.51,121.41 95.71,121.41 96.36,122.06 97.35,122.06 98.66,123.36 98.66,123.67 99.11,124.12 99.31,124.12 99.62,124.43 100.3,124.43 100.48,124.26 101.17,124.26 101.33,124.09 U1.CK34
  BOTTOM w0.114: R25389.1 94.85,120.74 R25387.2 95.03,120.94 95.1,121
BOARD_ID10: length 18.7
  BOTTOM w0.079: 110.05,117.94 110.05,118.28 110.12,118.35 110.12,119.56 110.22,119.66 110.22,120.89 110.1,121.01 110.1,121.25 110.03,121.41 110.03,121.8 109.97,121.86 109.97,122.67 U1.CM22
  BOTTOM w0.114: R25383.1 117.18,111.42 114.34,111.42 v1(114.33,111.43) 114.32,111.42 112.5,111.42 R25380.2 111.61,112.31 111.07,112.31 110.46,112.91 110.1,112.91 109.68,113.34 109.68,116.5 110.05,116.87 110.05,117.94
BOARD_ID11: length 13.2
  BOTTOM w0.079: 109.78,117.9 109.78,118.3 109.95,118.47 109.95,119.63 110.05,119.73 110.05,120.82 109.93,120.94 109.93,121.22 109.87,121.37 109.87,121.57 U1.CP22
  BOTTOM w0.114: R25384.1 107.78,112.26 v1(108.49,112.26) 109.19,112.26 109.44,112.52 109.7,112.52 109.85,112.36 R25385.2 110.23,112.41 109.47,113.17 109.47,116.59 109.78,116.91 109.78,117.9
BRIGHT: length 3
  BOTTOM w0.114: R439.2 R443.2 65.12,188.1 65.25,188.1 R441.1 65.99,187.68 v1(65.56,187.25)
BT_EN: length 57.4
  TOP w0.114: v1(169.83,106.09) 169.95,105.97 v1(169.95,105.43) 169.42,104.9 R960.2
  IN1 w0.089: v1(204.55,105.22) 203.23,103.9 199.56,103.9 199.08,103.42 190.52,103.42 190.19,103.08 184.46,103.08 184.1,103.44 173.9,103.44 170.86,106.49 170.23,106.49 v1(169.83,106.09)
  BOTTOM w0.114: CN17.54 192.56,110.4 193.93,111.78 R671.1 194.01,112.01 194.14,112.14 194.71,112.14 194.78,112.21 195.64,112.21 196.2,111.64 196.2,110.15 197.62,108.74 197.99,108.74 201.2,105.53 201.2,104.95 201.47,104.68 204.01,104.68 v1(204.55,105.22)
BXTALOUT: length 10.1
  BOTTOM w0.102: 123.65,179.38 123.66,179.39 124.25,179.39 125.2,180.34 125.88,180.34 126.64,181.1 126.64,182.11 126.77,182.24 126.77,183.3 127.2,183.73 U8.C10
  BOTTOM w0.114: 123.65,179.38 R332.1 122.55,178.28 122.55,177.46 123.12,176.89 R330.1
C_IN_CLK: length 15.1
  TOP w0.089: R67397.2 18.69,128.37 18.58,128.48 16.85,128.48 16.59,128.23 16.45,128.23 R489.1 15.9,128.19 15.7,128.19 D13088.2 15.27,128.03 15.16,128.14 14.54,128.14 14.4,128.28 14,128.28 13.77,128.05 13.77,127.44 14.1,127.11 15.5,127.11 15.74,126.87 15.74,126.29 15.5,126.04 13.21,126.04 12.72,126.53 12.72,127.73 12.59,127.87 12.49,127.87 CN37.10
C_IN_CLK#: length 15
  TOP w0.089: R67377.2 18.68,128.85 18.58,128.75 16.74,128.75 16.48,128.5 16.37,128.5 R489.2 15.89,128.45 15.66,128.45 D13087.2 15.27,128.51 15.16,128.4 14.65,128.4 14.51,128.55 13.89,128.55 13.5,128.16 13.5,127.33 13.99,126.85 15.39,126.85 15.48,126.76 15.48,126.4 15.39,126.31 13.32,126.31 12.99,126.64 12.99,127.84 12.7,128.14 12.44,128.14 CN37.12
C_IN_CLK#_R: length 15.1
  TOP w0.102: C96259.2 21.51,134.4 21.51,134.85 21.43,134.92 v1(21.2,134.92) ; U23.31 26.09,142.88 26.24,143.03 26.41,143.03 v1(26.68,142.76)
  IN1 w0.102: v1(21.2,134.92) 21.4,134.92 21.55,135.07 21.55,135.49 21.93,135.88 21.93,136.6 23.87,138.53 24.59,138.53 27.74,141.69 27.74,142.65 27.37,143.02 26.94,143.02 v1(26.68,142.76)
C_IN_CLK_R: length 15.1
  TOP w0.102: C96260.2 21.71,134.35 21.71,134.67 v1(21.96,134.92) ; U23.32 26.12,143.38 26.27,143.23 26.39,143.23 v1(26.68,143.52)
  IN1 w0.102: v1(21.96,134.92) 21.75,135.13 21.75,135.41 22.14,135.79 22.14,136.51 23.95,138.33 24.67,138.33 27.95,141.6 27.95,142.73 27.45,143.23 26.98,143.23 v1(26.68,143.52)
C_TX0_HDMI+: length 15.9
  TOP w0.089: v1(16.36,126.33) 16.61,126.57 18.57,126.57 18.68,126.46 R67391.2
  BOTTOM w0.089: v1(16.36,126.33) 16.12,126.57 15.96,126.57 R487.1 15.41,126.59 15.22,126.59 D13082.2 14.8,126.44 14.67,126.56 14.12,126.56 13.07,125.51 13.07,123.22 12.45,122.6 11.73,122.6 11.21,123.12 11.21,126.18 11.05,126.34 10.91,126.34 CN37.7
C_TX0_HDMI+_R: length 12.5
  TOP w0.102: U23.26 26.11,140.38 26.26,140.23 26.72,140.23 27.41,139.53 27.41,138.25 27.9,137.76 v1(28.65,137.76) 28.35,137.46 28.35,137.31 28.6,137.06 28.6,136.42 27.2,135.02 24.57,135.02 24.27,134.72 24.27,134.2 C96254.2
C_TX0_HDMI-: length 15.9
  TOP w0.089: R67390.2 18.69,126.97 18.57,126.84 16.61,126.84 v1(16.36,127.09)
  BOTTOM w0.089: CN37.9 10.92,126.61 11.16,126.61 11.47,126.29 11.47,123.23 11.84,122.87 12.34,122.87 12.8,123.33 12.8,125.62 14.01,126.83 14.69,126.83 14.79,126.94 D13081.2 15.15,126.86 15.47,126.86 R487.2 15.95,126.84 16.11,126.84 v1(16.36,127.09)
C_TX0_HDMI-_R: length 12.5
  TOP w0.102: C853.2 23.57,133.78 24.07,134.28 24.07,134.81 24.49,135.22 27.11,135.22 28.4,136.51 28.4,136.98 28.2,137.17 28.06,137.17 v1(27.76,136.86) 27.76,137.62 27.21,138.17 27.21,139.45 26.63,140.03 26.25,140.03 26.1,139.88 U23.25
C_TX1_HDMI+: length 15.4
  TOP w0.089: R67381.2 18.68,124.54 18.52,124.7 16.75,124.7 16.53,124.92 16.43,124.92 R486.1 15.93,124.89 15.6,124.89 D13084.2 15.19,124.78 15.1,124.87 13.91,124.87 13.75,124.72 13.75,124.15 13.98,123.92 15.72,123.92 15.98,123.66 15.98,123.08 15.69,122.79 13.56,122.79 12.75,123.6 12.75,124.75 12.62,124.87 12.49,124.87 CN37.4
C_TX1_HDMI+_R: length 13.3
  TOP w0.102: C96256.2 26.69,134.2 26.69,134.33 26.75,134.4 27.47,134.4 29.29,136.22 29.29,136.79 29.51,137.01 30.08,137.01 30.35,137.28 30.35,138.27 30.13,138.49 29.7,138.49 28.86,139.33 v1(28.86,140.08) 28.11,140.08 26.96,141.23 26.24,141.23 26.09,141.38 U23.28
C_TX1_HDMI-: length 15.5
  TOP w0.089: CN37.6 12.44,125.14 12.73,125.14 13.01,124.86 13.01,123.71 13.67,123.06 15.58,123.06 15.71,123.19 15.71,123.55 15.61,123.65 13.86,123.65 13.48,124.04 13.48,124.83 13.8,125.14 15.12,125.14 15.19,125.21 D13083.2 15.58,125.16 15.88,125.16 R486.2 16.41,125.19 16.64,125.19 16.86,124.97 18.54,124.97 18.69,125.12 R67392.2
C_TX1_HDMI-_R: length 13.3
  TOP w0.102: U23.27 26.09,140.88 26.24,141.03 26.87,141.03 27.96,139.93 v1(27.96,139.18) 28.72,139.18 29.62,138.29 30.05,138.29 30.15,138.18 30.15,137.37 29.99,137.21 29.43,137.21 29.09,136.87 29.09,136.31 27.38,134.6 26.67,134.6 26.48,134.42 26.48,134.23 26.03,133.78 C96255.2
C_TX2_HDMI+: length 13
  TOP w0.089: CN37.1 10.92,123.35 11.03,123.35 11.21,123.17 11.21,122.21 11.63,121.79 12.79,121.79 13.32,121.25 14.63,121.25 14.75,121.13 D13086.2 15.15,121.26 15.42,121.26 R484.1 15.89,121.22 16.11,121.22 16.33,120.99 16.79,120.99 17.06,121.27 17.06,121.89 16.63,122.33 16.63,122.62 16.86,122.85 18.62,122.85 18.68,122.79 R67383.2
C_TX2_HDMI+_R: length 14.7
  TOP w0.102: U23.30 26.09,142.38 26.24,142.23 26.73,142.23 27.07,141.89 27.88,141.89 28.09,141.67 29.33,141.67 v1(29.86,142.21) 30.39,141.67 30.72,141.67 31.11,141.28 31.11,136.8 29.2,134.89 29.2,134.1 C96258.2
C_TX2_HDMI-: length 13
  TOP w0.089: CN37.3 10.92,123.61 11.14,123.61 11.48,123.28 11.48,122.32 11.74,122.06 12.9,122.06 13.43,121.52 14.57,121.52 14.75,121.71 D13085.2 15.15,121.52 15.41,121.52 R484.2 15.97,121.49 16.22,121.49 16.44,121.26 16.68,121.26 16.8,121.38 16.8,121.78 16.36,122.22 16.36,122.73 16.75,123.12 18.54,123.12 18.68,123.26 R67384.2
C_TX2_HDMI-_R: length 14.7
  TOP w0.102: C96257.2 28.3,133.78 29,134.47 29,134.97 30.91,136.89 30.91,141.19 30.63,141.47 30.39,141.47 v1(29.86,140.94) 29.33,141.47 28.01,141.47 27.8,141.68 26.99,141.68 26.65,142.03 26.26,142.03 26.11,141.88 U23.29
CATERR#: length 5.2
  BOTTOM w0.079: R10.2 125.58,153.72 125.28,153.42 122.72,153.42 122.68,153.43 122.51,153.48 122.5,153.48 122.28,153.4 122.15,153.4 122.01,153.43 121.88,153.5 121.33,153.59 U1.AA4
CCG1_I2C_INT_D: length 10.4
  BOTTOM w0.114: U6511.15 25.4,49.55 25.57,49.72 27.35,49.72 R67880.2 R25574.2 28.47,49.65 29.14,50.31 Q19.3 31.28,48.3 v1(31.63,47.95)
CCG4_SWD_CLK: length 5.7
  BOTTOM w0.114: U6511.2 20.02,52.98 19.36,53.64 19.36,55.13 TP84.1 18.48,55.02 R67867.1 18,54.7 18.21,54.48 R25580.2
CCG4_SWD_IO: length 3
  BOTTOM w0.114: R135.2 18.21,53.49 TP9062.1 19.05,53.97 19.05,53.57 19.52,53.1 U6511.1
CCG4_VBUS_C_CTRL: length 59.7
  TOP w0.114: PR8014.1 32.1,97.42 26.74,97.42 v1(26.27,96.95) 25.61,96.95 v1(25.61,96.95)
  IN2 w0.102: v1(25.38,53.14) 25.99,53.14 27.05,54.2 27.05,58.07 26.91,58.22 26.91,62.84 28.93,64.86 28.93,71.69 26.99,73.62 26.99,74.49 28.7,76.19 28.7,85.4 25.16,88.94 25.16,93.41 26.29,94.54 26.29,96.27 v1(25.61,96.95)
  BOTTOM w0.114: U6511.12 25.61,51.05 25.88,51.31 25.88,52.64 v1(25.38,53.14)
CCG4_XRES: length 4.9
  BOTTOM w0.114: R197.1 26.85,53.48 26.85,53.39 26.72,53.26 C20091.2 26.15,53.26 TP9061.1 25.36,53.91 24.82,53.37 24.51,53.37 24.02,52.88 U6511.10
CCG_I2C_INT#: length 184
  TOP w0.114: U37.125 154.16,109.94 155.13,108.96 155.13,108.42 154.93,108.21 154.43,108.21 153.95,108.7 153.95,108.98 152.74,110.19 149.5,110.19 R67604.1 148.98,110.71 145.75,110.71 144.17,109.14 142.68,109.14 141.63,108.09 140.31,108.09 137.25,105.03 137.25,100.06 v1(137.24,100.05) 137.24,99.3 v1(137.3,99.23)
  IN2 w0.102: v1(137.3,99.23) 136.78,99.23 136.28,98.74 134.51,98.74 133.85,99.39 122.34,99.39 120.51,97.56 118.32,97.56 117.97,97.91 104.71,97.91 103.62,96.82 100.96,96.82 100.86,96.92 98.72,96.92 98.19,96.39 92.76,96.39 92.12,95.75 78.68,95.75 77.92,95 75.38,95 74.9,94.52 74.38,94.52 74.14,94.75 69.13,94.75 68.04,93.66 56.71,93.66 55.91,92.86 37.79,92.86 34.11,89.18 34.11,88.08 31.28,85.25 30.35,85.25 29.38,84.28 29.38,64.67 27.36,62.65 27.36,58.41 27.51,58.26 27.51,54.01 26.89,53.39 26.89,52.15 v1(27.38,51.66)
  BOTTOM w0.114: R67880.1 Q19.1 29.28,51.57 28.88,51.97 27.87,51.97 27.57,51.66 v1(27.38,51.66)
CCG_I2C_SCL: length 182.4
  TOP w0.114: R67448.2 145.29,109.78 144.47,108.96 144.47,108.33 143.73,107.59 140.51,107.59 137.74,104.83 137.74,99.9 137.8,99.84 137.8,97.63 v1(139.07,96.36) 139.07,95.69 140.04,94.73 v1(140.04,94.59)
  IN3 w0.102: v1(140.04,94.59) 139.58,95.04 138.56,95.04 137.93,95.68 120.6,95.68 119.3,94.38 98.46,94.38 97.82,95.02 93.49,95.02 92.86,94.38 79.25,94.38 77.59,92.72 77.59,92.06 76.73,91.2 76.73,90.84 76.34,90.45 38.36,90.45 36.82,88.91 36.82,88.6 36.59,88.37 36.59,88 35.61,87.02 35.61,80.24 32.19,76.82 32.19,47.26 32.79,46.66 33.58,46.66 33.71,46.53 33.71,46.07 31.89,44.25 30.74,44.25 v1(30.04,43.55)
  BOTTOM w0.114: v1(30.04,43.55) 29.99,43.6 R67878.1 30.12,44.65 30.12,45.45 29.96,45.6 Q6535.1
CCG_I2C_SCL_D: length 12.7
  BOTTOM w0.114: U6511.17 25.78,48.55 26.52,47.81 R25576.2 27.35,47.81 28.27,46.89 28.27,45.93 29.26,44.93 29.26,43.38 v1(29.67,42.97) 30.21,42.97 30.51,43.28 30.51,43.74 30.77,44 R67878.2 30.77,44.74 30.49,45.03 30.49,45.38 30.7,45.6 Q6535.6
CCG_I2C_SDA: length 176.8
  TOP w0.114: v1(140.7,94.59) 140.7,95.24 v1(140.67,95.27) 140.67,95.7 138.17,98.2 138.17,99.99 138.11,100.05 138.11,104.67 140.66,107.22 144.1,107.22 R67447.2
  IN3 w0.102: v1(33.23,46.22) 33.2,46.25 32.69,46.25 31.84,47.1 31.84,76.97 35.25,80.38 35.25,87.17 36.23,88.15 36.23,88.52 36.46,88.75 36.46,89.06 38.21,90.81 76.19,90.81 76.38,90.99 76.38,91.35 77.23,92.2 77.23,92.86 79.1,94.74 92.71,94.74 93.35,95.37 97.97,95.37 98.6,94.74 119.15,94.74 120.45,96.04 138.07,96.04 138.71,95.4 139.88,95.4 v1(140.7,94.59)
  BOTTOM w0.114: v1(33.23,46.22) 32.54,46.22 31.87,46.9 Q6535.4 30.75,46.9 30.64,47.01 30.64,47.49 30.8,47.66 R67879.1
CCG_I2C_SDA_D: length 7.3
  BOTTOM w0.114: U6511.16 25.63,49.05 25.86,49.28 R25575.2 26.8,49.28 27.33,48.74 28.1,48.74 v1(28.81,48.03) R67879.2 30.08,47.97 30.08,47.11 29.86,46.9 Q6535.3
CFG0: length 8
  TOP w0.102: R216.1 128.03,156.27 127.01,155.25 124.91,155.25 v2(123.97,156.19)
  BOTTOM w0.079: U1.T4 121.77,156.56 122.63,156.56 122.68,156.61 123.56,156.61 v2(123.97,156.19)
CFG1: length 6.6
  TOP w0.102: TP28.1 120.46,162.52 120.46,159.94 119.91,159.39 119.91,158.2 v2(120.37,157.74)
  BOTTOM w0.102: U1.R4 120.58,157.74 v2(120.37,157.74)
CFG2: length 11.9
  TOP w0.102: 131.98,158.15 130.63,158.15 130,158.77 129.54,158.77 128.54,157.77 128.54,157.35 127.42,156.23 v2(125.04,156.23)
  TOP w0.114: 131.98,158.15 TP30.1
  BOTTOM w0.079: U1.T3 121.96,156.77 124.5,156.77 125.04,156.23 v2(125.04,156.23)
CFG3: length 13
  TOP w0.102: v2(124.89,159.86) 124.99,159.86 125.17,160.04 125.9,160.04 127.08,161.23 R217.1
  BOTTOM w0.079: 126,159.67 125.49,159.17 125.49,157.49 124.94,156.94 122.31,156.94 122.21,157.04 U1.R3
  BOTTOM w0.102: v2(124.89,159.86) 125.32,159.86 125.53,160.07 R86.1 126.42,159.87 126.29,159.74 126.06,159.74 126,159.67
CFG4: length 9.3
  TOP w0.102: v2(125.4,161.44) 125.7,161.74 TP34.1
  BOTTOM w0.079: 125.88,161.21 125.65,161.44 v2(125.4,161.44) ; 123.48,162.33 123.37,162.33 122.94,161.9 122.17,161.9 122.04,162.02 121.71,162.02 121.56,161.87 121.56,161.62 121.34,161.39 121.11,161.16 U1.J4
  BOTTOM w0.102: 123.48,162.33 123.7,162.33 123.85,162.48 125.25,162.48 125.76,161.97 125.76,161.84 126.42,161.18 R87.1 126.01,161.08 125.88,161.21
CFG5: length 5.5
  TOP w0.102: TP36.1 125.69,160.45 v2(125.02,160.45)
  BOTTOM w0.079: v2(125.02,160.45) 124.74,160.45 124.49,160.19 124.49,159.68 124.17,159.37 123.76,159.37 123.7,159.3 123.29,159.3 123.19,159.41 122.3,159.41 121.99,159.55 121.71,159.55 U1.M4
CFG6: length 2.9
  TOP w0.102: v2(123.47,161.9) 122.99,161.9 TP38.1
  BOTTOM w0.079: U1.J3 121.77,161.16 122.3,161.69 123.27,161.69 v2(123.47,161.9)
CFG7: length 9.7
  TOP w0.102: 129.66,161.4 128.96,161.4 128.46,160.9 128.06,160.9 127.87,160.71 126.94,160.71 125.99,159.76 125.37,159.76 124.89,159.28 v2(124.89,159.28)
  TOP w0.114: 129.66,161.4 130.22,161.4 TP40.1
  BOTTOM w0.079: U1.M3 122,159.18 123.14,159.18 123.19,159.13 124.23,159.13 124.38,159.28 v2(124.89,159.28)
CFG8: length 9.5
  TOP w0.102: v2(125.04,157.65) 125.24,157.65 126.26,158.68 126.26,159.37 126.73,159.83 127.3,159.83 127.36,159.76 127.86,159.76 128.13,160.03 128.13,160.33 128.36,160.56 128.69,160.56 128.97,160.84 TP31.1
  BOTTOM w0.079: v2(125.04,157.65) 124.53,157.14 122.49,157.14 U1.R2
CFG9: length 4.5
  TOP w0.102: TP33.1 124.13,160.42 124.47,160.08 124.47,159.54 124.02,159.08 v2(124.02,158.49)
  BOTTOM w0.079: U1.N2 122.4,158.54 122.58,158.54 123.06,158.32 123.19,158.19 123.72,158.19 v2(124.02,158.49)
CFG10: length 6.7
  TOP w0.102: v2(125.05,158.38) 125.67,158.38 126.06,158.76 126.06,159.45 126.64,160.03 127.48,160.03 TP35.1
  BOTTOM w0.079: U1.R1 122.97,157.41 123.08,157.3 124.29,157.3 124.51,157.52 124.51,157.84 v2(125.05,158.38)
CFG11: length 6.4
  TOP w0.102: TP37.1 127.01,157.06 123.39,157.06 122.96,157.49 122.96,158.16 v2(123.36,158.57)
  BOTTOM w0.079: v2(123.36,158.57) 123.27,158.57 123.11,158.72 U1.N1
CFG12: length 3.1
  TOP w0.102: TP42.1 124.43,162.27 v2(124.1,161.93)
  BOTTOM w0.079: v2(124.1,161.93) 124.04,161.93 123.57,161.47 122.52,161.47 U1.J2
CFG13: length 4.5
  TOP w0.102: TP44.1 122.3,161.08 122.3,160.48 123.07,159.71 v2(123.47,159.71)
  BOTTOM w0.079: v2(123.47,159.71) 123.29,159.71 123.16,159.58 122.48,159.58 U1.L2
CFG14: length 2
  TOP w0.102: TP46.1 124.13,161.46 v2(123.98,161.31)
  BOTTOM w0.079: U1.J1 122.99,161.29 123.95,161.29 v2(123.98,161.31)
CFG15: length 3.2
  TOP w0.102: v2(124.08,159.8) 123.92,159.8 122.94,160.78 TP48.1
  BOTTOM w0.079: v2(124.08,159.8) 123.97,159.8 123.67,160.09 123.11,160.09 U1.L1
CFG16: length 5.8
  TOP w0.102: v2(124.54,160.83) 124.71,161 125.57,161 126.19,161.61 TP29.1
  BOTTOM w0.079: U1.L3 121.73,159.85 arc(121.77,159.86) 121.81,159.88 121.96,160.03 arc(122.02,160.07) 122.08,160.1 arc(122.09,160.1) 122.1,160.1 arc(122.14,160.11) 122.18,160.12 122.25,160.12 122.25,160.12 122.63,160.12 123.04,160.52 123.67,160.52 123.98,160.83 v2(124.54,160.83)
CFG17: length 5.4
  TOP w0.102: TP27.1 121.61,162.62 121.16,162.62 120.66,162.12 120.66,159.52 v2(120.57,159.43)
  BOTTOM w0.079: U1.L4 120.57,159.5 arc(120.57,159.5) 120.57,159.5 120.57,159.44 arc(120.57,159.44) 120.57,159.44 v2(120.57,159.43)
CFG18: length 5.5
  TOP w0.102: v2(123.98,157.67) 124.38,157.27 125.47,157.27 TP41.1
  BOTTOM w0.079: v2(123.98,157.67) 123.63,158.02 123.06,158.02 122.85,158.23 122.57,158.36 121.87,158.36 121.56,158.67 U1.N3
CFG19: length 5
  TOP w0.102: v2(124.55,158.8) 125.28,158.8 TP39.1
  BOTTOM w0.079: v2(124.55,158.8) 124.42,158.94 123.06,158.94 123.02,158.98 121.36,158.98 121.11,158.72 U1.N4
CFG_RCOMP: length 12.3
  TOP w0.102: R82.1 129.19,153.84 128.76,154.28 128.33,154.28 127.69,153.63 123.13,153.63 122.3,152.8 121.18,152.8 120.85,153.13 v2(120.37,153.13)
  BOTTOM w0.203: U1.AB5 120.17,153.39 120.37,153.18 v2(120.37,153.13)
CHA_SA0: length 4
  TOP w0.114: R225.2 R228.1 45.02,107.04 45.91,106.15 v1(45.91,105.92)
  BOTTOM w0.114: v1(45.91,105.92) 45.82,105.82 JDIM1.256
CHA_SA1: length 3
  TOP w0.114: R226.2 45.02,106.17 44.24,105.39 R229.1 44.24,104.43 v1(44.42,104.25)
  BOTTOM w0.114: v1(44.42,104.25) 44.42,104.61 JDIM1.260
CHA_SA2: length 4.9
  TOP w0.114: R227.2 44.56,127.54 v1(44.25,127.23)
  TOP w0.508: v1(43.29,128.76) 43.49,128.76 43.82,129.09 R230.1 44.51,128.16 R227.2
  BOTTOM w0.254: v1(43.29,128.76) 43.29,128.65 43.62,128.32 JDIM1.166
CHB_SA0: length 5.5
  TOP w0.114: v1(55.1,106.02) 54.83,106.02 54.35,105.53 54.03,105.53 v1(53.88,105.38) 53.88,105.13 53.96,105.04 53.96,104.6 R25599.2 53.66,104.53 53.56,104.63 53.56,104.92 R25596.2
  BOTTOM w0.114: v1(55.1,106.02) 55.49,106.02 55.68,105.82 JDIM02.256
CHB_SA1: length 9.5
  TOP w0.114: v1(57.98,104.59) 57.87,104.47 R25600.1 57.87,103.3 v1(57.06,102.49) 53.78,102.49 53.3,102.97 53.3,104.1 R25597.1
  BOTTOM w0.254: JDIM02.260 57.74,104.82 v1(57.98,104.59)
CHB_SA2: length 7
  TOP w0.114: R25598.2 56.88,130.95 R25601.2 57.54,130.95 58.11,130.38 58.55,130.38 59.21,129.72 v1(59.21,129.72)
  BOTTOM w0.114: JDIM02.166 58.15,128.32 59.21,129.39 v1(59.21,129.72)
CK_XDP_N: length 5.8
  BOTTOM w0.079: 126.09,142.38 126.07,142.38 126.04,142.36 125.96,142.36 125.65,142.67 125.11,142.67 124.11,143.67 122.92,143.67 122.72,143.86 122.72,143.94 U1.AU1
  BOTTOM w0.102: 126.09,142.38 126.95,142.38 127.05,142.48 TP47.1
CK_XDP_P: length 5.8
  BOTTOM w0.079: U1.AU2 122.29,144.08 122.85,143.51 124.04,143.51 125.05,142.51 125.59,142.51 125.9,142.2 126.04,142.2 126.07,142.18 126.09,142.18
  BOTTOM w0.102: TP45.1 126.56,142.18 126.09,142.18
CLK_24M_DEBUG: length 150.6
  IN1 w0.089: v1(117.79,95.86) 119.02,97.09 138.19,97.09 138.88,96.4 150.09,96.4 150.5,95.98 153.27,95.98 154.4,94.85 v1(197.44,94.85)
  IN4 w0.089: v1(117.79,95.86) 116.44,97.21 112.61,97.21 109.5,100.32 109.5,105.47 107.41,107.56 105.97,107.56 105.08,108.45 101.27,108.45 100.45,109.27 98.24,109.27 97.25,110.26 95.91,110.26 93.54,112.64 93.54,115.77 94.6,116.84 94.6,121.04 96.86,123.3 v1(96.86,123.5)
  BOTTOM w0.079: v1(96.86,123.5) 96.86,123.52 C96340.2 96.63,124.41 R92.2
  BOTTOM w0.114: v1(197.44,94.85) 197.92,95.33 199,95.33 200.09,96.42 200.09,100.48 200.92,101.31 v1(200.92,101.83) 200.92,104.04 200.44,104.52 200.44,105.17 199.1,106.51 198.93,106.51 R655.1 197.46,107.97 197.31,107.97 195.19,110.09 R674.2
CLK_24M_DEBUG_R: length 3.1
  BOTTOM w0.114: R674.1 193.86,110.09 v4(193.28,109.51) 192.67,108.9 CN17.60
CLK_PCI_EC: length 97.2
  TOP w0.114: v1(144.62,95.4) 144.18,95.84 143.95,95.84 143.57,96.21 143.26,96.21 142.05,97.42 142.05,98.8 142.51,99.26 142.77,99.26 v1(143.18,99.67) 146.71,103.2 146.81,103.2 147.1,103.49 147.42,103.49 R402.2 148.63,104.7 149.99,104.7 150.04,104.74 U37.13
  IN1 w0.089: v1(119.07,95.63) 119.59,96.15 137.8,96.15 138.49,95.46 142.38,95.46 142.97,94.87 144.09,94.87 v1(144.62,95.4)
  IN4 w0.089: v1(119.07,95.63) 118.74,95.63 116.76,97.6 112.77,97.6 109.9,100.48 109.9,105.63 107.57,107.95 106.13,107.95 105.24,108.84 103.76,108.84 103.1,109.5 101.9,109.5 100.74,110.66 96.08,110.66 93.93,112.8 93.93,115.61 95,116.67 95,120.88 97.36,123.24 97.36,127.47 v2(97.15,127.68)
  BOTTOM w0.079: v2(97.15,127.68) 96.83,128 C96341.2 96.76,128.56 R91.2
CLK_PCI_EC_R: length 9.1
  BOTTOM w0.079: R91.1 96.81,127.33 97.58,127.33 99.93,129.68 99.93,130.29 100.08,130.44 100.36,130.44 100.42,130.41 100.46,130.4 100.66,130.4 100.79,130.45 100.99,130.45 101.09,130.41 101.33,130.41 101.4,130.44 101.93,130.44 102.18,130.69 102.18,131.04 102.27,131.14 102.75,131.14 U1.BV32
CLK_PCI_LPC_R: length 10.6
  TOP w0.079: v2(104.21,130.2) 103.78,129.77 103.78,129.13 103.52,128.86 102.15,128.86 100.74,127.45
  TOP w0.114: v2(98.41,125.45) 98.41,125.6 99.2,126.39 99.84,126.39 100.3,126.85 100.3,127.01 100.74,127.45
  BOTTOM w0.079: v2(104.21,130.2) 104.53,130.52 U1.BV30 ; v2(98.41,125.45) 97.83,124.86 R92.1
CLK_PCIE_LANN: length 151.7
  TOP w0.102: v1(21.16,160.87) 20.88,161.15 20.88,162.27 20.99,162.38 U6521.45
  IN1 w0.102: v2(125.02,140.81) 124.82,141.02 124.82,141.21 124.53,141.5 123.82,141.5 122,143.32 122,158.65 122.1,158.75 122.1,160.84 120.65,162.28 120.65,163.53 118.9,165.28 118.9,166.68 118.08,167.5 118.08,168.12 116.34,169.86 116.34,170.9 115.93,171.31 110.72,171.31 108.82,173.21 105.84,173.21 102.46,169.83 72.72,169.83 65.87,176.68 63.71,176.68 62.59,177.8 59.17,177.8 58.72,178.24 57.79,178.24 55.92,176.36 51.41,176.36 50.9,176.87 44.16,176.87 37.55,170.26 37.55,168.92 36.66,168.03 36.66,167.1 33.47,163.91 32.33,163.91 31.65,164.59 29.66,164.59 28.85,163.78 28.85,163.16 26.74,161.05 24.61,161.05 24.22,160.66 22.26,160.66 21.79,160.19 21.03,160.19 20.92,160.3 20.92,160.63 v1(21.16,160.87)
  BOTTOM w0.079: v2(125.02,140.81) 124.88,140.81 124.78,140.91 124.78,141.17 124.61,141.34 122.82,141.34 122.77,141.39 122.69,141.39 122.61,141.47 122.61,141.58 122.67,141.64 U1.BA1
CLK_PCIE_LANP: length 151.7
  TOP w0.102: U6521.44 20.59,162.36 20.68,162.28 20.68,161.15 v1(20.4,160.87)
  IN1 w0.102: v1(20.4,160.87) 20.72,160.56 20.72,160.21 20.94,159.99 21.87,159.99 22.34,160.46 24.3,160.46 24.7,160.85 26.83,160.85 29.05,163.07 29.05,163.69 29.74,164.39 31.56,164.39 32.24,163.7 33.55,163.7 36.87,167.02 36.87,167.95 37.75,168.83 37.75,170.18 44.25,176.67 50.81,176.67 51.32,176.16 56,176.16 57.88,178.04 58.64,178.04 59.09,177.59 62.51,177.59 63.62,176.48 65.78,176.48 72.64,169.63 102.55,169.63 105.93,173 108.74,173 110.64,171.11 115.85,171.11 116.14,170.81 116.14,169.78 117.88,168.03 117.88,167.41 118.69,166.6 118.69,165.2 120.45,163.44 120.45,162.2 121.89,160.75 121.89,158.83 121.8,158.74 121.8,143.24 123.74,141.3 124.44,141.3 124.62,141.13 124.61,141.03 v2(124.4,140.82)
  BOTTOM w0.079: U1.BA2 122.21,141.39 122.37,141.23 122.71,141.23 122.76,141.18 124.55,141.18 124.62,141.11 124.62,140.95 124.49,140.82 v2(124.4,140.82)
CLK_PCIE_REQ2#: length 23.5
  TOP w0.079: 103.58,127.23 102.5,127.23 101.93,126.66 101.32,126.66 100.74,126.08
  TOP w0.102: v2(104.17,126.65) 104.16,126.65 103.58,127.23
  TOP w0.114: 100.74,126.08 99.22,124.57 95.73,124.57 94.59,123.42 92.78,123.42 92.52,123.16 91.53,123.16 89.97,121.6 TP9011.1 89.62,121.41 88.49,121.41 87.63,120.54 85.47,120.54 85,121.01 R25440.1
  BOTTOM w0.079: U1.CF30 104.17,126.46 v2(104.17,126.65)
CLK_PCIE_REQ3#: length 22.8
  TOP w0.079: 100.74,125.78 101.45,126.5 102,126.5 102.57,127.06 103.16,127.06 v2(103.55,126.67)
  TOP w0.114: 100.74,125.78 99.31,124.35 96.23,124.35 95.83,123.95 95.83,123.5 95.48,123.15 92.88,123.15 92.63,122.89 92.09,122.89 90.28,121.09 88.55,121.09 87.74,120.28 86.23,120.28 86.01,120.06 TP9012.1 84.66,120.06 R25441.1
  BOTTOM w0.079: U1.CE31 103.86,127.02 103.55,126.71 v2(103.55,126.67)
CLK_PCIE_SSDN: length 150.9
  IN1 w0.102: v2(125.82,138.92) 125.57,139.17 125.57,139.3 125.35,139.52 122.9,139.52 122.69,139.32 122.15,139.32 120.67,140.8 116.91,140.8 116.91,140.8 116.87,140.76 116.28,140.76 115.95,141.09 112.13,141.09 110.2,139.16 110.2,138.93 109.19,137.92 108.12,137.92 107.39,137.19 105.96,137.19 105.36,136.59 105.36,135.68 104.97,135.3 103.31,135.3 102.28,134.26 99.73,134.26 86.26,120.78 85.24,120.78 83.71,119.26 80.14,119.26 79.09,118.21 77.44,118.21 75.3,116.07 74.75,116.07 63.64,104.97 62.73,104.97 61.99,104.23 61.99,103.44 61.38,102.83 54.82,102.83 54.35,103.29 53.67,103.29 53.29,103.67 50.22,103.67 49.37,102.83 48.33,102.83 47.3,103.85 44.14,103.85 43.75,104.24 34.91,104.24 34.34,103.67 25.75,103.67 23.64,101.55 21.44,101.55 17.06,97.17 17.06,88.28 16.88,88.1 16.88,86.4 17.22,86.06 17.48,86.06 18.28,85.27 18.28,84.53 18.22,84.47 17.99,84.47 v1(17.8,84.67)
  BOTTOM w0.079: v2(125.82,138.92) 125.59,139.15 125.59,139.32 124.93,139.99 122.95,139.99 122.8,140.14 122.8,140.25 U1.BC1
  BOTTOM w0.102: v1(17.8,84.67) 18.04,84.42 18.67,84.42 18.94,84.15 18.94,84.01 R2658.1
CLK_PCIE_SSDN_C: length 4
  BOTTOM w0.102: R2658.2 18.94,83.01 18.94,82.88 20.13,81.68 20.46,81.68 20.69,81.45 20.69,81.25 20.85,81.09 CN16.53
CLK_PCIE_SSDP: length 150.9
  IN1 w0.102: v1(17.8,83.9) 17.8,84.11 17.96,84.27 18.31,84.27 18.48,84.44 18.48,85.35 17.57,86.27 17.3,86.27 17.08,86.49 17.08,88.02 17.26,88.2 17.26,97.09 21.52,101.35 23.72,101.35 25.83,103.46 34.43,103.46 35,104.04 43.66,104.04 44.05,103.64 47.22,103.64 48.24,102.62 49.46,102.62 50.3,103.47 53.21,103.47 53.59,103.09 54.27,103.09 54.74,102.62 61.46,102.62 62.2,103.36 62.2,104.15 62.82,104.77 63.73,104.77 74.83,115.87 75.39,115.87 77.52,118.01 79.18,118.01 80.22,119.05 83.8,119.05 85.33,120.58 86.34,120.58 99.82,134.06 102.36,134.06 103.4,135.09 105.06,135.09 105.56,135.6 105.56,136.5 106.04,136.98 107.47,136.98 108.2,137.71 109.27,137.71 110.4,138.84 110.4,139.07 112.22,140.89 115.87,140.89 116.2,140.56 116.95,140.56 116.99,140.6 120.58,140.6 122.07,139.11 122.78,139.11 122.98,139.32 125.27,139.32 125.37,139.22 125.37,139.07 v2(125.21,138.91)
  BOTTOM w0.079: U1.BC2 122.39,140.32 122.89,139.83 124.86,139.83 125.44,139.25 125.44,139.14 v2(125.21,138.91)
  BOTTOM w0.102: R2659.1 18.62,83.74 18.74,83.86 18.74,84.07 18.59,84.22 17.93,84.22 17.8,84.1 v1(17.8,83.9)
