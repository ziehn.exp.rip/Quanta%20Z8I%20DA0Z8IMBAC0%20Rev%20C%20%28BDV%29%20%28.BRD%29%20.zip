# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VIN on BOTTOM (solid shape): 159.36,157.98 159.36,154.99 158.93,154.56 158.93,151.05 158.3,150.42 156.67,150.42 156.49,150.24 156.49,149.98 156.33,149.82 152.75,149.82 152.64,149.92 152.64,150.94 153.34,151.63 153.34,158.16 153.47,158.29 154.49,158.29 154.59,158.19 154.59,153.97 154.74,153.82 155.83,153.82 156.31,154.3 156.57,154.3 156.58,154.3 156.75,154.26 156.93,154.3 156.94,154.3 157.08,154.3 157.56,154.78 157.56,158.44 157.71,158.59 158.75,158.59
+VIN on BOTTOM (solid shape): 147.02,167.18 147.02,165.3 147.2,165.12 148.06,165.12 148.26,165.33 148.26,165.91 148.52,166.16 149.91,166.16 150.09,165.99 150.09,162.56 150.24,162.4 150.6,162.4 150.78,162.23 150.78,161.83 150.77,161.8 150.77,161.77 150.77,161.49 150.77,161.45 150.78,161.42 150.78,161.21 150.66,161.1 150.66,161.1 150.29,160.73 150.28,160.72 150.06,160.61 149.94,160.39 149.94,160.37 149.81,160.25 146.18,160.25 145.7,160.73 145.7,167.08 145.93,167.31 146.89,167.31
+VIN on BOTTOM (solid shape): 79.91,201.39 79.91,192.78 79.63,192.66 79.51,192.37 79.54,192.23 79.61,192.11 79.61,191.98 79.53,191.85 79.5,191.7 79.61,191.43 79.88,191.3 79.88,191.03 79.89,191.03 79.89,188.85 79.76,188.72 77.68,188.72 77.6,188.79 77.6,194.46 78.01,194.87 78.01,196.31 78.02,196.32 78.02,201.48 78.49,201.95 79.35,201.95
+VIN on BOTTOM (solid shape): 112.25,191.93 112.21,191.81 112.19,191.69 112.21,191.58 112.24,191.47 112.25,191.46 112.25,191.31 112.17,191.23 111.31,191.23 111.28,191.26 110.54,191.26 110.29,191 110.29,190.22 109.05,188.97 109.05,188.52 108.92,188.39 106.99,188.39 106.86,188.47 106.72,188.5 106.58,188.47 106.45,188.4 106.44,188.39 106.32,188.39 106.31,188.4 106.19,188.47 106.05,188.49 105.97,188.48 105.9,188.46 105.86,188.45 105.67,188.64 105.67,191.21 106.07,191.61 107.45,191.61 108,192.17 108,192.3 108.09,192.39 112.25,192.39
+VIN on BOTTOM (solid shape): 165.9,156.41 165.9,156.39 165.9,155.76 165.95,155.7 166.33,155.7 166.33,153.22 166.22,153.11 166.1,153.11 165.9,152.92 165.9,152.02 165.91,152.02 166.16,151.77 167.59,151.77 167.92,151.44 167.92,151.02 167.8,150.9 167.07,150.9 166.65,150.49 166.01,150.49 165.98,150.49 165.93,150.48 165.87,150.46 165.82,150.43 165.77,150.4 165.75,150.38 165.33,149.96 163.53,149.96 163.48,150.01 163.48,151.2 163.99,151.72 164.92,151.72 165.1,151.89 165.13,151.89 165.15,151.91 165.15,152.02 165.65,152.02 165.65,152.81 165.4,152.81 165.4,152.02 165.15,152.02 165.15,152.81 165.15,152.81 165.15,152.99 165.02,153.12 165.02,155.64 165.08,155.71 165.58,155.71 165.65,155.79 165.65,156.02 165.65,156.34 165.66,156.7 165.66,156.7 165.9,156.7
+VIN on BOTTOM (solid shape): outline of 122 points within 143.92,119.26 153.58,127.78
+VIN_BLIGHT on BOTTOM (solid shape): 75.3,192.51 75.5,192.51 75.5,193.37 76.46,193.37 77.09,192.73 77.09,190.12 76.81,189.84 76.08,189.84 75.74,190.02 75.4,189.84 75.13,189.84 75.09,189.86 75.03,189.89 74.98,189.94 74.98,191.5 75.11,191.65 75.15,191.83 75.11,192.01 74.98,192.16 74.98,192.51 75,192.51 75,193.37 75.3,193.37
GND on TOP (solid shape): 22.22,195 22.22,193.59 21.85,193.22 17.48,193.22 17.04,193.66 17.04,195.68 17.27,195.9 21.32,195.9
GND on TOP (solid shape): 90.25,167.49 90.25,164.45 90.02,164.21 88.57,164.21 88.49,164.29 88.49,167.54 88.65,167.7 90.05,167.7
GND on TOP (solid shape): 149.68,184.1 149.68,183.36 149.43,183.11 145.87,183.11 145.7,183.28 145.7,183.75 146.22,184.27 149.51,184.27
GND on TOP (solid shape): 229.92,102.79 229.92,101.32 229.47,100.86 225,100.86 224.59,101.27 224.59,102.79 224.84,103.04 229.67,103.04
GND on TOP (solid shape): 230.28,108.57 230.28,106.04 229.92,105.69 228.5,105.69 228.25,105.94 228.25,109.6 228.35,109.7 229.15,109.7
GND on TOP (solid shape): 25.22,158.25 25.22,157.37 25.67,156.92 25.67,156.34 25.49,156.17 23.73,156.17 23.59,156.3 23.59,158.17 23.83,158.41 25.05,158.41
GND on TOP (solid shape): 47.64,103.56 47.64,102.63 47.44,102.43 45.52,102.43 44.84,103.11 44.84,103.54 44.92,103.63 47.42,103.63 47.44,103.65 47.55,103.65
GND on TOP (solid shape): 72.34,184.83 72.34,184.38 71.71,183.74 71.4,183.74 71.12,183.46 69.22,183.46 68.43,184.25 68.43,185.09 68.63,185.29 71.89,185.29
GND on TOP (solid shape): 82.79,142.82 84.45,142.82 84.55,142.72 84.55,142.11 83.99,141.55 81.34,141.55 81.03,141.86 81.03,142.92 81.15,143.04 82.57,143.04
GND on TOP (solid shape): 125.93,164.57 125.93,163.91 125.79,163.77 123.39,163.77 123.19,163.98 123.19,164.51 123.37,164.69 125.81,164.69
GND on TOP (solid shape): 134.32,163.21 134.32,162.34 133.83,161.85 131.7,161.85 131.2,162.35 131.2,162.89 131.28,162.97 131.98,162.97 132.36,163.34 134.19,163.34
GND on TOP (solid shape): 169.12,107.62 170.44,107.62 170.46,107.59 170.46,107.34 170.44,107.31 168.08,107.31 168.02,107.36 168.02,107.64 168.15,107.77 168.96,107.77
GND on TOP (solid shape): 233.78,119.25 233.78,118.68 233.99,118.48 233.99,118.28 233.94,118.23 232.01,118.23 231.96,118.28 231.96,119.1 232.21,119.35 233.68,119.35
GND on TOP (solid shape): 117.36,147.71 117.36,147.26 116.87,146.76 115.42,146.76 115.42,147.22 115.44,147.24 116.71,147.24 116.94,147.47 116.94,147.78 117.02,147.85 117.22,147.85
GND on TOP (solid shape): 24.95,95.91 24.95,94.28 24.41,93.75 23.19,93.75 22.99,93.95 22.99,95.7 23.38,96.1 24.76,96.1
GND on TOP (solid shape): 105.32,116.53 105.5,116.53 105.52,116.51 105.52,115.08 105.47,115.03 103.57,115.03 103.44,114.91 102.31,114.91 102.31,115.06 102.18,115.2 102.18,116.54 102.47,116.84 105.01,116.84
GND on TOP (solid shape): 53.79,135.4 53.79,134.94 53.72,134.88 53.72,134.48 53.73,134.48 53.73,133.58 53.69,133.54 52.17,133.54 51.88,133.83 51.88,134.58 52.03,134.72 52.5,134.72 53.23,135.46 53.73,135.46
GND on TOP (solid shape): 153.24,117.67 153.24,116.59 153.19,116.48 153.17,116.36 153.17,115.86 153.02,115.7 152,115.7 151.94,115.7 150.52,117.12 150.52,119.25 151.67,119.25
GND on TOP (solid shape): 38.95,135.94 38.95,134.03 38.81,133.89 38.61,133.89 38.55,133.94 37.84,133.94 37.52,134.26 37.52,135 37.66,135.14 38.22,135.14 38.23,135.15 38.33,135.15 38.53,135.35 38.53,135.98 38.58,136.03 38.85,136.03
GND on TOP (solid shape): 57.55,104.42 57.55,104.13 57.41,103.99 57.41,103.23 57.18,103 53.76,103 53.54,103.21 53.54,103.83 53.51,103.86 53.51,103.97 54.29,103.97 54.78,104.45 54.82,104.45 57.52,104.45
GND on TOP (solid shape): 79.23,185.54 79.23,185.52 79.35,185.39 80.78,185.39 81.23,184.93 81.23,184.43 81.03,184.22 75.95,184.22 75.8,184.38 75.8,184.98 76.05,185.24 77.12,185.24 77.52,185.65 77.52,186.48 77.63,186.59 78.18,186.59
GND on TOP (solid shape): 164.59,157.22 164.59,155 164.27,154.68 164.27,152.02 164.08,151.84 161.56,151.84 160.96,152.44 160.96,155.08 161.36,155.48 162.98,155.48 163.78,156.27 163.78,156.82 163.52,157.08 163.52,157.52 163.68,157.68 164.13,157.68
GND on TOP (solid shape): 166.2,132.66 166.2,130.4 165.26,129.46 164.93,129.46 164.8,129.59 164.8,130.12 165.23,130.55 165.23,131.59 165.1,131.72 164.14,131.72 164.14,132 165.08,132 165.23,132.15 165.23,132.71 165.48,132.97 165.89,132.97
GND on TOP (solid shape): 178.56,130.72 178.56,125.21 177.67,124.32 173.45,124.32 173.26,124.51 173.26,124.8 173.39,124.93 175.2,124.93 175.42,125.14 175.42,128.01 175.5,128.1 177.19,128.1 177.49,128.39 177.49,130.7 177.71,130.93 178.36,130.93
GND on TOP (solid shape): 221.05,111.67 221.05,108.28 220.65,107.88 220.65,106.63 219.69,106.63 219.28,107.04 219.27,107.04 218.95,107.37 218.95,109.14 219.41,109.6 219.69,109.88 219.69,110.93 220.63,111.87 220.85,111.87
GND on TOP (solid shape): 136.03,156.13 136.03,154.45 135.8,154.22 132.38,154.22 131.8,153.64 131.62,153.64 131.59,153.67 131.59,154.04 131.61,154.07 131.78,154.07 132.21,154.5 132.21,155.29 132.23,155.32 132.94,155.32 133.38,155.75 133.38,156.13 133.63,156.38 135.77,156.38
GND on TOP (solid shape): 162.2,188.21 162.2,186.06 162.2,186.04 162.2,184.53 161.95,184.27 161.73,184.27 159.66,186.34 159.66,186.94 159.66,186.94 159.66,187.09 159.64,187.11 159.64,188.62 159.87,188.84 161.57,188.84
GND on TOP (solid shape): 226.88,112.59 226.88,112.29 226.98,112.18 227.03,112.12 227.08,112.07 227.08,110.46 226.77,110.16 224.64,110.16 224.29,110.51 224.29,112.54 224.34,112.59 225.56,112.59 225.61,112.65 225.62,112.65 225.67,112.7 226.77,112.7
GND on TOP (solid shape): 17.99,140 17.99,139.25 17.98,139.24 17.98,136.81 17.66,136.49 16.54,136.49 16.41,136.62 16.41,138.56 16.62,139.31 16.71,140.09 16.86,140.24 17.75,140.24
GND on TOP (solid shape): 60.44,179.58 60.44,178.16 60.11,177.83 60.11,177.31 59.99,177.19 58.17,177.19 58.11,177.24 58.09,177.24 57.74,177.59 57.74,177.74 57.83,177.83 58.27,177.83 58.66,178.22 58.66,178.76 58.99,179.09 59.43,179.09 59.71,179.37 59.71,179.71 59.85,179.84 60.18,179.84
GND on TOP (solid shape): 115.33,150.8 116.4,150.8 116.51,150.9 117.22,150.9 117.35,150.77 117.35,150.19 117.22,150.06 116.76,150.06 116.08,149.37 116.08,149.29 116,149.22 115.54,149.22 115.21,149.55 115.21,150.03 115.11,150.13 109.93,150.13 109.7,150.37 109.7,151.08 109.94,151.32 114.81,151.32
GND on TOP (solid shape): 142.2,150.74 142.2,149.79 142.93,149.06 142.93,145.44 143.15,145.22 143.15,145.02 143.05,144.92 142.92,144.92 142.82,144.82 142.82,144.34 142.75,144.26 142.28,144.26 142.13,144.41 142.13,144.92 141.77,145.27 141.77,149.71 141.02,150.45 141.02,150.73 141.14,150.84 142.1,150.84
GND on TOP (solid shape): 168.07,165.66 168.36,163.16 168.82,160.7 168.82,160.67 168.77,160.62 166.66,160.62 166.27,161.01 166.27,161.6 166.65,161.99 166.65,165.6 166.76,165.71 168.03,165.71
GND on TOP (solid shape): 19.01,111.17 19.01,111.12 19.06,111.01 19.17,110.97 19.22,110.97 19.28,110.91 19.63,110.91 19.71,110.82 19.71,108.71 19.59,108.58 18.26,108.58 18.14,108.71 18.14,111.19 18.26,111.32 18.87,111.32
GND on TOP (solid shape): 47.25,98.48 47.25,98.1 47.13,97.99 46.21,97.99 45.39,97.16 45.39,96.32 45.28,96.21 44.79,96.21 44.32,96.68 43.66,96.68 43.28,96.29 42.54,96.29 42.4,96.15 42.4,96 42.32,95.92 41.9,95.92 41.81,96.01 41.81,96.78 43.68,98.65 47.07,98.65
GND on TOP (solid shape): 161.95,130.55 161.95,129.82 162.08,129.69 162.11,129.69 162.33,129.46 162.33,128.8 162.16,128.62 159.19,128.62 158.78,129.03 158.78,129.36 158.95,129.53 159.06,129.53 159.13,129.54 159.41,129.54 159.64,129.77 159.64,130.53 160.05,130.93 161.57,130.93
GND on TOP (solid shape): 32.76,136.65 32.86,136.61 32.97,136.6 33.08,136.61 33.18,136.66 33.51,136.66 33.66,136.51 33.66,135.72 34.22,135.16 34.22,134.3 34.09,134.18 32.86,134.18 32.59,134.45 32.59,136.55 32.7,136.66 32.75,136.66
GND on TOP (solid shape): 127.85,132.16 127.85,131.7 128.03,131.52 128.23,131.52 128.37,131.39 128.37,131.18 128.2,131.01 127.34,131.01 126.95,131.4 126.13,131.4 126.02,131.52 126.02,131.88 126.03,131.9 126.27,131.9 126.37,131.8 127.14,131.8 127.33,131.99 127.33,132.16 127.4,132.23 127.79,132.23
GND on TOP (solid shape): 144.48,163.17 144.48,162.73 144.63,162.58 145.11,162.58 145.27,162.43 145.27,160.25 144.94,159.92 141.84,159.92 141.84,159.98 141.79,160.09 141.68,160.13 141.39,160.13 141.18,160.35 141.18,162.48 141.96,163.27 144.38,163.27
GND on TOP (solid shape): 114.31,203.87 114.31,202.84 113.96,202.5 113.83,202.5 113.38,202.04 113.38,200.76 113.55,200.59 113.87,200.59 114.17,200.3 114.17,199.53 114.08,199.44 113.28,199.44 113.1,199.61 113.1,200.35 112.72,200.74 112.72,202.18 112.51,202.4 112.37,202.4 112.02,202.75 112.02,203.42 112.17,203.58 113.56,203.58 113.91,203.92 114.25,203.92
GND on TOP (solid shape): 173.15,98.73 173.15,97.96 173.05,97.85 173.05,97.43 172.92,97.3 171.98,97.3 171.89,97.39 171.89,97.86 171.5,98.26 171.24,98.26 171.12,98.37 171.11,98.37 170.95,98.53 170.86,98.53 169.92,98.53 169.88,98.57 169.88,98.73 169.93,98.78 173.1,98.78
GND on TOP (solid shape): 54.99,185.24 54.99,182.7 54.59,182.3 54.59,181.32 55.02,180.89 56.02,180.89 56.29,180.62 56.29,178.95 56.09,178.74 54.08,178.74 54.03,178.79 54.03,179.28 53.64,179.67 53.64,181.11 53.4,181.35 52.35,181.35 51.74,181.96 51.74,182.17 50.35,183.56 49.63,183.56 49.48,183.71 49.48,185.04 49.84,185.39 54.84,185.39
GND on TOP (solid shape): 57.83,129.96 57.98,129.96 58.09,129.85 58.09,129.63 57.48,129.02 57.48,128.34 58.01,127.81 58.86,127.81 59.49,127.18 59.49,126.74 59.38,126.63 59.14,126.63 59.01,126.75 59.01,127.05 58.79,127.28 58.26,127.28 58.09,127.12 58.09,126.66 57.95,126.52 56.81,126.52 56.68,126.65 56.68,128.88 56.98,129.19 56.98,130.32 57.06,130.39 57.4,130.39
GND on TOP (solid shape): 134.23,135.32 136.88,135.32 137.02,135.19 137.02,134.66 136.78,134.42 135.84,134.42 135.77,134.35 135.77,134.01 135.78,134 135.78,133.77 135.54,133.53 134.42,133.53 134.14,133.82 133.79,133.82 133.78,133.83 133.2,133.83 133.08,133.95 132.32,133.95 132.11,134.16 131.59,134.16 131.39,134.36 131.39,135.22 131.47,135.3 132.17,135.3 132.39,135.52 134.04,135.52
GND on TOP (solid shape): 152.59,136.73 152.59,136.35 152.83,136.1 154.41,136.1 154.52,136 154.52,135.71 154.44,135.63 153.27,135.63 153.05,135.41 153.05,134.09 152.61,133.65 151,133.65 150.42,134.23 149.42,134.23 149.33,134.32 149.33,135.26 149.47,135.4 150.77,135.4 150.93,135.57 150.93,135.73 150.93,135.74 150.93,136.46 150.99,136.53 151.84,136.53 152.12,136.81 152.5,136.81
GND on TOP (solid shape): 20.6,176.92 20.6,176.87 20.56,176.82 20.56,176.2 20,175.64 20,174.79 19.57,174.36 19.55,174.36 19.39,174.28 19.31,174.12 19.31,174.08 19.23,174 19.23,173.66 18.89,173.33 18.87,173.33 17.47,173.33 17.1,173.69 17.1,175.37 18.72,176.99 20.53,176.99
GND on TOP (solid shape): 89.51,99.77 89.51,96.34 89.46,96.28 85.74,96.28 85.74,96.47 85.7,96.56 85.62,96.62 85.58,96.63 85.58,96.66 84.58,96.66 84.58,96.97 85.58,96.97 85.58,97.01 85.62,97.02 85.67,97.04 85.71,97.07 85.73,97.07 85.9,97.24 85.9,98.09 85.89,98.09 85.89,99.9 89.38,99.9
GND on TOP (solid shape): 93.48,99.01 93.48,97.74 93.17,97.43 92.43,97.43 92.33,97.53 92.35,97.56 92.36,97.59 92.36,97.62 92.36,98 92.35,98.05 92.33,98.1 92.31,98.11 92.31,98.19 92.31,98.25 92.31,99.11 92.23,99.18 91.67,99.18 91.6,99.26 91.6,100.12 91.6,100.3 91.7,100.4 92.08,100.4
GND on TOP (solid shape): 121.56,172.26 121.56,171.6 121.46,171.5 116.1,171.5 115.85,171.24 115.85,170.23 116.1,169.97 116.74,169.97 117.12,169.59 117.12,168.83 116.99,168.7 116.48,168.7 116.47,168.69 116.26,168.69 115.83,168.26 115.83,167.68 115.75,167.59 115.42,167.59 115.34,167.67 115.34,169.34 114.96,169.72 113.69,169.72 113.44,169.46 113.44,168.7 113.18,168.45 112.93,168.45 112.67,168.7 112.67,170.73 112.93,170.99 112.93,171.88 113.44,172.39 121.44,172.39
GND on TOP (solid shape): 136.9,146.64 136.9,144.01 136.79,143.9 136.79,143.15 136.6,142.96 136.6,142.35 136.79,142.16 136.79,141.75 136.8,141.62 136.88,141.54 137.61,141.54 137.7,141.44 137.7,137.88 137.02,137.88 136.53,138.38 134.1,138.38 134.1,138.37 133.77,138.37 133.52,138.62 132.39,138.62 131.93,139.09 131.28,139.09 131.24,139.13 131.24,139.33 131.49,139.58 131.49,140.87 129.01,143.35 129.01,146.66 131.15,148.8 134.74,148.8
GND on TOP (solid shape): 135.35,121.25 135.35,119.25 135.16,119.06 135.16,119.02 135.14,119.01 135.14,118.73 135.12,118.65 135.11,118.58 135.12,118.5 135.14,118.42 135.14,117.97 135.13,117.92 135.12,117.85 134.91,117.65 133.5,117.65 133.19,117.95 133.19,118.71 133.2,118.72 133.2,120.12 133.83,120.76 133.86,120.79 133.89,120.83 134.46,121.4 135.19,121.4
GND on TOP (solid shape): 175.77,98.7 175.77,97.78 175.73,97.69 175.72,97.58 175.73,97.49 175.57,97.33 174.55,97.33 174.39,97.5 174.4,97.56 174.4,97.6 174.39,97.7 174.35,97.79 174.35,97.8 174.35,98.02 174.19,98.17 174.17,98.22 174.14,98.26 173.92,98.48 173.92,98.7 173.97,98.75 175.72,98.75
GND on TOP (solid shape): 115.89,145.82 115.89,145.37 116.08,145.18 117.1,145.18 117.38,144.91 117.38,144.67 117.19,144.48 116.93,144.48 116.79,144.61 116.61,144.65 116.42,144.6 116.19,144.37 114.76,144.37 114.68,144.45 114.68,144.78 115.14,145.24 115.14,145.61 115.41,145.89 115.82,145.89
GND on TOP (solid shape): 105.99,202.63 106.76,202.63 108.66,200.73 108.67,200.73 108.75,200.65 110.44,200.65 111.81,199.28 111.81,197.93 112.01,197.73 112.65,197.73 112.87,197.51 112.87,197.09 112.83,197.06 112.83,196.78 112.37,196.31 112.37,195.76 112.66,195.47 113.03,195.47 113.17,195.33 113.17,193.57 112.9,193.3 111.95,193.3 111.23,192.58 105.83,192.58 105.6,192.81 105.6,194.86 105.71,194.97 106.21,194.97 107.13,195.89 107.13,199.1 106.29,199.94 106.29,200.89 105.7,201.48 105.7,202.58 105.81,202.7 105.91,202.7
GND on TOP (solid shape): 129.18,125.55 129.18,125.33 129.08,125.2 129.04,125.04 129.15,124.77 129.42,124.65 129.47,124.66 129.51,124.67 129.63,124.55 129.63,123.8 129.47,123.64 129.22,123.64 128.89,123.98 128.5,123.98 128.46,124.01 128.46,125.27 128.53,125.34 128.53,125.51 128.6,125.58 129.15,125.58
GND on TOP (solid shape): 154.51,158.85 154.51,150.64 154.38,150.52 152.77,150.52 152.33,150.07 148.68,150.07 148.56,150.2 148.56,151.67 148.9,152.02 150.07,152.02 150.98,152.93 150.98,155.29 150.65,155.62 149.94,155.62 149.77,155.79 149.77,155.99 150.09,156.31 150.09,156.85 149.77,157.17 149.77,158.3 149.93,158.45 150.81,158.45 151.02,158.39 151.24,158.45 151.7,158.45 151.72,158.44 153.22,158.44 153.85,159.08 154.28,159.08
GND on TOP (solid shape): 22.37,63.72 22.37,62.58 22.06,62.28 20.16,62.28 20.06,62.38 20.06,62.77 20.22,62.93 20.25,62.92 20.33,62.89 20.42,62.88 20.55,62.91 20.67,62.97 20.93,62.97 21.05,62.91 21.18,62.88 21.31,62.9 21.42,62.96 21.43,62.97 21.5,62.97 21.68,63.15 21.68,63.65 21.8,63.77 22.32,63.77
GND on TOP (solid shape): 35.64,142.32 35.64,141.32 35.73,141.24 36.99,141.24 37.21,141.03 37.21,139.2 37.14,139.13 36.85,139.13 36.85,140.03 36.81,140.03 36.8,140.07 36.74,140.15 36.65,140.19 36.51,140.19 36.37,140.32 35.26,140.32 34.94,140.64 34.94,140.95 34.65,141.23 33.53,141.23 33.33,141.43 33.34,141.46 33.37,141.54 33.37,141.63 33.35,141.76 33.28,141.88 33.28,142.35 33.37,142.44 35.52,142.44
GND on TOP (solid shape): 27.66,165.57 27.69,165.57 27.73,165.57 27.77,165.58 27.92,165.58 28.1,165.4 28.1,164.63 27.67,164.21 27.64,164.21 27.34,164.21 27.17,164.15 27.09,164 27.08,163.98 26.77,163.67 25.28,163.67 25.12,163.83 25.12,164.31 25.13,164.32 25.87,164.32 26.16,164.6 26.17,164.66 26.2,164.71 26.25,164.74 26.31,164.75 26.35,164.79 26.69,164.79 26.93,165.03 26.93,165.07 27,165.15 27,165.45 27.13,165.58 27.61,165.58
GND on TOP (solid shape): 140.68,126.68 140.77,126.62 140.88,126.6 141.7,126.6 141.89,126.41 141.89,124.32 141.62,124.05 141.62,122.07 141.72,121.97 142.19,121.97 142.34,121.82 142.34,121.05 141.96,120.67 139.7,120.67 139.55,120.52 139.55,119.61 139.51,119.55 139.25,119.29 139.25,119.27 139.09,119.12 138.53,119.12 138.23,119.43 138.23,125.37 138.57,125.71 138.57,126.31 138.58,126.35 138.58,126.65 138.57,126.73 138.84,127 140.37,127
GND on TOP (solid shape): 116.27,155.57 116.8,155.57 117.04,155.48 117.27,155.57 118.27,155.57 118.32,155.56 118.54,155.34 118.54,154.89 118.39,154.74 117.09,154.74 116.74,155.09 116.53,155.09 116.48,155.1 116.43,155.1 116.38,155.1 116.33,155.09 116.23,155.09 115.97,154.83 115.97,154.72 115.37,154.11 115.37,152.93 115.21,152.78 114.65,152.78 114.35,153.08 113.36,153.08 113.36,153.13 113.16,153.34 113.16,154.63 113.36,154.84 114.05,154.84 114.89,155.68 116.17,155.68
GND on TOP (solid shape): 106.02,206.9 106.02,206.04 103.58,203.6 103.45,203.6 100.33,200.48 100.33,199.92 99.52,199.11 97.82,199.11 97.49,199.44 97.49,200.63 97.64,200.78 98.25,200.78 99.01,201.55 99.01,205.17 99.09,205.3 99.11,205.46 99.09,205.61 99.01,205.75 99.01,205.93 99.09,206.07 99.11,206.22 99.11,206.28 99.09,206.36 99.13,206.41 99.64,206.66 100.08,207.01 103,209.92
GND on TOP (solid shape): 109,139.67 112.93,139.67 113.68,138.93 116.77,138.93 116.95,138.93 117.25,138.63 117.25,138.1 117.12,137.97 114.61,137.97 114.23,138.35 111.25,138.35 111.05,138.55 109.12,138.55 108.26,137.69 108.2,137.69 107.77,137.26 107.77,137.08 107.7,137 107.37,137 107.34,137.03 107.34,137.78 107.49,137.93 107.49,138.45 107.56,138.52 107.95,138.52 108.03,138.51 108.16,138.52 108.2,138.55 108.28,138.61 108.35,138.7 108.36,138.72 108.38,138.8 108.39,138.86 108.38,138.92 108.36,138.99 108.36,139.68 108.52,139.84 108.83,139.84
GND on TOP (solid shape): 200.94,131.16 201.55,131.09 201.55,130.6 200.91,129.96 200.87,129.98 200.76,130.04 200.65,130.06 200.4,129.97 200.25,129.76 200.24,129.72 200.15,129.72 200.1,129.74 200.06,129.74 199.76,129.74 199.71,129.74 199.66,129.72 199.51,129.72 199.32,129.91 199.33,129.98 199.33,130.26 199.26,130.44 199.08,130.51 198.84,130.51 198.64,130.71 198.64,131.24 200.32,131.24
GND on TOP (solid shape): 130.31,189.79 130.31,188.95 129.37,188.01 129.06,188.01 129,188 128.97,187.96 128.95,187.93 128.89,187.93 128.79,187.91 128.7,187.86 128.55,187.86 128.54,187.87 128.48,187.9 128.42,187.91 128.12,187.91 127.98,187.85 127.92,187.71 127.92,187.6 127.33,187.6 127.33,187.92 127.2,188.06 126.75,188.06 126.72,188.08 126.72,188.97 126.83,189.07 128.78,189.07 129,189.29 129.04,189.29 129.25,189.36 129.36,189.53 129.37,189.55 129.64,189.82 129.65,189.82 129.72,189.87 129.77,189.93 129.79,189.96 130.13,189.96
GND on TOP (solid shape): 116.74,135.43 116.74,135.05 115.49,133.8 115.19,133.8 115.04,133.96 115.04,134.08 114.73,134.39 114.73,134.79 113.66,135.86 112.93,135.86 112.62,135.56 112.62,135.19 112.5,135.06 112.15,135.06 112.09,135 112.09,134.36 112.32,134.13 112.32,133.8 112.17,133.65 111.61,133.65 111.53,133.73 111.53,134.16 111.45,134.23 111.45,134.91 111.3,135.06 110.12,135.06 109.96,134.89 109.96,133.75 110.18,133.52 110.57,133.52 110.69,133.4 110.69,133.22 110.54,133.07 110.26,133.07 109.96,132.76 109.96,132.48 110.24,132.2 110.49,132.2 110.54,132.15 110.54,131.87 110.44,131.77 109.96,131.77 109.35,131.16 108.61,131.16 108.51,131.26 108.51,131.47 108.64,131.59 108.99,131.59 109.52,132.13 109.52,133.6 109.55,133.63 109.55,133.92 109.52,133.95 109.52,134.21 109.12,134.62 109.12,134.97 109.04,135.05 108.51,135.05 107.9,134.44 107.54,134.44 107.39,134.59 107.39,135.28 107.54,135.43 108.91,135.43 109.09,135.61 109.09,136.57 109.19,136.67 115.49,136.67
GND on TOP (solid shape): 135.86,211.76 135.86,211.6 135.87,211.52 135.9,211.45 135.91,211.44 135.91,211.41 137.84,209.48 137.84,208.12 137.65,207.93 136.88,207.93 136.64,208.17 136.64,209.48 136.53,209.58 136.5,209.64 136.45,209.67 136.36,209.76 135.32,209.76 135.31,209.77 135.17,209.79 135.03,209.77 135.02,209.76 133.7,209.76 133.69,209.77 133.6,209.8 133.51,209.81 133.42,209.8 133.33,209.77 133.32,209.76 133.04,209.76 133.03,209.77 132.94,209.8 132.85,209.81 132.76,209.8 132.67,209.77 132.66,209.76 130.63,209.76 130.43,209.96 130.43,211.58 130.72,211.87 131.02,211.87 131.05,211.86 131.08,211.86 131.64,211.86 131.66,211.86 131.7,211.87 134.39,211.87 134.55,212.03 135.59,212.03
GND on TOP (solid shape): 160.33,136.43 160.33,134.1 160.33,134.07 160.34,134.02 160.35,133.97 160.37,133.92 160.39,133.88 160.39,133.82 159.63,133.05 159.63,133.04 158.7,132.12 157.59,132.12 157.51,132.2 157.51,132.68 157.68,132.85 157.68,133.31 158.81,134.44 158.81,134.67 159,134.67 159.01,134.61 159.02,134.56 159.04,134.5 159.06,134.45 159.1,134.41 159.14,134.36 159.18,134.33 159.23,134.3 159.28,134.28 159.34,134.27 159.4,134.26 159.45,134.26 159.51,134.27 159.56,134.29 159.61,134.31 159.66,134.35 159.7,134.38 159.74,134.43 159.77,134.48 159.79,134.53 159.81,134.58 159.82,134.64 159.82,134.7 159.81,134.75 159.79,134.81 159.77,134.86 159.74,134.91 159.7,134.95 159.66,134.99 159.61,135.02 159.56,135.05 159.51,135.06 159.45,135.07 159.4,135.07 159.34,135.07 159.28,135.06 159.23,135.03 159.18,135.01 159.14,134.97 159.1,134.93 159.06,134.88 159.04,134.83 159.02,134.78 159.01,134.72 159,134.67 158.81,134.67 158.81,134.89 159.15,135.23 159.15,136.65 159.29,136.79 159.97,136.79
GND on TOP (solid shape): 38.84,164.76 38.84,163.97 38.84,163.97 38.84,160.93 38.69,160.78 38.32,160.78 38.24,160.85 38.24,162.7 38.1,162.84 38.01,162.84 37.96,162.88 35.61,162.88 35.57,162.85 35.28,162.85 35.18,162.82 35.13,162.74 35.12,162.7 35.08,162.7 35.08,161.95 34.88,161.95 34.88,162.7 34.84,162.7 34.83,162.74 34.77,162.82 34.68,162.85 34.44,162.85 34.44,162.9 34.31,162.9 34.31,162.9 33.68,162.9 33.65,162.91 31.71,162.91 31.64,162.84 31.03,162.84 30.9,162.98 30.9,164.01 30.99,164.11 32.36,164.11 32.44,164.09 32.52,164.09 32.54,164.09 32.79,163.84 32.81,163.84 32.84,163.81 34.2,163.81 34.22,163.84 35.52,163.84 35.52,163.79 36.27,163.79 36.28,163.79 37.19,163.79 37.2,163.8 37.46,163.8 37.5,163.84 37.51,163.84 38.01,164.34 38.01,164.45 38,164.48 38,164.83 38.01,164.85 38.01,164.89 38.05,164.93 38.67,164.93
GND on TOP (solid shape): 78.86,193.67 78.86,192.64 78.68,192.46 78.68,190.14 77.89,189.34 77,189.34 76.43,188.78 74.96,188.78 74.84,188.89 74.71,188.98 74.55,189.01 74.02,189.01 74.02,189.59 73.94,189.67 73.94,189.69 73.89,189.74 73.89,189.75 73.79,189.91 73.63,190.01 73.62,190.01 73.3,190.33 72.99,190.33 72.9,190.35 72.85,190.4 72.84,190.4 72.77,190.47 71.17,190.47 71.05,190.6 71.05,190.92 71.05,191.27 71.16,191.39 71.24,191.39 71.29,191.43 71.3,191.44 71.43,191.52 71.52,191.65 71.52,191.66 71.73,191.87 71.73,193.24 71.81,193.32 72.39,193.32 72.44,193.27 72.44,193.05 72.39,193 72.39,191.88 72.44,191.83 72.44,191.82 72.8,191.46 72.82,191.43 72.82,191.36 73.2,191.36 73.31,191.24 73.31,190.94 73.48,190.77 73.95,190.77 74.58,190.14 74.79,190.14 74.94,189.98 75.74,189.98 75.81,189.91 77.61,189.91 77.91,190.2 77.91,192.85 77.83,192.92 77.83,194.02 77.87,194.06 78.48,194.06
GND on TOP (solid shape): 107.66,144.62 107.66,144.21 107.72,144.15 107.78,144.08 107.85,144.02 107.88,144 107.91,144 108.03,143.98 108.16,144 108.19,144 108.22,144.03 108.28,144.08 108.33,144.14 108.52,144.33 108.73,144.33 109.06,144 109.32,144 109.42,143.95 109.52,143.93 109.63,143.95 109.73,144 114.09,144 114.25,143.84 114.25,142.8 114.69,142.36 114.96,142.36 114.96,142.36 115.42,142.36 115.43,142.36 116.3,142.36 116.34,142.36 116.34,142.4 116.57,142.62 116.93,142.62 117.36,142.19 117.36,141.69 117.2,141.54 116.97,141.54 116.83,141.39 116.83,141.38 116.83,141.01 116.82,141.01 116.82,140.9 116.69,140.76 114.71,140.76 114.45,141.02 114.45,141.37 114.03,141.79 112.83,141.79 112.81,141.8 112.79,141.81 112.74,141.87 112.67,141.92 112.61,141.99 108.4,141.99 108.35,142.03 108.35,142.35 108.39,142.51 108.35,142.67 108.35,142.95 108.15,143.15 107.3,143.15 107.05,143.4 107.05,144.6 107.15,144.7 107.59,144.7
GND on TOP (solid shape): 89.52,194.27 89.52,189.62 89.44,189.49 89.41,189.33 89.41,189.28 89.38,189.2 89.31,189.17 89.08,189.17 88.85,189.4 88.85,189.65 88.84,189.7 88.82,189.77 88.82,190.22 88.84,190.28 88.85,190.34 88.85,190.64 88.82,190.76 88.73,190.85 88.72,190.85 88.67,190.91 87.46,190.91 86.76,190.2 85.39,190.2 85.31,190.25 85.3,190.34 85.32,190.42 85.33,190.49 84.92,190.9 84.51,190.49 84.52,190.42 84.54,190.34 84.53,190.25 84.45,190.2 84.15,190.2 83.94,190.42 83.94,192.03 84.26,192.35 86.16,192.35 86.67,192.86 86.67,193.95 87.43,194.71 89.08,194.71
GND on TOP (solid shape): 94.41,186.67 94.41,185.52 94.4,185.47 94.4,185.27 94.41,185.22 94.41,185.12 94.4,185.07 94.4,184.87 94.41,184.82 94.41,184.72 94.4,184.67 94.4,184.47 94.44,184.36 94.49,184.33 94.54,184.28 94.55,184.28 94.55,184.27 95.24,184.27 95.25,184.26 95.25,184.09 95.24,184.07 94.55,184.07 94.55,184.07 94.49,184.07 94.41,183.98 94.41,183.92 94.4,183.87 94.4,183.67 94.41,183.62 94.41,183.56 94.34,183.56 94.34,181.27 94.08,181.01 93.78,181.01 93.75,181.04 93.25,181.04 93.19,181.1 93.19,181.8 93.24,181.85 93.37,181.85 93.39,181.87 93.39,182.07 93.45,182.13 93.45,183.65 93.42,183.69 93.42,183.87 93.41,183.92 93.39,183.96 93.39,183.98 93.41,184.02 93.42,184.07 93.42,184.67 93.41,184.72 93.39,184.76 93.39,184.78 93.41,184.83 93.45,184.87 93.45,186.17 93.01,186.61 93.01,186.76 92.92,186.85 92.39,186.85 92.27,186.97 92.27,187.35 92.34,187.42 93.66,187.42
GND on TOP (solid shape): 177.75,98.86 177.8,98.81 177.87,98.8 178.25,98.8 178.32,98.81 178.37,98.86 178.38,98.88 178.47,98.88 178.48,98.86 178.54,98.81 178.6,98.8 178.98,98.8 179.05,98.81 179.11,98.86 179.12,98.88 179.2,98.88 179.22,98.86 179.27,98.81 179.34,98.8 179.72,98.8 179.79,98.81 179.84,98.86 179.86,98.88 179.94,98.88 179.96,98.86 180.01,98.81 180.08,98.8 180.46,98.8 180.53,98.81 180.58,98.86 180.59,98.88 180.83,98.88 180.84,98.86 180.9,98.81 180.97,98.8 181.35,98.8 181.41,98.81 181.47,98.86 181.48,98.88 181.72,98.88 181.73,98.86 181.79,98.81 181.85,98.8 182.24,98.8 182.3,98.81 182.36,98.86 182.37,98.88 182.61,98.88 182.62,98.86 182.68,98.81 182.74,98.8 183.02,98.8 183.15,98.66 183.15,98.14 182.46,97.45 181.82,97.45 181.8,97.43 177.63,97.43 177.13,97.94 177.13,98.8 177.51,98.8 177.58,98.81 177.63,98.86 177.65,98.88 177.73,98.88
GND on TOP (solid shape): 15.72,101.93 15.72,100.46 14.81,99.54 14.81,96.64 15.67,95.77 15.67,95.01 15.34,94.68 13.54,94.68 13.26,94.97 13.26,96.52 12.51,97.49 11.38,97.03 9.4,97.03 8.94,96.87 8.67,96.47 8.66,96.43 3.86,96.43 3.86,99.91 8.66,99.91 8.67,99.87 8.94,99.47 9.4,99.31 11.38,99.31 12.51,98.85 13.26,99.82 13.26,102.27 13.36,102.36 15.28,102.36
GND on TOP (solid shape): 13.45,119.43 13.45,116.52 15.5,114.46 15.5,112.79 14.53,111.82 14.19,111.82 14.15,111.82 14.11,111.84 13.87,111.97 13.6,112.02 13.49,112.01 13.39,111.99 13.3,112.01 13.26,112.09 13.26,114.62 12.51,115.59 11.38,115.13 9.4,115.13 8.94,114.97 8.67,114.57 8.66,114.53 2.51,114.53 2.51,119.27 7.72,119.27 8.96,118.7 9.81,119.78 9.81,122.15 10.73,122.15
GND on TOP (solid shape): outline of 107 points within 157.05,115.06 162.37,121.21
GND on TOP (solid shape): 166.52,146.4 166.6,146.36 166.62,146.27 166.61,146.21 166.6,146.15 166.65,145.96 166.78,145.81 166.8,145.8 166.8,145.74 166.79,145.73 166.73,145.62 166.71,145.5 166.74,145.37 166.81,145.25 166.81,145.07 166.78,145.01 166.78,144.95 166.78,144.65 166.78,144.59 166.81,144.53 166.81,144.3 166.71,144.3 166.6,144.25 166.56,144.14 166.56,143.76 166.6,143.65 166.71,143.61 166.79,143.61 166.81,143.6 166.81,142.86 167.11,142.56 167.11,140.16 166.99,140.04 165.54,140.04 165.52,140.06 165.47,140.11 165.4,140.13 164.95,140.13 164.84,140.25 164.84,140.43 164.64,140.63 163.22,140.63 162.88,140.29 162.88,139.86 162.81,139.79 162.3,139.79 162.21,139.88 162.21,140.43 162.14,140.5 162.14,140.51 162.1,140.64 162.02,140.74 161.93,140.83 161.93,141.7 161.85,141.8 161.82,141.82 161.17,142.47 161.18,142.56 161.18,143.49 161.17,143.54 161.16,143.6 161.16,144.02 160.63,144.55 160.63,145.03 160.74,145.14 164.1,145.14 164.31,145.36 164.31,145.63 164.32,145.67 164.32,145.71 164.32,146.01 164.32,146.05 164.31,146.09 164.31,146.2 164.5,146.4
GND on TOP (solid shape): 15.83,83.05 15.83,81.61 15.82,81.59 15.82,80.5 11.48,76.17 11.48,73 10.77,72.29 8.79,72.29 8.66,72.16 8.66,71.72 8.89,71.49 8.89,70.94 8.68,70.72 8.18,70.72 7.4,70.76 7,70.1 7,70.04 7.01,69.94 7.03,69.84 7.03,69.56 6.95,69.48 6.01,69.48 5.88,69.55 5.73,69.58 5.71,69.58 5.64,69.61 5.61,69.68 5.61,71.37 4.86,72.34 3.73,71.88 1.01,71.88 1.01,78.63 3.73,81.81 8.66,81.81 8.67,81.77 8.94,81.37 9.4,81.21 11.38,81.21 12.51,80.75 13.26,81.72 13.26,83.66 15.21,83.66
GND on TOP (solid shape): outline of 84 points within 183.63,97.43 193.6,98.88
GND on TOP (solid shape): 10.46,195.34 9.76,194.26 8.55,193.83 8.66,193.63 8.74,193.42 11.7,193.42 12.92,192.92 13.42,191.7 13.42,190.57 13.34,190.49 12.59,190.49 12.41,190.67 12.41,191.7 12.2,192.2 11.7,192.41 7.81,192.41 7.81,192.9 7.6,193.4 7.1,193.61 5.7,193.61 5.2,193.4 4.99,192.9 4.99,192.41 1.71,192.41 1.71,193.15 1.41,193.86 0.7,194.16 0.51,194.16 0.51,195.14 3.95,195.14 4.25,194.92 4.62,194.84 6.77,194.84 7.05,194.95 7.27,195.14 7.78,195.14 8.7,194.86 9.43,195.47 9.56,195.6 10.2,195.6
GND on TOP (solid shape): 6.88,63.81 6.88,62.82 7.24,62.45 7.45,62.45 7.76,62.39 8.07,62.45 8.78,62.45 8.9,62.33 8.9,59.54 8.56,59.2 6.52,59.2 5.52,58.21 5.52,57.54 4.93,56.11 3.5,55.52 2.02,55.52 2.02,43.38 2.75,42.71 3.02,41.75 3.02,35.53 2.02,35.53 2.02,31.04 2.3,30.76 4.85,30.76 4.92,30.69 4.99,30.62 4.99,30.33 4.85,30.19 3.86,30.19 3.68,30.24 3.5,30.26 1.01,30.26 1.01,36.54 2.01,36.54 2.01,41.75 1.77,42.32 1.2,42.56 1.01,42.56 1.01,56.54 3.5,56.54 4.21,56.83 4.51,57.54 4.51,59.05 4.21,59.76 3.5,60.05 1.01,60.05 1.01,61.36 3.73,61.36 4.86,60.9 5.61,61.87 5.61,63.37 5.76,63.53 6.01,63.53 6.37,63.89 6.8,63.89
GND on TOP (solid shape): 97.66,186.08 97.73,186.05 97.76,185.97 97.76,185.97 98.17,185.56 98.58,185.97 98.58,185.97 98.61,186.05 98.68,186.08 99.54,186.08 99.88,185.74 99.88,181.48 99.58,181.18 96.92,181.18 96.78,181.32 96.78,181.56 96.79,181.6 96.83,181.62 96.96,181.65 97.08,181.72 97.15,181.75 97.22,181.73 97.34,181.65 97.48,181.63 97.89,182.04 97.48,182.44 97.33,182.41 97.2,182.34 97.14,182.31 97.07,182.33 96.96,182.4 96.84,182.43 96.83,182.43 96.78,182.48 96.78,183.95 97.66,183.95 97.72,183.88 97.92,183.88 97.94,183.85 98.03,183.74 98.17,183.7 98.47,183.7 98.65,183.77 98.72,183.95 98.72,184.23 98.65,184.41 98.47,184.49 98.17,184.49 98.06,184.46 97.97,184.39 97.9,184.35 97.83,184.37 97.21,184.37 97.14,184.4 97.11,184.47 97.11,184.48 97.03,184.72 96.81,184.87 96.78,184.88 96.78,185.49 97.2,185.91 97.2,186 97.28,186.08
GND on TOP (solid shape): outline of 205 points within 9.03,149.99 25.37,154.48
GND on TOP (solid shape): outline of 118 points within 11.94,151.15 26.91,155.16
GND on TOP (solid shape): outline of 122 points within 8.13,152.69 26.91,157.69
GND on TOP (solid shape): outline of 140 points within 8.99,152.06 26.32,156.77
GND on TOP (solid shape): outline of 319 points within 1.01,132.81 14.63,178.29
GND on TOP (solid shape): 35.59,33.83 35.59,26.32 35.16,25.27 34.1,24.83 30.7,24.83 29.74,24.64 28.93,24.1 17.64,12.81 16.92,12.81 13.7,12.81 11.93,12.07 11.19,10.3 11.19,0.51 9.71,0.51 9.71,2.5 9.12,3.92 7.71,4.51 6.28,3.92 5.69,2.5 5.69,0.51 4.21,0.51 4.21,2.1 3.91,2.81 3.2,3.11 1.01,3.11 1.01,4.52 1.09,4.62 1.2,4.56 1.98,3.71 3.1,3.39 3.75,3.49 4.33,3.78 4.62,4.03 4.86,4.32 5.13,4.89 5.22,5.51 5.22,5.99 4.6,7.49 3.1,8.11 2.54,8.04 2.02,7.82 2,7.8 1.54,7.43 1.2,6.94 1.09,6.88 1.01,6.98 1.01,15.16 2.02,15.16 2.02,10.72 2.75,10 10.18,10 10.18,10.3 11.21,12.79 13.7,13.82 17.12,13.82 17.22,13.82 28.21,24.82 29.35,25.58 30.7,25.85 30.78,25.85 31.48,25.15 32.67,25.15 33.37,25.85 34.1,25.85 34.44,25.99 34.58,26.32 34.58,33.61 34.83,33.86 35.56,33.86
GND on TOP (solid shape): outline of 596 points within 45.49,104.66 66.32,110.04
GND on TOP (solid shape): outline of 238 points within 0.51,56.26 236.99,218.99
GND on TOP (solid shape): outline of 1246 points within 103.91,149.91 107.47,166.8
GND on BOTTOM (solid shape): 15.93,134.86 15.93,133.52 15.69,133.29 14.08,133.29 13.76,133.61 13.76,134.24 14.69,135.16 15.63,135.16
GND on BOTTOM (solid shape): 24.24,39.86 24.24,39.53 22.68,37.96 22.38,37.96 22.27,38.08 22.27,39.59 22.59,39.91 24.19,39.91
GND on BOTTOM (solid shape): 89.63,97.6 89.63,96.22 89.17,95.75 85.85,95.75 85.54,96.06 85.54,98.8 85.75,99.01 88.22,99.01
GND on BOTTOM (solid shape): 113.75,170.5 113.75,168.66 113.43,168.34 112.73,168.34 112.39,168.68 112.39,170.58 112.65,170.84 113.41,170.84
GND on BOTTOM (solid shape): 116.39,170.48 116.39,168.63 116.14,168.37 115.31,168.37 115,168.67 115,170.62 115.25,170.87 116,170.87
GND on BOTTOM (solid shape): 192.54,127.27 192.54,126.33 192.09,125.88 188.81,125.88 188.67,126.02 188.67,127.32 188.79,127.45 192.36,127.45
GND on BOTTOM (solid shape): 195.28,105.31 195.28,104.34 195.14,104.2 194.43,104.2 194.33,104.3 194.33,105.4 194.36,105.43 195.15,105.43
GND on BOTTOM (solid shape): 161.8,130.48 161.8,129.31 161.75,129.26 161.75,128.72 161.7,128.67 160.02,128.67 159.93,128.76 159.93,130.46 160.61,131.14 161.14,131.14
GND on BOTTOM (solid shape): 149.76,184.91 149.76,183.64 149.25,183.13 146.1,183.13 146.1,183.74 145.82,184.02 145.82,184.09 145.69,184.22 145.69,185.11 145.87,185.29 149.38,185.29
GND on BOTTOM (solid shape): 136.66,174.85 136.66,174.35 137.1,173.92 138.76,173.92 138.88,173.8 138.88,171.06 138.73,170.91 135.84,170.91 135.57,171.18 135.57,174.81 135.66,174.9 136.61,174.9
GND on BOTTOM (solid shape): 134.26,211.8 134.26,207.55 134.08,207.37 132.13,207.37 132.06,207.44 132.06,208.94 132.48,209.37 132.55,209.44 132.55,211.74 132.72,211.91 134.16,211.91
GND on BOTTOM (solid shape): 103.42,107.58 103.42,107.29 103.68,107.03 103.68,106.24 103.1,105.66 102.1,105.66 101.74,106.02 100.18,106.02 100.1,106.09 100.1,106.57 100.26,106.72 100.8,106.72 101.73,107.65 103.35,107.65
GND on BOTTOM (solid shape): 123.08,122.97 123.19,122.97 123.47,122.69 123.47,121.84 122.58,120.95 122.45,120.95 122.24,121.16 122.24,121.42 122.07,121.59 122.07,122.6 122.33,122.86 122.33,123.49 122.36,123.52 122.52,123.52
GND on BOTTOM (solid shape): 123.15,166.11 123.15,164.84 122.97,164.67 122.94,164.65 122.92,164.64 122.76,164.64 121.87,165.53 121.21,165.53 121.08,165.66 121.08,165.93 121.55,166.41 122.85,166.41
GND on BOTTOM (solid shape): 147.65,120.77 147.65,120.39 147.6,120.34 147.15,120.34 146.79,119.99 146.79,118.64 146.38,118.23 142.88,118.23 142.32,118.79 142.32,119.68 142.62,119.99 143.69,119.99 144.53,120.82 147.6,120.82
GND on BOTTOM (solid shape): 73.83,174.51 73.89,174.46 73.97,174.45 74.37,174.45 75.02,173.8 75.02,170.22 74.87,170.06 70.49,170.06 70.42,170.14 70.42,175.31 71.14,176.04 72.3,176.04
GND on BOTTOM (solid shape): 172,132.44 173.29,132.44 173.38,132.36 173.38,132.03 173.13,131.77 173.13,130.35 173.03,130.25 171.48,130.25 171,130.73 171,131.42 171.39,131.81 171.39,132.47 171.5,132.58 171.83,132.58 171.85,132.6
GND on BOTTOM (solid shape): 229.88,99.15 230.68,99.15 230.81,99.02 230.82,99.01 230.85,98.93 230.89,98.86 230.89,98.62 229.52,97.25 227.49,97.25 227.39,97.34 227.39,99.13 227.81,99.55 229.48,99.55
GND on BOTTOM (solid shape): 13.55,57.2 13.55,50.46 13.44,50.35 12.05,50.35 12.04,50.35 8.91,50.35 8.7,50.55 8.7,52.31 8.85,52.46 9.58,52.46 9.77,52.65 9.77,53.88 10.51,54.62 10.51,57.25 10.7,57.45 13.3,57.45
GND on BOTTOM (solid shape): 195,103.27 195,102.2 195.01,102.19 195.01,101.6 194.84,101.42 194.84,100.39 194.77,100.32 194.26,100.32 194.24,100.34 194.24,101.65 193.53,102.36 192.38,102.36 192.28,102.46 192.28,103.22 192.38,103.32 194.95,103.32
GND on BOTTOM (solid shape): 113.92,104.34 113.92,100.64 113.91,100.63 113.88,100.54 113.87,100.45 113.87,100.4 113.89,100.35 113.89,100.32 113.75,100.17 111.51,100.17 111.29,100.39 111.29,104.34 111.37,104.42 113.84,104.42
GND on BOTTOM (solid shape): 116.14,207.61 116.14,206.41 115.96,206.24 115.14,206.17 115.14,205.65 115.05,205.57 114.66,205.57 114.59,205.64 114.59,205.88 114.22,206.24 113.69,206.24 113.58,206.35 113.58,207.59 113.71,207.72 116.02,207.72
GND on BOTTOM (solid shape): 51.84,188.57 51.84,185.67 52,185.52 54.18,185.52 54.71,184.98 54.71,182.67 54.33,182.67 54.29,182.68 54.05,182.68 53.04,183.69 49.46,183.69 49.08,184.07 49.08,188.86 49.08,189.2 51.21,189.2
GND on BOTTOM (solid shape): 107.62,188.12 109.1,188.12 109.16,188.07 109.15,187.95 109.15,187.9 109.15,187.86 109.16,187.8 109.16,186.69 108.9,186.43 105.96,186.43 105.74,186.64 105.74,188.1 105.88,188.24 107.5,188.24
GND on BOTTOM (solid shape): 146.86,208.16 146.86,208.01 147.03,207.85 148.23,207.85 148.49,207.58 148.49,203.96 148.23,203.7 146.21,203.7 146.08,203.84 146.08,204.38 146.33,204.63 146.33,207.67 146.18,207.82 145.75,207.82 145.65,207.92 145.65,208.13 145.77,208.25 146.77,208.25
GND on BOTTOM (solid shape): 22.14,168.02 22.14,163.51 21.74,163.11 18.3,163.11 18.03,163.38 18.03,163.84 17.55,164.31 13.57,164.31 13.24,164.64 13.24,165.38 13.64,165.78 14.1,165.78 14.71,165.17 17.41,165.17 17.65,165.41 17.65,167.91 17.87,168.13 22.03,168.13
GND on BOTTOM (solid shape): 92.41,196.21 92.41,195.45 92.41,195.45 91.99,195.04 89.11,195.04 89.01,194.95 88.98,194.92 88.96,194.89 88.83,194.76 88.83,193.57 88.29,193.04 88.29,191.18 88.14,191.03 87.18,191.03 86.92,191.28 86.92,195.6 87.48,196.16 89.11,196.16 89.31,196.36 92.26,196.36
GND on BOTTOM (solid shape): 186.23,125.29 186.23,123.87 186.18,123.77 186.17,123.66 186.17,123.59 186.19,123.53 186.2,123.5 186.09,123.39 185.05,123.39 184.96,123.47 184.65,123.47 184.65,123.5 183.17,123.5 183.11,123.55 183.11,125.24 183.25,125.37 186.14,125.37
GND on BOTTOM (solid shape): 156.65,117.65 155.69,116.69 154.37,116.69 154.27,116.79 154.27,117.18 154.4,117.31 154.4,118.09 154.49,118.17 154.85,118.17 154.94,118.08 154.94,117.98 155.2,117.73 155.42,117.73 155.63,117.73 155.91,118.01 155.91,118.23 156.65,118.23
GND on BOTTOM (solid shape): 47.35,188.11 47.35,187.04 47.04,186.74 44.71,186.74 44.28,186.31 43.61,186.31 43.36,186.56 43.36,188.19 43.45,188.28 43.65,188.08 43.71,188.04 43.79,188.02 45.16,188.02 45.24,188.04 45.31,188.08 45.56,188.34 47.12,188.34
GND on BOTTOM (solid shape): 141.55,125.77 142.34,125.77 142.34,125.52 141.55,125.52 141.55,125.27 142.34,125.27 142.34,125.02 141.55,125.02 141.55,124.77 142.34,124.77 142.34,124.52 141.55,124.52 141.55,124.27 142.34,124.27 142.34,124.05 142.19,123.9 142.19,121.51 142.1,121.42 140,121.42 139.42,121.99 139.42,124.99 140.21,125.78 141.55,125.78
GND on BOTTOM (solid shape): 229.26,104.36 229.26,102.08 229.04,101.86 228.23,101.86 228.01,102.08 228.01,102.6 229.01,102.6 229.01,103.74 228.76,103.74 228.76,102.6 228.51,102.6 228.51,103.74 228.26,103.74 228.26,102.6 228.01,102.6 228.01,104.33 228.2,104.52 229.11,104.52
GND on BOTTOM (solid shape): 78.3,98.46 78.45,98.35 78.63,98.31 78.78,98.34 78.91,98.43 78.95,98.46 82.82,98.46 83.32,97.97 83.32,95.52 83.13,95.33 77.22,95.33 77.07,95.48 77.07,97.67 77.87,98.46
GND on BOTTOM (solid shape): 140.97,152.16 140.97,151.07 141.18,150.86 142.04,150.86 142.19,150.71 142.19,148.96 142.89,148.25 142.89,145.53 143.16,145.27 143.16,145.02 142.73,144.58 142.73,143.41 142.6,143.28 141.24,143.28 141.13,143.39 141.12,143.39 141.03,143.48 141.03,149.11 140.63,149.52 139.33,149.52 139.25,149.6 139.25,152.2 139.27,152.22 140.91,152.22
GND on BOTTOM (solid shape): 152.52,165.8 152.52,165.7 152.39,165.56 152.39,165.45 152.31,165.38 152.31,164.91 152.39,164.83 152.39,164.5 152.61,164.28 152.61,163.11 151.57,162.07 151.57,161.39 151.49,161.31 151.03,161.31 150.93,161.41 150.93,162.29 150.93,162.3 150.65,162.58 150.32,162.58 150.24,162.66 150.24,165.94 150.4,166.09 152.24,166.09
GND on BOTTOM (solid shape): 138.4,210.48 138.4,209.59 138.29,209.48 138.29,207.44 138.21,207.36 136.23,207.36 136.07,207.52 136.07,207.82 136.07,207.87 136.05,207.93 136.05,208.55 136.07,208.61 136.07,208.66 136.07,208.96 136.07,209.01 136.05,209.07 136.05,210.51 136.11,210.57 138.31,210.57
GND on BOTTOM (solid shape): 75.55,180.5 75.55,179.64 75.92,179.27 77.54,179.27 77.71,179.1 77.71,178.74 77.57,178.6 76.54,178.6 76.46,178.68 75.64,178.68 75.5,178.78 75.34,178.81 75.22,178.8 75.11,178.74 74.9,178.96 74.9,180.6 74.91,180.61 75.44,180.61
GND on BOTTOM (solid shape): 221.1,111.68 221.1,107.96 221.07,107.95 220.9,107.83 220.81,107.63 220.81,107.62 220.26,107.06 219.31,107.06 218.92,107.45 218.92,108.53 219.44,109.05 219.44,109.58 219.48,109.63 220.05,109.63 220.08,109.66 220.27,109.66 220.45,109.83 220.45,111.69 220.62,111.86 220.93,111.86
GND on BOTTOM (solid shape): 138.68,112.23 139.4,112.23 139.49,112.14 139.49,111.34 139.42,111.27 139.4,111.27 139.13,111.15 139.01,110.87 139.01,110.85 138.63,110.47 137.57,110.47 136.59,111.45 135.07,111.45 134.93,111.59 134.93,112.43 135.01,112.51 138.41,112.51
GND on BOTTOM (solid shape): 31.28,192.3 32.42,192.3 32.54,192.18 32.54,191.35 32.78,191.11 33.97,191.11 34.2,191.34 34.82,191.34 35.12,191.04 35.35,191.04 35.38,191.03 35.41,191.03 35.71,191.03 35.74,191.03 35.82,191.04 35.83,191.04 37.81,191.04 37.99,190.86 37.99,190.04 37.76,189.82 30.06,189.82 29.67,190.21 29.67,192.23 29.84,192.4 31.19,192.4
GND on BOTTOM (solid shape): 153.62,118.94 153.62,114.94 153.32,114.64 152.49,114.64 152.43,114.7 152.43,115.47 152.31,115.58 152.29,115.58 152.28,115.59 152.15,115.67 152,115.7 151.85,115.67 151.72,115.59 151,115.59 150.89,115.69 150.89,117.43 151.39,117.93 151.39,118.82 151.68,119.11 153.11,119.11 153.13,119.12 153.44,119.12
GND on BOTTOM (solid shape): 34.07,69.14 34.07,66.88 33.99,66.81 33.41,66.81 32.69,66.09 29.52,66.09 29.44,66.09 29.41,66.08 29.11,66.08 29.09,66.09 28.3,66.09 28.27,66.08 27.97,66.08 27.88,66.18 27.88,67.27 28.23,67.62 29.34,67.62 29.64,67.92 30.57,67.92 30.75,67.74 30.76,67.74 30.8,67.7 32.17,67.7 32.85,68.39 32.87,68.39 33.7,69.22 33.98,69.22
GND on BOTTOM (solid shape): 46.71,170.66 46.79,170.61 46.8,170.52 46.77,170.44 46.76,170.35 46.76,170.31 46.77,170.24 46.52,169.98 45.61,169.98 45.59,170 45.57,170.03 45.54,170.05 45.51,170.06 45.51,170.2 44.07,170.2 44.07,170.45 45.51,170.45 45.51,170.59 45.54,170.6 45.57,170.62 45.59,170.64 45.61,170.66
GND on BOTTOM (solid shape): 149.19,128.65 149.19,127.09 149.61,126.66 149.61,125.29 149.78,125.11 152.09,125.11 152.27,124.94 152.27,123.83 152.1,123.66 150.2,123.66 150.07,123.68 149.93,123.66 149.8,123.66 149.32,124.15 148.26,124.15 148.15,124.26 148.15,124.79 148.19,124.83 148.82,124.83 148.83,124.85 148.83,125.88 148.65,126.07 148.65,126.58 148.26,126.97 148.25,126.97 148.08,127.15 148.08,128.68 148.16,128.77 149.06,128.77
GND on BOTTOM (solid shape): 37.75,97.16 37.75,91.56 37.04,90.86 35.81,90.86 35.73,90.89 35.7,90.96 35.71,91.13 35.71,91.3 35.57,92.58 35.13,93.78 35.12,93.79 35.12,95.9 35.12,95.92 35.14,95.95 35.14,97.67 35.65,98.18 36.73,98.18
GND on BOTTOM (solid shape): 46.27,155.02 46.26,154.95 46.26,154.91 46.28,154.77 46.36,154.66 46.38,154.54 46.29,154.48 45.61,154.48 45.59,154.5 45.57,154.53 45.54,154.55 45.51,154.56 45.51,154.7 43.83,154.7 43.83,154.86 43.91,154.95 45.51,154.95 45.51,155.09 45.54,155.1 45.57,155.12 45.59,155.14 45.61,155.16 46.13,155.16
GND on BOTTOM (solid shape): 21.67,69.8 21.67,69.21 21.63,69.17 21.1,69.17 20.88,68.96 20.88,67.55 20.27,66.94 16.35,66.94 16.14,67.16 16.14,68.03 16.16,68.04 16.21,68.1 16.23,68.17 16.23,68.6 16.19,68.71 16.08,68.76 16.07,68.76 16.05,68.77 15.41,68.77 15.25,68.93 15.25,69.24 15.31,69.31 16.82,69.31 16.87,69.31 16.93,69.33 16.98,69.33 17.43,69.78 17.43,70.25 17.64,70.46 21,70.46
GND on BOTTOM (solid shape): 74.51,191.5 74.62,191.44 74.74,191.42 74.8,191.43 74.83,191.39 74.83,191.31 74.83,191.31 74.83,190.35 74.83,190.33 74.83,189.95 74.83,189.92 74.83,189.87 75.02,189.68 76.88,189.68 77.03,189.84 77.12,189.84 77.41,189.55 77.41,188.91 77.09,188.59 76.43,188.59 76.17,188.68 75.91,188.59 74.32,188.59 74.05,188.86 74.05,191.41 74.14,191.5
GND on BOTTOM (solid shape): 133.47,120.65 133.54,120.64 133.62,120.65 133.7,120.67 133.86,120.67 133.94,120.59 133.94,120.27 135.13,119.07 135.13,118.71 135.12,118.64 135.11,118.58 135.12,118.51 135.13,118.44 135.13,117.95 135.12,117.88 135.11,117.81 135.12,117.76 134.97,117.61 132.52,117.61 132.52,118.46 132.37,118.61 132.37,118.95 132.36,119.07 132.07,119.37 132.07,120.31 132.42,120.67 133.39,120.67
GND on BOTTOM (solid shape): 71.17,190.6 71.17,190.19 70.83,190.19 70.36,189.72 70.36,188.31 70.24,188.19 69.3,188.19 69.24,188.25 69.24,188.64 69.39,188.79 69.43,188.84 69.45,188.91 69.45,188.92 69.47,188.94 69.47,189.14 69.46,189.15 69.46,189.75 69.6,189.89 69.65,190.09 69.6,190.29 69.46,190.44 69.46,190.62 69.54,190.7 71.03,190.7 71.06,190.72
GND on BOTTOM (solid shape): 161.99,155.37 162.57,154.8 162.63,154.8 162.63,154.79 163.44,154.79 163.44,154.54 162.63,154.54 162.63,154.29 163.44,154.29 163.44,154.04 162.63,154.04 162.63,153.79 163.44,153.79 163.44,153.54 162.63,153.54 162.63,153.29 163.44,153.29 163.44,151.58 163.12,151.25 163.12,150.19 162.89,149.96 161.9,149.96 161.65,150.21 160.68,150.21 160.48,150.42 160.48,150.43 160.36,150.66 160.13,150.78 160.11,150.78 159.13,151.76 159.13,154.45 159.59,154.91 159.59,156.38 159.85,156.64 160.72,156.64
GND on BOTTOM (solid shape): 166.87,165.92 167.01,165.76 167.21,165.71 167.41,165.76 167.55,165.92 168.06,165.92 168.45,162.59 169.15,159.31 169.15,159.31 169.15,159.1 168.98,158.92 167.79,158.92 167.52,159.2 167.52,159.98 166.65,160.85 166.65,165.75 166.82,165.92
GND on BOTTOM (solid shape): 43.73,125.1 43.75,125.09 43.75,124.95 45.51,124.95 45.51,125.09 45.69,125.09 45.82,124.96 46,124.92 46.1,124.93 46.19,124.97 46.27,124.99 46.33,124.94 46.36,124.89 45.95,124.48 45.61,124.48 45.59,124.5 45.57,124.53 45.54,124.55 45.51,124.56 45.51,124.7 43.75,124.7 43.75,124.65 43.53,124.65 43.43,124.55 43.18,124.55 43.08,124.65 43.08,125.03 43.15,125.1
GND on BOTTOM (solid shape): 128.37,165.4 128.37,163.73 129.01,163.09 129.93,163.09 129.97,163.09 130.01,163.09 132.08,163.09 132.25,163.27 133.07,163.27 133.62,162.72 133.62,161.77 133.51,161.66 133.02,161.66 132.96,161.65 132.9,161.62 132.88,161.62 132.75,161.62 131.71,160.58 129.29,160.58 129.25,160.58 129.22,160.59 129.18,160.58 129.15,160.58 128.42,160.58 127.75,159.91 127.17,159.91 127.12,159.86 126.82,159.86 126.74,159.94 126.74,163.97 126.94,164.17 126.94,165.24 126.72,165.46 126.02,165.46 125.95,165.53 125.95,166.29 126.04,166.37 127.39,166.37
GND on BOTTOM (solid shape): 45.51,151.49 45.54,151.53 45.59,151.52 45.64,151.48 45.69,151.44 45.75,151.43 46.13,151.43 46.35,151.21 46.33,151.14 46.33,151.1 46.35,150.98 46.42,150.87 46.43,150.76 46.34,150.7 45.87,150.7 45.64,150.94 45.61,150.96 45.58,151.01 45.54,151.05 45.51,151.06 45.51,151.2 43.83,151.2 43.83,151.45 45.51,151.45
GND on BOTTOM (solid shape): 81.4,186.24 81.4,184.56 81.21,184.38 76.46,184.38 76.3,184.22 76.3,184.2 75.67,183.56 71.82,183.56 71.56,183.66 71.29,183.56 68.92,183.56 68.18,182.82 68.18,182.48 67.99,182.3 67.51,182.3 67.4,182.41 67.4,184.66 68.21,185.47 71.47,185.47 71.78,185.15 71.78,184.35 71.87,184.26 71.94,184.2 71.95,184.2 72.67,184.2 72.67,184.2 75.42,184.2 75.57,184.35 75.57,185.11 75.9,185.44 78.51,185.44 79.07,186 79.07,186.31 79.12,186.36 81.28,186.36
GND on BOTTOM (solid shape): 111.31,195.35 111.31,194.43 111.45,194.28 112.48,194.28 112.62,194.42 112.62,195.21 112.77,195.37 113.29,195.37 113.41,195.24 113.41,193.01 113.15,192.75 113.14,192.75 113.07,192.7 113.04,192.63 113.03,192.63 108.05,192.63 107.8,192.38 107.8,192.22 107.5,191.92 105.71,191.92 105.5,192.12 105.5,193.26 105.53,193.34 105.54,193.42 105.53,193.49 105.5,193.58 105.5,193.94 105.53,194.03 105.54,194.1 105.53,194.18 105.5,194.26 105.5,194.67 106.31,195.48 111.18,195.48
