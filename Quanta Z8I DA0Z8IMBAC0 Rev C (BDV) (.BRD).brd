# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Nets (continued)
M_A_DQ36: JDIM1.170 U1.AN37
M_A_DQ37: JDIM1.169 U1.AN36
M_A_DQ38: JDIM1.182 U1.AR36
M_A_DQ39: JDIM1.187 U1.AR37
M_A_DQ40: JDIM1.190 U1.AU35
M_A_DQ41: JDIM1.194 U1.AU34
M_A_DQ42: JDIM1.208 U1.AW35
M_A_DQ43: JDIM1.203 U1.AW34
M_A_DQ44: JDIM1.191 U1.AU37
M_A_DQ45: JDIM1.195 U1.AU36
M_A_DQ46: JDIM1.204 U1.AW36
M_A_DQ47: JDIM1.207 U1.AW37
M_A_DQ48: JDIM1.215 U1.BA35
M_A_DQ49: JDIM1.212 U1.BA34
M_A_DQ50: JDIM1.225 U1.BC35
M_A_DQ51: JDIM1.224 U1.BC34
M_A_DQ52: JDIM1.211 U1.BA37
M_A_DQ53: JDIM1.216 U1.BA36
M_A_DQ54: JDIM1.228 U1.BC36
M_A_DQ55: JDIM1.229 U1.BC37
M_A_DQ56: JDIM1.237 U1.BE35
M_A_DQ57: JDIM1.232 U1.BE34
M_A_DQ58: JDIM1.246 U1.BG35
M_A_DQ59: JDIM1.245 U1.BG34
M_A_DQ60: JDIM1.236 U1.BE37
M_A_DQ61: JDIM1.233 U1.BE36
M_A_DQ62: JDIM1.250 U1.BG36
M_A_DQ63: JDIM1.249 U1.BG37
M_A_DQSN0: JDIM1.11 U1.C27
M_A_DQSN1: JDIM1.32 U1.D31
M_A_DQSN2: JDIM1.53 U1.J35
M_A_DQSN3: JDIM1.74 U1.P34
M_A_DQSN4: JDIM1.177 U1.AP35
M_A_DQSN5: JDIM1.198 U1.AV34
M_A_DQSN6: JDIM1.219 U1.BB35
M_A_DQSN7: JDIM1.240 U1.BF34
M_A_DQSN8: JDIM1.95 R232.1
M_A_DQSP0: JDIM1.13 U1.D27
M_A_DQSP1: JDIM1.34 U1.C31
M_A_DQSP2: JDIM1.55 U1.J34
M_A_DQSP3: JDIM1.76 U1.P35
M_A_DQSP4: JDIM1.179 U1.AP34
M_A_DQSP5: JDIM1.200 U1.AV35
M_A_DQSP6: JDIM1.221 U1.BB34
M_A_DQSP7: JDIM1.242 U1.BF35
M_A_DQSP8: JDIM1.97 R231.1
M_A_PARITY: JDIM1.143 U1.W31
M_A_RAS#: JDIM1.152 U1.Y32
M_A_WE#: JDIM1.151 U1.AC31
M_B_A0: JDIM02.144 U1.AG36
M_B_A1: JDIM02.133 U1.AG35
M_B_A2: JDIM02.132 U1.AF34
M_B_A3: JDIM02.131 U1.AG37
M_B_A4: JDIM02.128 U1.AE35
M_B_A5: JDIM02.126 U1.AF35
M_B_A6: JDIM02.127 U1.AE37
M_B_A7: JDIM02.122 U1.AC29
M_B_A8: JDIM02.125 U1.AE36
M_B_A9: JDIM02.121 U1.AB29
M_B_A10: JDIM02.146 U1.AG34
M_B_A11: JDIM02.120 U1.AC28
M_B_A12: JDIM02.119 U1.AB28
M_B_A13: JDIM02.158 U1.AK35
M_B_ACT#: JDIM02.114 U1.W28
M_B_ALERT#: JDIM02.116 U1.Y29
M_B_BG#0: JDIM02.115 U1.W29
M_B_BG#1: JDIM02.113 U1.Y28
M_B_BS#0: JDIM02.150 U1.AJ37
M_B_BS#1: JDIM02.145 U1.AJ36
M_B_CAS#: JDIM02.156 U1.AK34
M_B_CB0: JDIM02.92 R25602.2
M_B_CB1: JDIM02.91 R25603.2
M_B_CB2: JDIM02.101 R25604.2
M_B_CB3: JDIM02.105 R25605.2
M_B_CB4: JDIM02.88 R25606.2
M_B_CB5: JDIM02.87 R25608.2
M_B_CB6: JDIM02.100 R25609.2
M_B_CB7: JDIM02.104 R25610.2
M_B_CKE0: JDIM02.109 U1.T28
M_B_CKE1: JDIM02.110 U1.T29
M_B_CLKN0: JDIM02.139 U1.AF28
M_B_CLKN1: JDIM02.140 U1.AE28
M_B_CLKP0: JDIM02.137 U1.AF29
M_B_CLKP1: JDIM02.138 U1.AE29
M_B_CS#0: JDIM02.149 U1.AL37
M_B_CS#1: JDIM02.157 U1.AL35
M_B_DIM0_ODT0: JDIM02.161 U1.AL36
M_B_DIM0_ODT1: JDIM02.155 U1.AL34
M_B_DQ0: JDIM02.29 U1.J22
M_B_DQ1: JDIM02.37 U1.H25
M_B_DQ2: JDIM02.28 U1.G22
M_B_DQ3: JDIM02.25 U1.H22
M_B_DQ4: JDIM02.42 U1.F25
M_B_DQ5: JDIM02.41 U1.J25
M_B_DQ6: JDIM02.38 U1.G25
M_B_DQ7: JDIM02.24 U1.F22
M_B_DQ8: JDIM02.3 U1.D22
M_B_DQ9: JDIM02.8 U1.C22
M_B_DQ10: JDIM02.20 U1.C24
M_B_DQ11: JDIM02.16 U1.D24
M_B_DQ12: JDIM02.4 U1.A22
M_B_DQ13: JDIM02.7 U1.B22
M_B_DQ14: JDIM02.17 U1.A24
M_B_DQ15: JDIM02.21 U1.B24
M_B_DQ16: JDIM02.49 U1.G31
M_B_DQ17: JDIM02.45 U1.G32
M_B_DQ18: JDIM02.59 U1.H29
M_B_DQ19: JDIM02.58 U1.H28
M_B_DQ20: JDIM02.46 U1.G28
M_B_DQ21: JDIM02.50 U1.G29
M_B_DQ22: JDIM02.63 U1.H31
M_B_DQ23: JDIM02.62 U1.H32
M_B_DQ24: JDIM02.66 U1.L31
M_B_DQ25: JDIM02.71 U1.L32
M_B_DQ26: JDIM02.79 U1.N29
M_B_DQ27: JDIM02.84 U1.N28
M_B_DQ28: JDIM02.67 U1.L28
M_B_DQ29: JDIM02.70 U1.L29
M_B_DQ30: JDIM02.83 U1.N31
M_B_DQ31: JDIM02.80 U1.N32
M_B_DQ32: JDIM02.173 U1.AJ29
M_B_DQ33: JDIM02.169 U1.AJ30
M_B_DQ34: JDIM02.182 U1.AM32
M_B_DQ35: JDIM02.186 U1.AM31
M_B_DQ36: JDIM02.183 U1.AM30
M_B_DQ37: JDIM02.187 U1.AM29
M_B_DQ38: JDIM02.174 U1.AJ31
M_B_DQ39: JDIM02.170 U1.AJ32
M_B_DQ40: JDIM02.190 U1.AR31
M_B_DQ41: JDIM02.194 U1.AR32
M_B_DQ42: JDIM02.204 U1.AV30
M_B_DQ43: JDIM02.208 U1.AV29
M_B_DQ44: JDIM02.195 U1.AR30
M_B_DQ45: JDIM02.191 U1.AR29
M_B_DQ46: JDIM02.207 U1.AV32
M_B_DQ47: JDIM02.203 U1.AV31
M_B_DQ48: JDIM02.212 U1.BA32
M_B_DQ49: JDIM02.211 U1.BA31
M_B_DQ50: JDIM02.229 U1.BD31
M_B_DQ51: JDIM02.228 U1.BD32
M_B_DQ52: JDIM02.216 U1.BA30
M_B_DQ53: JDIM02.215 U1.BA29
M_B_DQ54: JDIM02.225 U1.BD29
M_B_DQ55: JDIM02.224 U1.BD30
M_B_DQ56: JDIM02.236 U1.BG31
M_B_DQ57: JDIM02.233 U1.BG32
M_B_DQ58: JDIM02.249 U1.BK32
M_B_DQ59: JDIM02.245 U1.BK31
M_B_DQ60: JDIM02.237 U1.BG29
M_B_DQ61: JDIM02.232 U1.BG30
M_B_DQ62: JDIM02.246 U1.BK30
M_B_DQ63: JDIM02.250 U1.BK29
M_B_DQSN0: JDIM02.32 U1.H24
M_B_DQSN1: JDIM02.11 U1.C23
M_B_DQSN2: JDIM02.53 U1.G30
M_B_DQSN3: JDIM02.74 U1.L30
M_B_DQSN4: JDIM02.177 U1.AL31
M_B_DQSN5: JDIM02.198 U1.AU31
M_B_DQSN6: JDIM02.219 U1.BC31
M_B_DQSN7: JDIM02.240 U1.BH31
M_B_DQSN8: JDIM02.95 R25611.2
M_B_DQSP0: JDIM02.34 U1.G24
M_B_DQSP1: JDIM02.13 U1.D23
M_B_DQSP2: JDIM02.55 U1.H30
M_B_DQSP3: JDIM02.76 U1.N30
M_B_DQSP4: JDIM02.179 U1.AL30
M_B_DQSP5: JDIM02.200 U1.AU30
M_B_DQSP6: JDIM02.221 U1.BC30
M_B_DQSP7: JDIM02.242 U1.BH30
M_B_DQSP8: JDIM02.97 R25607.2
M_B_PARITY: JDIM02.143 U1.AE34
M_B_RAS#: JDIM02.152 U1.AJ34
M_B_WE#: JDIM02.151 U1.AJ35
MAIND: PC51.1 PQ6.3 PQ9.2 PR59.2 PR2060.1
MAINON: PQ16.2 PR120.1 PR5000.1 PR6016.2 PR6028.2 PR6417.1 PR9268.1 PR9270.1 R890.1 U37.30
MAINON_ON_G: PQ6.2 PQ12.2 PQ14.2 PQ16.3 PQ19.2 PQ9050.2 PR116.2 PR118.1
MBCLK: PC11.1 PD4.1 PR12.2 PR17.1 Q13.3 R361.1 U37.110
MBCLK_THM: Q6564.4 R67858.2 U2.8 U6517.8
MBDATA: PC10.1 PD3.1 PR13.2 PR19.1 Q13.6 R369.1 U37.111
MBDATA_THM: Q6564.1(S) R67857.2 U2.7 U6517.7
MCT1: R516.2 U25.24
MCT2: R517.2 U25.21
MCT3: R518.2 U25.18
MCT4: R519.2 U25.15
MDI0+: U25.9 U6521.13
MDI0+_1: CN8.1 U25.16
MDI0-: U25.8 U6521.14
MDI0-_1: CN8.2 U25.17
MDI1+: U25.12(TD4-) U6521.17
MDI1+_1: CN8.3 U25.13
MDI1-: U25.11 U6521.18
MDI1-_1: CN8.6 U25.14
MDI2+: U25.2 U6521.20
MDI2+_1: CN8.4 U25.23
MDI2-: U25.3 U6521.21
MDI2-_1: CN8.5 U25.22
MDI3+: U25.6 U6521.23
MDI3+_1: CN8.7 U25.19
MDI3-: U25.5 U6521.24
MDI3-_1: CN8.8 U25.20
ME_WR#: R118.1 U37.109
MEM_VREF_CTL_QA: Q20.3 R411.1 R25283.1
MIC2-VREFO: R468.1 R471.1 U20.29
MINICAR_PME#: CN17.55 Q33.1(S) R651.1
MODE: R754.1 R755.2 U30.53
MODE1: R25645.2 R25650.1 R67877.1 U37.35
MODE1_HUB: R25645.1 U6516.A3
MODE2: R25646.2 R25652.1 R67876.1 U37.20
MODE2_HUB: R25646.1 U6516.B2
MODEM_CLKREQ: R679.2 U1.CH29 U36.1 U36.2
MODEM_CLKREQ_L: CN17.14 R678.1 U36.4
MUX_3V: C880.1 C881.2 C912.2 C913.2 R754.2 R756.2 R758.2 R760.2 R762.2 R764.2 R772.2 R842.2 R843.2 R25525.1 U30.14 U30.28 U30.41 U30.56
MX0: C725.1 CN18.10 CN19.10 U37.58
MX1: C727.1 CN18.9 CN19.9 U37.59
MX2: C723.1 CN18.8 CN19.8 U37.60
MX3: C722.1 CN18.7 CN19.7 U37.61
MX4: C720.1 CN18.6 CN19.6 U37.62
MX5: C726.1 CN18.5 CN19.5 U37.63
MX6: C721.1 CN18.4 CN19.4 TP13180.1 U37.64
MX7: C724.1 CN18.3 CN19.3 TP13181.1 U37.65
MY0: C719.1 CN18.26 CN19.26 U37.36
MY1: C716.1 CN18.25 CN19.25 U37.37
MY2: C717.1 CN18.24 CN19.24 U37.38
MY3: C708.1 CN18.23 CN19.23 U37.39
MY4: C718.1 CN18.22 CN19.22 U37.40
MY5: C707.1 CN18.21 CN19.21 U37.41
MY6: C706.1 CN18.20 CN19.20 U37.42
MY7: C709.1 CN18.19 CN19.19 U37.43
MY8: C711.1 CN18.18 CN19.18 U37.44
MY9: C713.1 CN18.17 CN19.17 U37.45
MY10: C714.1 CN18.16 CN19.16 U37.46
MY11: C715.1 CN18.15 CN19.15 U37.51
MY12: C728.1 CN18.14 CN19.14 U37.52
MY13: C729.1 CN18.13 CN19.13 U37.53
MY14: C730.1 CN18.12 CN19.12 U37.54
MY15: C731.1 CN18.11 CN19.11 U37.55
MY16: C732.1 CN18.28 CN19.28 U37.56
MY17: C733.1 CN18.27 CN19.27 U37.57
N12E_SCL: R367.1 U8.C9
N12E_SDA: R368.1 U8.C8
NBSWON#: C6615.2 C96346.1 CN52.4 R720.2 R25314.1 R67861.2 SW5.1 SW5.2 U37.107
NBSWON#_R: CN18.1 CN19.1 D33.2 R720.1
NFC_DWL_REQ: CN58.5 Q6558.1(S) R67563.2 R67567.2
NFC_I2C_SCL: CN58.8 Q6556.1(S) R67568.2 R67570.2
NFC_I2C_SDA: CN58.9 Q6559.1(S) R67564.2 R67571.2
NFC_INT: CN58.11 Q6555.1(S) R67561.2
NFC_RST#: Q6557.3 R67566.1 R67572.2 U1.CN28
NFC_RST#_Q: CN58.6 Q6557.1(S) R67566.2 R67573.2
NFC_SWP: CN58.13 TP13163.1
NGFF_SATA_DET: R134.1 R653.1 U1.CP10
NV_PLLVDD: C457.2 C458.2 L7.2 U8.L6
ODD_PRSNT#: R25475.2 TP13165.1 U1.CP14
PBA_FP_PWREN#: CN52.11 R609.1 U37.76
PCBEEP_EC: D6543.2 U37.34
PCH_AZ_CODEC_BITCLK: C587.2 C96350.1 R187.1 U20.6
PCH_AZ_CODEC_RST#: C216.2 Q21.1(S) R194.1 R738.1
PCH_AZ_CODEC_SDIN0: R191.1 U20.8
PCH_AZ_CODEC_SDOUT: R25374.1 U20.5
PCH_AZ_CODEC_SYNC: R188.1 U20.10
PCH_BLON_C: Q6521.5 R440.2 R25365.2 R25366.2 R25369.1
PCH_BLON_EC: R25366.1 U37.88
PCH_DISP_ON: R445.2 U1.CG11
PCH_DPST_PWM: C2.2 R443.1 U1.CH11
PCH_LVDS_BLON: C1.2 R25365.1 U1.CK11
PCH_OPI_RCOMP: R18.2 U1.BW25
PCH_PWROK: R25357.2 U37.78
PCH_PWROK_R: R25357.1 R25501.1 U1.BP31
PCH_SLP_S0_N: R38.1 R592.1 U1.BJ37
PCH_SPI1_CLK: R88.2 R111.1 R596.1 U1.CH37
PCH_SPI1_CLK_R: C191.1 CN59.6 CN60.6 R111.2 TP15.1 U37.105 U6526.6 U6528.6
PCH_SPI1_CLK_TPM: R596.2 U33.19
PCH_SPI1_SI: R221.2 R597.1 R25667.1 U1.CF36
PCH_SPI1_SI_R: CN59.5 CN60.5 R25303.1 R25667.2 TP16.1 U37.102 U6526.5 U6528.5
PCH_SPI1_SI_TPM: R597.2 U33.21
PCH_SPI1_SO: R108.2 R583.1 R598.1 U1.CF37
PCH_SPI1_SO_R: CN59.2 CN60.2 R108.1 R25316.1 TP17.1 U37.103 U6526.2 U6528.2
PCH_SPI1_SO_TPM: R598.2 U33.24
PCH_SPI_CS0#: R106.2 U1.CG36
PCH_SPI_CS0#_R: CN59.1 CN60.1 R106.1 TP14.1 U37.101 U6526.1 U6528.1
PCH_SPI_IO2: R110.1 R220.1 U1.CF34
PCH_SPI_IO3: R109.1 U1.CG34
PCH_SUSPWRDNACK: R39.2 U37.15
PCIE_CLKREQ_LAN#: Q6531.3 R155.1 R25444.1 R25446.1 U1.CE30
PCIE_CLKREQ_SSD#: CN16.52 R159.1 U1.CE32
PCIE_CLKREQ_VGA#: Q9.3 R25487.1 R25493.1 U1.CF32
PCIE_CLKREQ_WLAN#: Q63.3 R154.1 U1.CF31
PCIE_RCOMP: R139.2 U1.CE6
PCIE_RCOMP_P: R139.1 U1.CE5
PCIE_REQ_LAN#_R: Q6531.1(S) R25445.1 R25446.2 U6521.48
PCIE_RXN9_LAN: C96306.2 U1.BP5
PCIE_RXN10_WLAN: CN17.43 U1.BN6
PCIE_RXN13_SSD: R2652.1 U1.BK6
PCIE_RXN13_SSD_C: CN16.5 R2652.2
PCIE_RXN14_SSD: R2654.1 U1.BJ6
PCIE_RXN14_SSD_C: CN16.17 R2654.2
PCIE_RXN15_SSD: R2656.1 U1.BG5
PCIE_RXN15_SSD_C: CN16.29 R2656.2
PCIE_RXN16_SSD: R646.1 U1.BE5
PCIE_RXN16_SSD_C: CN16.43 R646.2
PCIE_RXN_LAN_L: C96306.1 U6521.39
PCIE_RXP9_LAN: C96307.2 U1.BP6
PCIE_RXP10_WLAN: CN17.41 U1.BN5
PCIE_RXP13_SSD: R2653.1 U1.BK5
PCIE_RXP13_SSD_C: CN16.7 R2653.2
PCIE_RXP14_SSD: R2655.1 U1.BJ5
PCIE_RXP14_SSD_C: CN16.19 R2655.2
PCIE_RXP15_SSD: R2657.1 U1.BG6
PCIE_RXP15_SSD_C: CN16.31 R2657.2
PCIE_RXP16_SSD: R647.1 U1.BE6
PCIE_RXP16_SSD_C: CN16.41 R647.2
PCIE_RXP_LAN_L: C96307.1 U6521.38
PCIE_TXN9_LAN: C200.2 U6521.42
PCIE_TXN9_LAN_C: C200.1 U1.BR2
PCIE_TXN10_WLAN: C203.2 U1.BR4
PCIE_TXN10_WLAN_C: C203.1 CN17.37
PCIE_TXN13_SSD: C788.1 U1.BM4
PCIE_TXN13_SSD_C: C788.2 CN16.11
PCIE_TXN14_SSD: C790.1 U1.BL2
PCIE_TXN14_SSD_C: C790.2 CN16.23
PCIE_TXN15_SSD: C792.1 U1.BL4
PCIE_TXN15_SSD_C: C792.2 CN16.35
PCIE_TXN16_SSD: C794.1 U1.BJ4
PCIE_TXN16_SSD_C: C794.2 CN16.47
PCIE_TXP9_LAN: C201.2 U6521.41
PCIE_TXP9_LAN_C: C201.1 U1.BR1
PCIE_TXP10_WLAN: C202.2 U1.BR3
PCIE_TXP10_WLAN_C: C202.1 CN17.35
PCIE_TXP13_SSD: C789.1 U1.BM3
PCIE_TXP13_SSD_C: C789.2 CN16.13
PCIE_TXP14_SSD: C791.1 U1.BL1
PCIE_TXP14_SSD_C: C791.2 CN16.25
PCIE_TXP15_SSD: C793.1 U1.BL3
PCIE_TXP15_SSD_C: C793.2 CN16.37
PCIE_TXP16_SSD: C795.1 U1.BJ3
PCIE_TXP16_SSD_C: C795.2 CN16.49
PCIE_WAKE#: CN49.9 EC13.1 Q33.3 R33.1 R67506.2 R67883.1 U1.BU30
PD#: C595.1 D12.2 D13.2 R478.1 R479.1 U20.47
PD_ADP_DISCHARGE: PR8015.2 U6511.20 U6523.9
PEDET: CN16.69 Q34.2 R649.2 R654.2
PEG_RXN5: C358.1 U1.BW9
PEG_RXN5_C: C358.2 U8.AB9
PEG_RXN6: C384.1 U1.BU6
PEG_RXN6_C: C384.2 U8.AC10
PEG_RXN7: C6554.1 U1.BT7
PEG_RXN7_C: C6554.2 U8.AC11
PEG_RXN8: C6557.1 U1.BU9
PEG_RXN8_C: C6557.2 U8.AB12
PEG_RXP5: C370.1 U1.BW8
PEG_RXP5_C: C370.2 U8.AC9
PEG_RXP6: C382.1 U1.BU5
PEG_RXP6_C: C382.2 U8.AB10
PEG_RXP7: C6556.1 U1.BT6
PEG_RXP7_C: C6556.2 U8.AD11
PEG_RXP8: C6555.1 U1.BU8
PEG_RXP8_C: C6555.2 U8.AC12
PEG_TXN5: C192.2 U8.AG7
PEG_TXN5_C: C192.1 U1.BW4
PEG_TXN6: C194.2 U8.AE7
PEG_TXN6_C: C194.1 U1.BU4
PEG_TXN7: C6551.2 U8.AF9
PEG_TXN7_C: C6551.1 U1.BU2
PEG_TXN8: C6550.2 U8.AG10
PEG_TXN8_C: C6550.1 U1.BT4
PEG_TXP5: C193.2 U8.AG6
PEG_TXP5_C: C193.1 U1.BW3
PEG_TXP6: C195.2 U8.AF7
PEG_TXP6_C: C195.1 U1.BU3
PEG_TXP7: C6553.2 U8.AE9
PEG_TXP7_C: C6553.1 U1.BU1
PEG_TXP8: C6552.2 U8.AG9
PEG_TXP8_C: C6552.1 U1.BT3
PEGX_RST#: R296.2 R305.2 R306.2 R384.1
PEGX_RST#_C: R305.1 U9.4
PEQ: R762.1 R763.2 U30.8
PEX_CLKREQ#: Q9.1(S) R297.1 R25487.2 U8.AC6
PEX_TERMP: R312.2 U8.AF25
PEX_TSTCLK: R307.2 U8.AF22
PEX_TSTCLK#: R307.1 U8.AE22
PHASE1_CORE: PC7105.1 PL7000.1 PQ7000.5 PQ7000.6 PQ7000.7 PR7072.2 PR7073.1 PU7002.2
PHASE2_CORE: PC7056.1 PL7001.1 PQ7001.5 PQ7001.6 PQ7001.7 PR7081.2 PR7082.1 PU7001.2
PHASE_GT: PC7101.1 PL7003.1 PQ7004.5 PQ7004.6 PQ7004.7 PR7095.2 PR7096.1 PU7003.2
PHASE_SA: PC7103.1 PL7002.1 PQ7002.1 PQ7002.2 PQ7002.3(S3) PQ7003.5 PR7087.2 PR7088.1 PU7004.2
PIRQA#: R179.1 R580.1 R593.1 U1.CC32
PLTRST#: CN49.8 R56.2 R601.1 R648.2 R894.2 R2665.2 U1.BJ35 U9.2 U6521.36
PLTRST#_EC: C2374.1 R894.1 U37.22
PM_EXTTS#0: JDIM1.134 JDIM02.134 R224.2
PMON: PC18.2 PR23.1 PR25.1 PR7039.1
PP: R600.2 U33.4
PROC_POPIRCOMP: R16.1 U1.BP27
PROC_TRST#: R6.2 U1.AB6
PROCHOT#: R9.2 U1.Y4
PROCHOT_EC: C6610.2 Q6509.2 R25298.2 U37.17
PROCPWRGD: C6619.1 R34.2 U1.AR2
PS_FB_CLAMP: R313.1 U8.F3
PULSAR_38P4M_REFCLK: CN17.64 R67868.2
PULSAR_38P4M_REFCLK_R: C204.2 R148.2 R67868.1 U1.CM3
PVADPTR: PC1.1 PC5.1 PD8001.1 PD9002.2 PQ1.5 PQ8006.1 PQ8006.2 PQ8006.3(S3) PQ8007.1 PQ8007.2 PQ8007.3(S3) PR31.1 PR9278.2 PR9279.1
PWM1_CORE: PR7105.1 PU7000.17
PWM2_CORE: PR7077.1 PU7000.16
PWM-VID: PR9015.1 R370.2
PWM_GT: PR7109.1 PU7000.22
PWM_SA: PR7113.1 PU7000.36
PWRLED#: CN48.20 CN52.12 CN55.10 R67484.1 U37.24
R_SPK+: R67367.1 R67403.1 U20.45
R_SPK+_1: C603.1 CN63.1 R67367.2
R_SPK+_2: C96263.1 CN64.1 R67403.2
R_SPK-: R67368.1 R67404.1 U20.44
R_SPK-_1: C604.1 CN63.2 R67368.2
R_SPK-_2: C96264.1 CN64.2 R67404.2
REGN6V: PC9.1 PR39.1 PU1.24
REQ_WLAN#: CN17.53 Q63.1(S) R652.1
RF_EN: CN17.56 R672.1 R25318.2 R25494.1
RF_OFF_PCH: R37.1 U1.BV36
RGND_CORE: PC7008.1 PC7009.1 PR7046.2 PU7000.48
RGND_GT: PC7014.1 PC7015.1 PR7053.2 PU7000.25
RGND_SA: PC7022.1 PC7024.1 PR7062.2 PU7000.44
RING2: C591.2 C96265.1 CN51.2 D13094.1 R471.2 U20.17
ROM_CS: TP67.1 U8.D12
ROM_SCLK: R342.1 R352.2 U8.C12
ROM_SI: R341.1 R350.2 U8.B12
ROM_SO: R343.1 R351.2 U8.A12
RREF: R752.2 U40.1
RSET: R4009.1 R67477.2 U6521.12
RSMRST#: EC1.2 R45.1 R47.2 U1.BR36 U37.112
RTC_RST#: C1217.1 J9007.1 Q22.3 R979.2 U1.BR34
RTC_X1: C206.2 R169.1 U1.BN31 Y1.1
RTC_X2: C209.2 R169.2 U1.BN32 Y1.2
S5_ON: PR566.2 PR6015.1 PR6027.1 R25309.1 U37.100
SATA_LED#: CN16.10 TP2092.1
SATA_RXN0_CN: C6596.1 CN11.16
SATA_RXN0_HDD: C6588.2 U1.BN10
SATA_RXN0_IN: C6588.1 U42.4
SATA_RXN_OUT: C6596.2 U42.12
SATA_RXP0_CN: C6597.1 CN11.15
SATA_RXP0_HDD: C6589.2 U1.BN8
SATA_RXP0_IN: C6589.1 U42.5
SATA_RXP_OUT: C6597.2 U42.11
SATA_TXN0_CN: C6595.1 CN11.18
SATA_TXN0_HDD: C6587.2 U1.BN4
SATA_TXN0_IN: C6587.1 U42.2
SATA_TXN_OUT: C6595.2 U42.14
SATA_TXP0_CN: C6594.1 CN11.19
SATA_TXP0_HDD: C6586.2 U1.BN3
SATA_TXP0_IN: C6586.1 U42.1
SATA_TXP_OUT: C6594.2 U42.15
SATAGP0: R25481.1 U1.CN8
SATAGP1: R25433.1 U1.CM10
SC_PWRSV#: R25557.2 R67606.1 U1.CR28
SCARDC6: CN53.4 U6509.2
SCARDC8: CN53.3 U6509.1
SCARDCLK: CN53.6 U6509.6
SCARDDATA: C20053.1 CN53.5 R25558.1
SCARDFCB: CN53.7 U6509.3
SCARDRST: CN53.8 U6509.5
SCL_GSENSOR: C20137.1 Q6567.6 R25638.2 R67875.2 TP13174.1 U6515.12
SCL_GSENSOR_R: R25636.2 R25638.1 U6516.E5
SCL_SENSOR_HUB: Q6569.6 R25631.2 R25632.2 U6516.C4
SD_1P8_RCOPM: R209.1 U1.CK33 U1.CM34
SD_CDZ: Q6565.3 U40.13
SD_CDZ_R: CN62.11 R67539.2
SD_CLK: R67532.1 U40.15
SD_CLK_R: C1648.1 CN62.6 R67532.2
SD_CMD: C1647.1 R67899.1 U40.18
SD_D0/MS_D6: C1643.1 R67897.1 U40.11
SD_D1/MS_D7: C1644.1 R67898.1 U40.10
SD_D2/MS_D5: C1645.1 R67895.1 U40.21
SD_D3/MS_D4: C1646.1 R67896.1 U40.20
SD_WP/MS_D1: Q6570.3 U40.8
SD_WP/MS_D1_R: CN62.10(WP SW) R67887.2
SDA_GSENSOR: C20136.1 Q6567.3 R25637.2 R67873.2 TP13175.1 U6515.2
SDA_GSENSOR_R: R25635.2 R25637.1 U6516.E4
SDA_SENSOR_HUB: Q6539.3 R25629.2 R25630.2 U6516.C5
SDREG: C1651.1 U40.6
SDVO_CLK: R494.2 R67596.1 R67870.1 U1.CC8
SDVO_CLK_R: R67870.2 U23.7
SDVO_DATA: R502.2 R67595.1 R67869.1 U1.CC9
SDVO_DATA_R: R67869.2 U23.6
SENSEA: R451.1 R452.1 U20.13
SERIRQ: R94.1 R25520.1 U1.BV28 U37.5
SIO_EXT_SCI#: R25436.1 R25448.2 U37.23
SIO_EXT_SMI#: R98.1 U1.CG22
SIO_RCIN#: R100.1 U1.BV29 U37.4
SLEEVE: C590.2 C96268.1 CN51.1 D10.1 R468.2 U20.18
SLP_A#: TP7.1 U1.BU37
SLP_LAN#: R67507.1 U1.BT31
SLP_S5#: TP3.1 U1.BT29
SLP_SUS#_EC: TP9027.1 U1.BU29
SM_RCOMP_0: R28.1 U1.BN28
SM_RCOMP_1: R29.2 U1.BN27
SM_RCOMP_2: R30.1 U1.BN29
SM_VREF: C266.1 R242.1 U1.F36
SMB_ME1_CLK: Q6568.4 R103.2 R67881.1 U1.CN15
SMB_ME1_DAT: Q6568.1(S) R104.2 R67882.1 U1.CM15
SMB_PCH_CLK: Q3.6 R95.1 U1.CK14
SMB_PCH_DAT: Q3.3 R97.1 U1.CH15
SMB_RUN_CLK: JDIM1.253 JDIM02.253 Q3.1(S) R115.2 R25531.2
SMB_RUN_DAT: JDIM1.254 JDIM02.254 Q3.4 R114.2 R25530.2
SMDDR_VREF_DQ1_M3: C20130.1 R67514.1 U1.E36
SML0ALERT#: R119.1 R121.1 U1.CJ15
SML1ALERT#: R123.1 R125.2 U1.CG15
SP2: TP100.1 U40.9
SP5: TP101.1 U40.12
SP7: TP102.1 U40.14
SP9: TP103.1 U40.16
SP11: TP97.1 U40.19
SP14: TP98.1 U40.22
SP_PLLVDD: C459.2 C460.2 C461.1 C462.1 L8.2 R329.1 U8.M6
SPI1_CLK: TP9.1 U1.CF20
SPI1_CS#: TP12.1 U1.CG20
SPI1_IO2: TP10.1 U1.CG23
SPI1_IO3: TP11.1 U1.CH23
SPI_TPM_CS#: R586.1 R599.1 U1.CH34
SPI_TPM_CS#_TPM: R599.2 U33.20
SRTC_RST#: C1211.1 Q6520.3 R971.2 U1.BR37
STRAP0: R344.1 R353.2 U8.D1
STRAP1: R345.1 R354.2 U8.D2
STRAP2: R346.1 R355.2 U8.E4
STRAP3: R347.1 R356.2 U8.E3
STRAP4: R348.1 R357.2 U8.D3
STRAP5: R349.1 R358.2 U8.C1
SUS_STAT#: C6626.1 U1.CA27
SUSACK#: R32.2 TP9018.1 U1.BY32
SUSB#: C5.1 U1.BU36 U37.119 U2014.1
SUSC#: C6.1 U1.BU27 U37.18
SUSCLK_32K: R670.2 U1.BT32
SUSCLK_32KHZ: CN17.50 R670.1
SUSD: PC152.1 PQ11.2 PQ25.3 PR191.2
SUSLED#: CN48.21 CN52.13 CN55.11 R67486.1 U37.28
SUSON: C247.2 PR5012.1 PR9258.1 PR9269.1 PR9271.1 R215.2 R25320.1 TP13167.1 U3.3 U37.120
SUSPWRDNACK: R31.2 R39.1 U1.BV34
SW: R764.1 R765.2 R67597.2 U30.45
SWP_PWR: CN58.4 TP13164.1
SYS_HWPG: D60.1(CATHODE) PR6004.1 PR6022.1 PR8041.1 PR8060.1 U37.124
SYS_PWROK: C7.1 R25359.1 R25362.1 TP5.1 U1.CR10 U6504.4
SYS_RESET#: R43.1 U1.CN10
SYS_SHDN#: PR3022.2 PR6002.1 PR6009.1 PR6020.1 Q86.3 R67418.1 R67422.1 U37.85
TABLET_MODE: CN4.2 R67885.2 U6525.1
TCT1: C645.1 C96313.1 U25.1 U25.4 U25.7 U25.10
TEMP_MBAT#: PR8.1 PR14.2 PR18.1 U37.73
TESTMODE: R311.1 U8.AD9
THERM+: TP68.1 U8.F12(THERMDP)
THERM-: TP69.1 U8.E12
THERMTRIP#: Q86.1(EMITTER) R822.1 R25479.2
THERMTRIP#_CPU: R25479.1 U1.BJ1
TMDS_CLK+: R67378.1 U30.16
TMDS_CLK-: R67377.1 U30.15
TMDS_D0+: R67379.1 U30.19
TMDS_D0-: R67380.1 U30.18
TMDS_D1+: R67381.1 U30.22
TMDS_D1-: R67382.1 U30.21
TMDS_D2+: R67383.1 U30.25
TMDS_D2-: R67384.1 U30.24
TMDS_DDCBUF: R760.1 R761.2 U30.2
TMDS_HPD: R67385.1 U30.17
TMDS_PRE: R756.1 R757.2 U30.20
TMDS_RT: R758.1 R759.2 U30.23
TMDS_SCL: R67376.1 U30.48
TMDS_SDA: R67375.1 U30.47
TP_I2C_CLK: R558.2 R25415.2 U1.CN11
TP_I2C_DATA: R560.2 R25413.2 U1.CM11
TP_INTH#_L: CN33.7 Q29.1(S) R25471.2 R25472.1
TP_SMB_CLK: C699.1 CN33.6 Q27.3 R559.1
TP_SMB_DATA: C698.1 CN33.5 Q27.6 R562.1
TPCLK: L23.1 R566.1 U37.89
TPCLK-1: C696.1 CN33.2 L23.2
TPD_EN: R572.2 R574.1 R895.2
TPD_INT#: R573.1 R25477.1 U1.CN14
TPD_INT#_EC: R25308.2 R25323.1 R25473.1
TPDAT-1: C697.1 CN33.3 L24.2
TPDATA: L24.1 R567.1 U37.90
TPM_LRESET#: R601.2 U33.17
TPM_PIRQ#: R102.1 U1.CF22
TS_EN: R436.2 R956.1
TS_EN_C: C1210.1 R956.2 U37.81
TS_EN_R: CN29.28 R436.1
TS_I2C_SCL: R126.1 U1.CJ12
TS_I2C_SCL_C: R67411.1 TP13177.1
TS_I2C_SDA: R67413.1 U1.CK12
TS_I2C_SDA_C: R67412.1 TP13178.1
TS_INT#: CN29.11 TP13179.1
TS_INT#_L: R67884.1 U1.CM14
TYPEC1_CCG1_CC1: C691.2 C20086.2 CN10.A5 D16.1 U6511.9
TYPEC1_CCG1_CC2: C692.2 C20087.2 CN10.B5 D17.1 U6511.7
TYPEC1_CCG4_VBUS_P_CTRL: R67591.1 R67592.1 U6511.11
TYPEC1_OUT_1-5A: Q6562.2 R67852.2 U37.48
TYPEC1_RX1N: CN10.B10 RV3.2 RV3.9 U12.31
TYPEC1_RX1P: CN10.B11 RV3.1 RV3.10(NC#4) U12.30
TYPEC1_RX2N: CN10.A10 RV2.2 RV2.9 U12.39
TYPEC1_RX2P: CN10.A11 RV2.1 RV2.10(NC#4) U12.40
TYPEC1_SBU1: CN10.A8 D19.1 U12.27
TYPEC1_SBU2: CN10.B8 D18.1 U12.26
TYPEC1_TX1N: C20055.2 CN10.A3 RV2.4 RV2.7
TYPEC1_TX1P: C361.2 CN10.A2 RV2.5 RV2.6
TYPEC1_TX2N: C20057.2 CN10.B3 RV3.4 RV3.7
TYPEC1_TX2P: C20056.2 CN10.B2 RV3.5 RV3.6
TYPEC1_USB0: C282.1 C675.2 C676.2 C96327.1 CN10.A4 CN10.A9 CN10.B4 CN10.B9(VBUS_4) D13096.1 PC8000.1 PD8003.2 PD8007.2 PQ8002.1 PQ8002.2 PQ8002.3(S3) PQ8004.1(S) PR8003.2 PR8004.1 PR8006.1 R206.2 U6523.15
TYPEC1_USB0_EN: R67591.2 U6523.4
TYPEC1_USB0_PD: PQ8002.5 PQ8006.5 PR9281.2
TYPEC_DDI2_HPD: R25578.1 R67890.1 U1.CM6 U12.32 U6511.18
UART2_CTS#: R604.1 U1.CM12
UART2_RTS#: R607.1 U1.CN12
UART2_RXD: R606.1 U1.CR12
UART2_TXD: R605.1 U1.CP12
UGATE1_CORE: PQ7000.1 PR7106.2
UGATE2_CORE: PQ7001.1 PR7078.2
UGATE_GT: PQ7004.1 PR7110.2
UGATE_SA: PQ7002.4 PR7114.2
ULT_EDP_HPD: C6616.2 R1.2 R10880.1 R25467.1 U1.CM7
ULT_EDP_HPD_R: CN29.25 CN29.29 R25467.2 R25522.2
USB2_COMP: R136.1 U1.CC5
USB2_ID: R137.1 U1.CE8
USB2_VBUSSENSE: R138.1 U1.CC6
USB30_RX1+: C518.2 R422.2 U1.CB6
USB30_RX1+_C: CN2.6 R422.1 U6530.2 U6530.9
USB30_RX1-: C513.2 R421.2 U1.CB5
USB30_RX1-_C: CN2.5 R421.1 U6530.1 U6530.10(NC#4)
USB30_RX2+: C526.2 R428.2 U1.BY9
USB30_RX2+_C: CN3.6 R428.1 U6531.2 U6531.9
USB30_RX2-: C523.2 R427.2 U1.BY8
USB30_RX2-_C: CN3.5 R427.1 U6531.1 U6531.10(NC#4)
USB30_RX3+: C20070.1 U1.BY6
USB30_RX3-: C20071.1 U1.BY7
USB30_RX4+: CN48.14 U1.BW5
USB30_RX4-: CN48.13 U1.BW6
USB30_TX1+: C520.1 U1.CA3
USB30_TX1+_C: C520.2 R432.2
USB30_TX1+_C_R: C522.1 CN2.9 R432.1 U6530.5 U6530.6
USB30_TX1-: C519.1 U1.CA4
USB30_TX1-_C: C519.2 R424.2
USB30_TX1-_C_R: C521.1 CN2.8 R424.1 U6530.4 U6530.7
USB30_TX2+: C531.1 U1.CA1
USB30_TX2+_C: C531.2 R430.2
USB30_TX2+_C_R: C533.1 CN3.9 R430.1 U6531.5 U6531.6
USB30_TX2-: C530.1 U1.CA2
USB30_TX2-_C: C530.2 R429.2
USB30_TX2-_C_R: C532.1 CN3.8 R429.1 U6531.4 U6531.7
USB30_TX3+: C20072.1 U1.BY3
USB30_TX3-: C20073.1 U1.BY4
USB30_TX4+: CN48.18 U1.BW1
USB30_TX4-: CN48.17 U1.BW2
USB_BC_ON: U14.4 U37.97
USB_CHARGE_ON: R416.1 U14.5 U37.96
USB_CLT1: U14.6 U37.79
USB_OC0#: C6614.2 R60.1 U1.CK6 U14.13
USB_OC1#: C6613.2 R25439.1 U1.CK5 U15.3
USB_OC2#: C6612.2 R25438.1 U1.CK8 U18.3
USB_OC3#: C96322.2 C96333.2 R25437.1 U1.CK9 U6523.10
USBON#: U15.4 U18.4 U37.99
USBP1+: R25518.2 U1.CE4
USBP1+_R: CN2.3 D13099.2 R25518.1
USBP1-: R25517.2 U1.CE3
USBP1-_R: CN2.2 D13099.1 R25517.1
USBP2+: U1.CE2 U14.3
USBP2+_C: D13100.2 R425.2 U14.10
USBP2+_C_R: CN3.3 R425.1
USBP2-: U1.CE1 U14.2
USBP2-_C: D13100.1 R426.2 U14.11
USBP2-_C_R: CN3.2 R426.1
USBP3+_TPC: R25292.1 U1.CG4
USBP3-_TPC: R67470.1 U1.CG3
USBP4+_DB: R67462.2 R67499.2 U1.CD4
USBP4+_DB_RS232: CN55.8 R67499.1
USBP4+_DB_USB: CN48.10 R67462.1
USBP4-_DB: R67461.2 R67498.2 U1.CD3
USBP4-_DB_RS232: CN55.7 R67498.1
USBP4-_DB_USB: CN48.9 R67461.1
USBP5+_CAM: R25289.1 U1.CG6
USBP5+_CAM_C: CN29.8 R25289.2
USBP5-_CAM: R25288.1 U1.CG5
USBP5-_CAM_C: CN29.7 R25288.2
USBP6+_CR: U1.CC2 U40.3
USBP6-_CR: U1.CC1 U40.2
USBP7+_FP: R67492.1 R67497.2 U1.CG9
USBP7+_FP_P2: CN14.7 EC7.2 R67492.2
USBP7+_FP_P4: CN52.7 EC16.2 R67497.1
USBP7-_FP: R67493.1 R67496.2 U1.CG8
USBP7-_FP_P2: CN14.6 EC8.1 R67493.2
USBP7-_FP_P4: CN52.8 EC17.1 R67496.1
USBP8+_LTE: CN49.19 U1.CB9
USBP8-_LTE: CN49.20 U1.CB8
USBP9+_HUB: R25560.1 U1.CH6
USBP9+_TS: CN29.5 R67411.2 R67414.2
USBP9-_HUB: R25559.1 U1.CH5
USBP9-_TS: CN29.4 R67412.2 R67415.2
USBP10+_BT: CN17.3 U1.CC4
USBP10+_R: R25560.2 U6509.9
USBP10-_BT: CN17.5 U1.CC3
USBP10-_R: R25559.2 U6509.8
USBP_TYPC+_C: CN10.A6 CN10.B6 R25292.2 RV1.1
USBP_TYPC-_C: CN10.A7 CN10.B7 R67470.2 RV1.2
USIM_DET: CN49.11 U37.68
VA2: PC2.1 PQ1.1 PQ1.2 PQ1.3(S3) PQ9054.1 PQ9054.2 PQ9054.3(S3) PR28.1
VADJ1: C558.1 CN29.27 R441.2 R442.1
VADPBL: PQ8001.5 PQ8007.5 PR9280.2
VCONN_5V_P1: U6510.5 U6510.6(OUT#2) U6511.8
VCORE_SENSE: PR7043.1 PR7044.1 U1.AN6
VCORESS_SENSE: PR7045.1 PR7046.1 U1.AN5
VGA_DDC_CLK_RT: C20006.2 CN21.15 ESD4.5 ESD4.6 R25529.2 U67.15
VGA_DDC_DAT_RT: C20004.1 CN21.12 ESD4.1 ESD4.10(NC#4) R25528.2 U67.16
VGA_DDI2_AUXN_C: C20014.2 U67.3
VGA_DDI2_AUXP_C: C20015.2 U67.2
VGA_DDI2_TXN0_C: C20017.2 U67.6
VGA_DDI2_TXN1_C: C20019.2 U67.8
VGA_DDI2_TXP0_C: C20016.2 U67.5
VGA_DDI2_TXP1_C: C20018.2 U67.7
VGA_OVT#: Q15.1(S) R395.1 U8.A6
VGA_RST#: C364.1 R296.1 U8.AC7
VGA_SDA: R458.2 R25530.1 U67.29
VGA_SLK: R25531.1 R25533.2 U67.30
VGA_VCCSENSE: PR9026.2 PR9028.2 U8.F2
VGA_VSSSENSE: PR9029.2 PR9031.2 U8.F1
VL: PR3020.1 PR6025.1 PR8050.2
VMA_CLK0: R25488.2 U8.D24 VRAM1.J12
VMA_CLK0#: R25488.1 U8.D25 VRAM1.J11
VMA_CLK1: R25489.2 U8.N22 VRAM2.J12
VMA_CLK1#: R25489.1 U8.M22 VRAM2.J11
VMA_DQ0: U8.E18 VRAM1.E2
VMA_DQ1: U8.F18 VRAM1.F2
VMA_DQ2: U8.E16 VRAM1.A2
VMA_DQ3: U8.F17 VRAM1.B2
VMA_DQ4: U8.D20 VRAM1.F4
VMA_DQ5: U8.D21 VRAM1.B4
VMA_DQ6: U8.F20 VRAM1.E4
VMA_DQ7: U8.E21 VRAM1.A4
VMA_DQ8: U8.E15 VRAM1.B11
VMA_DQ9: U8.D15 VRAM1.E13
VMA_DQ10: U8.F15 VRAM1.A13
VMA_DQ11: U8.F13 VRAM1.A11
VMA_DQ12: U8.C13 VRAM1.E11
VMA_DQ13: U8.B13 VRAM1.F11
VMA_DQ14: U8.E13 VRAM1.B13
VMA_DQ15: U8.D13 VRAM1.F13
VMA_DQ16: U8.B15 VRAM1.N11
VMA_DQ17: U8.C16 VRAM1.U11
VMA_DQ18: U8.A13 VRAM1.M11
VMA_DQ19: U8.A15 VRAM1.T11
VMA_DQ20: U8.B18 VRAM1.U13
VMA_DQ21: U8.A18 VRAM1.T13
VMA_DQ22: U8.A19 VRAM1.N13
VMA_DQ23: U8.C19 VRAM1.M13
VMA_DQ24: U8.B24 VRAM1.N4
VMA_DQ25: U8.C23 VRAM1.U4
VMA_DQ26: U8.A25 VRAM1.M4
VMA_DQ27: U8.A24 VRAM1.T4
VMA_DQ28: U8.A21 VRAM1.T2
VMA_DQ29: U8.B21 VRAM1.U2
VMA_DQ30: U8.C20 VRAM1.M2
VMA_DQ31: U8.C21 VRAM1.N2
VMA_DQ32: U8.R22 VRAM2.U11
VMA_DQ33: U8.R24 VRAM2.N11
VMA_DQ34: U8.T22 VRAM2.U13
VMA_DQ35: U8.R23 VRAM2.M11
VMA_DQ36: U8.N25 VRAM2.N13
VMA_DQ37: U8.N26 VRAM2.M13
VMA_DQ38: U8.N23 VRAM2.T11
VMA_DQ39: U8.N24 VRAM2.T13
VMA_DQ40: U8.V23 VRAM2.M4
VMA_DQ41: U8.V22 VRAM2.N4
VMA_DQ42: U8.T23 VRAM2.U4
VMA_DQ43: U8.U22 VRAM2.T4
VMA_DQ44: U8.Y24 VRAM2.N2
VMA_DQ45: U8.AA24 VRAM2.T2
VMA_DQ46: U8.Y22 VRAM2.M2
VMA_DQ47: U8.AA23 VRAM2.U2
VMA_DQ48: U8.AD27 VRAM2.F2
VMA_DQ49: U8.AB25 VRAM2.B2
VMA_DQ50: U8.AD26 VRAM2.E2
VMA_DQ51: U8.AC25 VRAM2.A2
VMA_DQ52: U8.AA27 VRAM2.B4
VMA_DQ53: U8.AA26 VRAM2.A4
VMA_DQ54: U8.W26 VRAM2.E4
VMA_DQ55: U8.Y25 VRAM2.F4
VMA_DQ56: U8.R26 VRAM2.B13
VMA_DQ57: U8.T25 VRAM2.A13
VMA_DQ58: U8.N27 VRAM2.F13
VMA_DQ59: U8.R27 VRAM2.E13
VMA_DQ60: U8.V26 VRAM2.A11
VMA_DQ61: U8.V27 VRAM2.B11
VMA_DQ62: U8.W27 VRAM2.F11
VMA_DQ63: U8.W25 VRAM2.E11
VMA_WCK01: U8.D18 VRAM1.D4
VMA_WCK01#: U8.C18 VRAM1.D5
VMA_WCK23: U8.D17 VRAM1.P4
VMA_WCK23#: U8.D16 VRAM1.P5
VMA_WCK45: U8.T24 VRAM2.P4
VMA_WCK45#: U8.U24 VRAM2.P5
VMA_WCK67: U8.V24 VRAM2.D4
VMA_WCK67#: U8.V25 VRAM2.D5
VQQD_VPPSNS: PR5002.2 PU5000.12
VR_READY: PR7067.2 PU7000.38
VR_SVID_ALERT#_VCORE: PR7002.2 PR7020.2 R63.1 R64.2
VR_SVID_CLK_R: R66.2 U1.AA1
VRON: PR7025.2 R25311.1 U37.69
VSEN_CORE: PC7007.1 PC7008.2 PC7010.1 PR7044.2 PR7047.2 PU7000.47
VSEN_GT: PC7013.1 PC7014.2 PC7016.2 PR7051.2 PR7054.2 PU7000.27
VSEN_SA: PC7019.1 PC7020.2 PC7022.2 PR7058.2 PR7059.2
VSTBY_FSPI: R359.2 R25330.2 U37.106
WIGIG_LED: CN17.6 TP9029.1
WLAN_RST#: CN17.52 R2665.1
WRST#: C6571.1 D63.2 R25300.1 U37.14(WRST#)
WRST#_8350: C20142.1 D13093.2 R25633.2 U6516.A2(WRST#)
XCLK_BIASREF: R145.1 U1.CJ1
XD_CD#: TP99.1 U40.7
XD_D7: TP96.1 U40.23(XD_D7)
XDP_BPM0: TP23.1 U1.U1
XDP_BPM1: TP25.1 U1.U2
XDP_PRDY#_CPU: TP24.1 U1.W2
XDP_PREQ#_CPU: TP22.1 U1.W1
XDP_TCK0: R7.2 R24.2 TP52.1 U1.T6
XDP_TDI_CPU: R3.2 R19.2 U1.U6
XDP_TDO_CPU: R4.2 R22.1 U1.Y5
XDP_TMS_CPU: R5.2 R15.2 U1.T5
XDP_TRST#_CPU: R6.1 R25.2 U1.Y6
XTAL1: R511.1 U6521.9
XTAL2: R512.1 U6521.10
XTAL24_IN: R166.1 U1.CK3
XTAL24_IN_C: C205.2 R166.2 R167.1 Y2.1
XTAL24_OUT: R168.1 U1.CK2
XTAL24_OUT_C: C208.2 R167.2 R168.2 Y2.3
XTAL_SSIN: R331.1 U8.A10
N15767591: C20130.2 R25614.2
N16244674: R1616.2 U67.28
N16251939: R67598.1 U6521.46
N16251941: R67599.1 U6521.47
N16390345: C266.2 R244.2
N16485113: C96328.2 R67583.2 U6523.11
N16485177: Q6562.3 R67582.2
N16485185: R67582.1 R67851.1 U6523.13
N16485221: C96332.1 U6523.12
N16485697: R67593.1 R67594.2
N16502093: R67586.1 U6523.14
N16722265: Q6566.3 R67600.1 R67601.1
N16821711: PC5006.1 PC5007.1 PL5001.2 PR5001.1 PR5002.1
N16826936: R323.2 R324.2 U11.2
N17011327: C572.2 U20.39
N17011330: C566.2 U20.37
N17011339: C567.1 U20.34
N17011340: C573.1 U20.19
N17011365: R454.2 U20.48
N17011431: C578.1 U20.7
N17011437: R738.2 U20.11
N17011447: C846.1 U20.12
N17011480: C566.1 U20.35
N17061276: PJ1.3 PR13.1
N17061293: PQ9054.5 PR1.1 PR3.1
N17061294: PR5.1 PU1.20
N17061299: PR6.1 PU1.19
N17061317: PJ1.5 PR14.1
N17061319: PC17.1 PL5.2 PQ2.1 PQ2.2 PQ2.3(S3) PR7.1 PR209.1 PR210.1
N17061327: PC1.2 PC2.2 PQ1.4 PQ9054.4 PR29.1
N17061416: PC19.1 PR33.2
N17061438: PC15.2 PR11.2
N17061451: PJ1.4 PR12.1
N17061494: PC17.2 PQ2.4 PR4.1
N17070212: PQ7.2 PR9258.2 PR9272.1
N17072870: PC9080.1 PC9081.1 PC9082.1 PC9083.1 PC9084.1 PC9085.1 PC9086.1 PC9087.1 PJ9002.1 PL9002.2 PR9263.1
N17073105: PC9089.2 PR9094.1 PR9263.2
N17074882: PC9067.1 PC9068.1 PC9069.1 PJ9003.2 PQ9008.1 PQ9008.2 PQ9008.3(S3) PR9073.1
N17074965: PC561.1 PC562.1 PC563.1 PC9098.1 PJ9005.2 PL551.2 PR569.2
N17184837: D11.1(CATHODE) D6543.1(CATHODE) R735.1
N17326408: PQ17.2 PR230.1 PR235.2 PR9276.2
N17412621: PR30.2 PU1.5
N17419587: PC8003.2 PQ8001.4 PQ8003.3 PR8002.2 PR8008.1
N17419880: PC8000.2 PQ8002.4 PQ8004.3 PR8004.2 PR8009.1
N17421868: PQ8012.3 PR8022.1
N17421870: PQ8006.4 PQ8012.6 PR8000.2
N17421874: PQ8012.2 PQ8012.5 PR8031.1
N17421890: PD8001.2 PQ8009.2 PQ8010.2 PR8023.2
N17421892: PQ8013.3 PR8024.1
N17421946: PQ8013.2 PQ8013.5 PR8032.1
N17421950: PQ8007.4 PQ8013.6 PR8030.2
N17421954: PQ8013.1 PR9278.1
N17421956: PQ8010.1(S) PQ8013.4(E2)
N17422036: PQ8009.1(S) PQ8012.4(E2)
N17423044: PQ8005.6 PR9277.2
N17423573: PQ8012.1 PR9279.2
N17424509: PQ8010.3 PR9280.1
N17424572: PQ8009.3 PR9281.1
N17424918: PR19.2 PU1.11
N17424920: PR17.2 PU1.12
N17424921: PR32.2 PU1.7
N17424925: PR25.2 PU1.9
N17424950: PR8.2 PR205.2 PU1.15
N17661815: PR26.2 PU1.8
N17699210: C842.1 D13092.2 HE1.2(VCC) R25519.2
N18453595: CN11.13 R67866.1
N18723876: C646.2 R516.1 R517.1 R518.1 R519.1
N18867651: PC6020.1 PC6021.1 PR9245.1 PU6001.8 PU6001.9
N18867812: PC6042.1 PC6043.1 PR9249.1 PU6002.8 PU6002.9
N18922914: C425.2 C429.2 C431.2 R299.2 U8.AA8 U8.AA9
N19138106: R321.2 U8.F22
N19138109: R322.2 U8.J22
N19509659: R25378.2 R25381.1
N19510593: R25379.2 R25382.1
N19521323: PQ6000.3 PR6006.1
N19521733: PQ6000.2 PR6012.1 PR9268.2 PR9269.2
N19549602: PQ6001.2 PR6024.1 PR9270.2 PR9271.2
N19634328: R67885.1 R67886.1 U37.83
N20380930: R44.2 U1.BT27
N20513971: R220.2 TP54.1
N20681162: R25494.2 U1.BY31
N20910893: Q6565.2 R67539.1 R67865.2
N20911229: Q6570.2 R67887.1 R67888.2
N21094013: R67891.2 U6511.3
N21094016: R67892.2 U6511.4
N21094286: R67893.2 U6511.28
N21094358: R67894.2 U6511.29
N21263014: TP65.1 U8.E10
N21263017: TP66.1 U8.F10
N22233972: PC7001.1 PR7001.1 PR7002.1 PR7003.1 PR7102.1
N22317721: CN62.5 F1.2
N22358547: CN53.10 F2.2
N22430724: PQ7.3 PQ10.2 PQ25.2 PR79.2 PR80.1
N22430737: PQ10.3 PR105.2
N22430755: PC219.1 PC220.1 PC222.1 PC224.1 PC227.1 PC230.1 PC231.1 PC233.1 PJ3005.1 PL12.2 PR9259.1
N22430839: PC225.2 PR269.1 PR9259.2
N22430843: PC82.1 PR99.2
N22430851: PC235.2 PR277.1
N22573697: R25448.1 U1.CP6
N22767382: R84.2 U1.BP36
N22907784: CN62.1 R67895.2
N22907880: CN62.2 R67896.2
N22907920: CN62.8 R67897.2
N22907953: CN62.9 R67898.2
N22907986: CN62.3 R67899.2
N24359231: PC7056.2 PU7001.4
N24359390: PR7078.1 PU7001.3
N24444747: PR7017.2 PR7018.1 PR7021.2 PR7031.1
N24444757: PC7023.1 PR7063.2
N24445360: PC7005.1 PR7025.1 PU7000.37
N24445593: PR7066.2 PR7069.2 PU7000.8
N24445614: PR7016.2 PR7026.1 PR7030.1 PR7032.2
N24446268: PR7037.2 PR7038.1
N24459302: PR7073.2 PR7076.1
N24492000: PC7012.1 PR7049.1
N24507636: PC229.1 PC6230.1 PC6231.1 PJ3008.1 PL14.2 PR6414.2
N24507642: PC9097.1 PR283.1 PR6418.2 PU3003.6
N24507664: PC9097.2 PR6414.1 PR6418.1
N24507676: PC6229.2 PR6417.2 PU3003.1
N24507691: PR284.2 PU3003.5
N24515156: PC7018.1 PR7056.1
N24602110: PR7007.2 PR7013.2 PR7014.1
N24622727: PR7099.2 PR7100.1 PR7101.1
N24679794: C243.2 L3.1 R212.1 R213.1
N24742096: PD9001.2 PQ9011.3 PR9075.2
N24742104: PQ9009.2 PQ9010.3 PQ9011.2 PR9074.2 PR9077.1
N24742107: PC9055.1 PC9056.1 PR9067.2 PU9002.13 PU9002.14(VOUT1#2)
N24742118: PR9078.2 PU9003.3
N24742123: PQ9009.3 PR9073.2
N24742126: PC9073.1 PQ9010.2 PR9079.2 PU9003.4
N24742146: PC9071.1 PR9080.2
N24742173: PC9059.1 PR9069.2 PU9002.4
N24742207: PC9063.1 PU9002.10
N24742208: PC9062.1 PU9002.12
N24742222: PC9060.1 PR9070.1 PU9002.5
N24742230: PC9064.1 PR9072.2 PU9002.3
N24995566: PC6228.1 PR3020.2 PU3002.5(VCC)
N24995570: PR3021.1 PU3002.1
N24995581: PR3022.1 PU3002.3
N25235355: PQ8005.2 PR8015.1 PR8017.2
N25257440: PQ8005.3 PR8007.2 PR9277.1
N25257697: PQ8005.5 PR8006.2 PR8014.2 PR8016.1
N25318825: PQ8000.3 PR8005.1
N25318883: PQ8000.2 PR8010.2 PR8011.2 PR8012.1
N25318964: PQ8000.1(S) PR8012.2 PR8013.2
N25319146: PQ8003.2 PR8001.2 PR8005.2
N25365001: PQ9084.3 PR9103.2
N25369936: Q27.1(S) R560.1
N25369945: Q27.4 R558.1
N25430953: PQ14.3 PR111.2
N25430988: PQ12.3 PR106.2
N25430994: PQ19.3 PR126.2
N25431520: PQ9050.3 PR9227.2
N25804343: PR9027.2 PR9030.2
N25817818: PQ9085.3 PR9099.2
N25817820: PQ9085.2 PQ9086.3 PR9100.2 PR9101.1
N25821251: PC9088.1 PR9092.2
N27752748: R450.2 R736.2
N28053888: PR7006.1 PR7007.1
N28054550: PR7077.2 PU7001.5
N28088374: PC7004.1 PR7008.2
N28089786: PR7035.1 PR7040.1
N28089833: PR7036.2 PR7041.2
N28092561: R83.2 U1.W4
N28107941: PC7096.2 PR7095.1
N28108994: PR7096.2 PR7098.1
N28123718: PR7030.2 PR7033.1
N28123995: PR7031.2 PR7034.1
N28124269: PR7010.2 PR7017.1
N28124298: PR7009.2 PR7016.1
N28129355: PR7022.1 PR7027.1
N28129385: PR7023.1 PR7028.1
N28129414: PR7024.1 PR7029.1
N28159674: PR7091.1 PR7092.1 PR7093.1
N28160119: PC7078.2 PR7087.1
N28160139: PR7088.2 PR7090.2
N28379472: PC9025.1 PR9021.2 PR9023.1 PR9024.1
N28379477: PC9024.1 PR9019.1
N28380796: PR9017.1 TP9000.1
N28380828: PC9004.1 PR9000.2 PR9002.2
N28414264: PR9033.1 PR9274.1 PU9000.13
N28607521: PR9034.1 PU9000.22
N29093947: Q14.2 Q16.3 R386.1
N30319351: PC9079.2 PR9089.1
N30442035: PC6040.1 PC6041.1 PR9248.2 PU6002.13 PU6002.14(VOUT1#2)
N30442060: PC6051.1 PR6023.2 PU6002.4
N30442062: PC6056.1 PU6002.12
N30442063: PC6057.1 PU6002.10
N30442080: PC6053.1 PR6028.1 PU6002.5
N30442084: PC6052.1 PR6027.2 PU6002.3
N30568314: PC6024.2 PR6010.1 PR6014.2 PU6000.12
N30568326: PC6024.1 PR6011.1
N30568424: PC6059.2 PR6030.1 PR6031.2 PU6003.9
N30568429: PC6059.1 PR6029.1
N30568472: PC6054.1 PR6025.2 PU6003.12
N30568498: PQ6001.3 PR6021.1
N30568535: PR6003.2 PR6004.2 PR6005.1 PR6007.1
N31069510: PC6018.1 PC6019.1 PR9244.2 PU6001.13 PU6001.14(VOUT1#2)
N31161958: PC6025.1 PR6013.2 PU6001.4
N31161974: PC6028.1 PU6001.12
N31161976: PC6029.1 PU6001.10
N31162017: PC6027.1 PR6016.1 PU6001.5
N31162025: PC6026.1 PR6015.2 PU6001.3
N31353100: PC551.2 PR551.2
N32484985: PQ8008.2 PR8018.2 PR8021.1
N32484987: PR8021.2 PR8025.2 PR8027.1
N32485009: PQ8008.3 PQ8011.2 PR8028.1
N32485013: PQ8008.1(EMITTER) PQ8011.1(EMITTER) PR8019.2 PR8020.1
N32485017: PQ8011.3 PR8026.1 PR8029.1
N32485347: PQ8004.2 PR8003.1 PR8007.1
N33618596: Q34.3 R653.2
N33652665: EC12.1 R655.2
N33712295: R85.2 U1.E1
N33761123: CN16.38 R645.1 R2660.1
N33761125: CN16.50 R648.1
N33761127: CN16.68(SUSCLK) TP81.1
N33764822: R216.2 TP26.1
N33764826: R217.2 TP32.1
N34044006: PR7109.2 PU7003.5
N34044116: PC7101.2 PU7003.4
N34044137: PR7110.1 PU7003.3
N34045443: PR7113.2 PU7004.5
N34045547: PC7103.2 PU7004.4
N34045574: PR7114.1 PU7004.3
N34047546: PR7105.2 PU7002.5
N34047656: PC7105.2 PU7002.4
N34047677: PR7106.1 PU7002.3
N35244209: R25623.1 R25624.2 U6515.1
N35444059: C20140.2 U6516.B3
N35539245: TP9073.1 U6516.D5
N35539258: TP9074.1 U6516.D3
N35539657: TP9067.1 U6516.A1
N35539676: TP9068.1 U6516.D1
N35539679: TP9071.1 U6516.B1
N35539682: TP9072.1 U6516.E1
N36446693: C639.2 R512.2 Y4.3
N36977514: Q30.2 Q31.3 R579.2
N37162665: L28.1 R449.1
N37162929: R454.1 TP9023.1
N37164070: C844.2 C846.2 R734.2 R25371.1
N37164724: R735.2 R25371.2
N37349239: PC7046.2 PR7072.1
N37349425: PC7064.2 PR7081.1
N37352433: PC9012.1 PR9004.1
N37598035: R507.1 U23.4
N38674948: PR7082.2 PR7084.1
N38680880: Q6523.2 R576.1
N38756671: C6568.2 R25318.1 U37.66
N38756738: C1208.2 R960.1 U37.82
N38756787: C6580.2 R895.1 U37.98
N38756834: Q81.3 R25321.2 SW2.3 SW2.4
N38757336: C6563.1 R25308.1 U37.128
N38757406: C1044.1 Q81.2 R25310.2 SW4.3 SW4.4
N38758998: C6562.2 R402.1
N38759178: C1190.1 U37.12
N39017089: R67415.1 TP13173.1
N39017091: R67414.1 TP13172.1
N39782161: TP9044.1 U1.BW35
N39782179: TP9042.1 U1.BW34
N39782191: TP9043.1 U1.CA37
N40437801: TP9033.1 U8.V7
N40437812: TP9032.1 U8.W7
N40437815: TP9031.1 U8.W6
N40437818: TP9030.1 U8.Y6
N40911013: R405.2 VRAM1.J13(ZQ)
N40911015: R406.2 VRAM2.J13(ZQ)
N43686188: PQ17.3 PR9275.1
N43700942: CN29.24 R25521.2
N44885066: PD9002.3(COMMON ANODE) PR16.2
N44984144: R779.2 U30.27
N44984193: C808.2 U30.1
N44994019: R25526.1 U67.9
N44994033: R25527.1 U67.10
N44994150: TP2.1 U67.11
N44994160: TP9046.1 U67.12
N44994181: TP9064.1 U67.13
N44999557: C20064.1 U12.1
N44999826: R25571.2 U12.29
N45003416: TP88.1 U6511.26
N45003467: C20083.1 U6511.33
N45003503: TP89.1 U6511.5
N45003505: TP90.1 U6511.6
N45003796: TP93.1 U6511.14
N45003808: TP92.1 U6511.21
N45004159: C20085.2 R205.1 R206.1 U6511.13
N45124268: Q23.3 R25617.1
N45124292: C20132.2 Q23.2 R25620.2
N45124296: R25619.2 R25620.1 R67507.2 R67508.2
N45244883: Q28.2 R67361.2 R67362.1
N45302727: D12.1(CATHODE) Q21.3
N45365737: C96269.1 R67855.2 U2.1(VCC)
N45365860: R67418.2 U2.4
N45366087: C96271.1 R67856.2 U6517.1(VCC)
N45366166: C96272.1 U6517.2
N45366191: C96272.2 U6517.3
N45366210: R67422.2 U6517.4
N45500595: PC8005.1 PR8033.2 PU8000.1(VIN)
N45500603: PC8007.1 PQ8015.3 PR8035.2 PR8040.2 PU8000.3
N45500619: PD8002.1(CATHODE) PD8003.1(CATHODE) PR8033.1 PR8035.1
N45500625: PQ8016.6 PR8042.1 PR8045.1 PR8047.1
N45500627: PQ8016.5 PR8045.2
N45500633: PQ8016.1 PR8046.1 PR8048.1
N45500637: PQ8016.2 PR8047.2
N45500667: PQ8014.3 PR8034.1 PR8037.1
N45500689: PR8036.1 PR8039.1 PU8000.4
N45500733: PQ8015.2 PR8038.2 PR8041.2 PR8043.1
N45509729: PC8008.2 PR8052.2 PU8001.1(VIN)
N45509733: PD8006.1(CATHODE) PD8007.1(CATHODE) PR8052.1 PR8054.1
N45509737: PR8053.2 PR8055.1 PU8001.4
N45509757: PC8011.1 PQ8019.3 PR8054.2 PR8057.1 PU8001.3
N45509773: PQ8019.2 PR8058.2 PR8060.2 PR8064.1
N45509797: PQ8018.6 PR8056.1 PR8061.1 PR8062.1
N45509799: PQ8018.5 PR8061.2
N45509807: PQ8018.2 PR8062.2
N45509836: PQ8018.1 PR8063.1
N45509840: PQ8017.1(S) PR8051.1
N45515909: PD8005.2 PR8049.2 PR8050.1
N45782696: R450.1 U20.20
N45870434: Q85.1(S) R821.2 R825.2
N45870491: Q86.2 R821.1
N45873726: TP1.1 U1.C35
N45952789: R160.1 U6510.3
N46166544: CN33.8 R572.1
N46167434: Q29.3 R573.2 R25471.1 R25473.2
N46207407: R25554.1 R25558.2 U6509.7
N46207590: C20040.1 R25555.2 U6509.23
N46207592: R25556.2 R25557.1 U6509.26
N46213996: R593.2 U33.18
N46213998: R592.2 U33.29
N46214095: D22.2 R600.1
N46222285: C750.2 Q32.2 R609.2
N47271970: R363.2 R364.1 R366.2 R367.2 R368.2
N48434117: C375.2 C380.2 C386.2 L4.2 U8.F11
N48587681: R329.2 U8.N6
N48650493: Q15.2 R382.1 R384.2
N49263752: R339.2 R341.2 R342.2 R343.2
N156051040: TP9066.1 U6516.E2
N156051160: TP9070.1 U6516.A4
N156052720: TP9069.1 U6516.E3
N159797420: JDIM02.162 T1.1
N159810220: JDIM02.165 T2.1
N168487945: C96331.2 U6523.7(VREG)

Pads without a net: CN1 3 4; CN4 3 5; CN11 2 7 11 12; CN13 3; CN14 1 2 3 4; CN16 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN17 8 12 16 20 38 40 42 44 46 48; CN21 4; CN29 10 13 14 38; CN37 13 14; CN48 5; CN49 5 15 17 22 23 25 26 28; CN52 3; CN55 15 16; CN62 13; HOLE33 1; HOLE34 1; JDIM1 162 165; NOREF 1; NOREF#3 1; NOREF#4 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; PQ7000 2; PQ7001 2; PQ7004 2; PQ9000 2; PQ9001 2; PU16 7; PU3004 5; PU7000 14 15 19 20 21; PU9004 7; Q6539 1 2 6; Q6569 3 4 5; U1 A34 A35 AA24 AA26 AB25 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC3 BC24 BC28 BD3 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL5 BL6 BL34 BL36 BL37 BN1 BN2 BP8 BP9 BP34 BP35 BR18 BT8 BT9 BV24 BV25 BW36 BW37 C34 CA32 CA34 CA35 CA36 CB35 CB36 CC27 CC35 CC36 CE9 CF12 CG1 CG2 CG12 CG14 CG17 CG25 CG35 CH4 CH7 CH8 CH9 CH12 CH17 CH20 CH22 CH25 CH30 CH32 CJ17 CJ22 CJ25 CJ27 CJ29 CK19 CK23 CK25 CM16 CM18 CM19 CM20 CM23 CM24 CM27 CN3 CN4 CN7 CN16 CN18 CN19 CN20 CN23 CN24 CN26 CN36 CP3 CP4 CP7 CP16 CP18 CP20 CP24 CP26 CP36 CR3 CR4 CR16 CR18 CR20 CR24 CR26 CR35 D34 D35 D37 F34 F37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L25 M24 M26 P24 P26 R24 R25 R26 T25 U3 U4 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; U2 6; U8 A3 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C2 C3 C7 C14 D4 D10 D11 D23 E6 E7 E9 F4 F5 F6 F7 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 W5 W22 Y3 Y4; U12 23 38; U14 9; U20 14 15 16 23 24; U23 3 23 24; U30 11 30 31 33 34 46; U33 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; U67 27 31; U2015 1; U6509 20 21 22 24 25 27 28; U6510 4; U6511 22 23 24 25 30 34 35 36 37 38 39 40; U6515 10; U6517 6; U6523 18; VRAM1 A5 A10 U5 U10; VRAM2 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5547 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 1753 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 345 vias
v4: diameter 0.305, hole 0.152, TOP to BOTTOM, 7 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_S:
  vias: v1(95.31,182.29) v1(95.92,182.02) v1(96.24,181.35)
1V8_MAIN_EN: length 104.6
  TOP w0.114: v1(111.61,183.59) 111.13,183.59 v1(110.67,183.13) 110.15,182.61 110.15,182.01 110.3,181.86 R403.1 110.3,180.54 110.65,180.2 R374.2 ; v1(89.66,186.3) 89,185.64 88.86,185.64 88.73,185.51 PR9072.1 ; PQ9083.2 159.15,210.47 159.08,210.54 PR9105.1 v1(157.57,210.54)
  IN1 w0.089: v1(89.66,186.3) 90.09,185.86 91.53,185.86 94.58,188.92 97.96,188.92 100.97,185.92 100.97,185.44 101.5,184.91 101.98,184.91 102.71,184.17 103.86,184.17 104.14,183.89 105.49,183.89 105.66,184.05 106.9,184.05 107.08,183.88 108.37,183.88 108.61,183.64 110.41,183.64 110.46,183.59 v1(111.61,183.59) 113.31,183.59 113.84,184.12 115.95,184.12 117.35,185.52 118.02,185.52 119.06,186.56 119.06,189.91 118.28,190.7 118.28,192.91 120.5,195.13 120.5,196.77 121.35,197.62 121.35,205.92 121.74,206.31 123.93,206.31 124.45,206.83 125.23,206.83 125.9,207.51 127.21,207.51 128.59,206.12 134.42,206.12 135.06,205.49 139.99,205.49 140.9,206.41 148.07,206.41 150.13,208.47 150.13,209.16 150.61,209.63 151.63,209.63 151.95,209.95 154.21,209.95 154.54,210.28 157.1,210.28 157.35,210.54 v1(157.57,210.54)
1V8_MAIN_EN_N17: length 19.7
  TOP w0.102: 123.41,183.47 124.81,183.47 125.58,184.25 125.58,185.69 v2(125.2,186.08)
  TOP w0.114: R374.1 111.57,179.69 113.33,179.69 114.16,180.52 115.16,180.52 v1(115.45,180.24) 115.78,180.24 116.66,181.12 120.36,181.12 122.72,183.47 123.41,183.47
  BOTTOM w0.102: v2(125.2,186.08) 125.99,186.08 U8.F9
5V_HSMBCK: length 3
  TOP w0.102: R490.1 16.92,131.87 17.85,130.94 18.33,130.94 D14.1
5V_HSMBDT: length 2.4
  TOP w0.102: D14.2 17.64,129.9 17.41,129.67 16.03,129.67 R491.1
8813VID: length 2.6
  TOP w0.203: PU9000.5 99.13,197.29 PR9017.2 97.27,197.29 PR9015.2
8813VOUT1: length 4.7
  TOP w0.203: PC9027.1 100.82,191.64 100.33,191.64 v1(100.21,191.51) 100.17,191.48 PR9028.1
  TOP w0.254: PC9027.1 100.69,192.27 100.57,192.27 100.18,192.66 100.3,192.78 100.3,193.73 PU9000.11
8813VREF: length 11.5
  TOP w0.114: v1(103.43,192) 103.43,192.25 PR9033.2
  TOP w0.254: PR9033.2 102.71,192.22 v1(102.47,192.22) ; PU9000.8 99.15,194.71 v2(97.59,194.71) 97.15,194.71 PC9023.1
  IN4 w0.254: v2(97.59,194.71) 98.18,194.71 100.8,192.1 102.35,192.1 v1(102.47,192.22)
  BOTTOM w0.254: PR9021.1 v2(97.59,194.71)
+1.2VSUS: length 70.1
  TOP w0.305: R26.2 76.35,129.65 75.34,128.64 75.34,127.98 v1(75.65,127.67)
  IN1 w0.305: v1(66.18,129.02) 66.18,128.19 66.71,127.67 v1(75.65,127.67)
  BOTTOM w0.102: U1.AY36 100.65,142.17 99.79,142.17 99.72,142.24 ; v2(99.7,154.75) U1.Y36 ; v2(99.64,152.26) 99.68,152.23 U1.AD36 ; v2(99.15,146.92) 99.4,146.92 99.68,147.2 U1.AM36 ; 64.85,109.57 JDIM02.241 ; 64.85,120.07 JDIM02.199 ; 99.7,149.58 99.86,149.58 99.99,149.71 U1.AH36
  BOTTOM w0.191: v2(98.05,149.42) 98.21,149.58 99.7,149.58
  BOTTOM w0.203: v2(99.56,137.04) 100.56,137.04 U1.BH36
  BOTTOM w0.254: JDIM02.220 55.35,114.82 55.1,115.07 v1(55.1,115.22) ; JDIM02.75 66.05,153.07 v1(66.17,153.18) ; JDIM1.118 43.7,142.32 v1(43.31,142.71) ; JDIM1.124 43.57,140.82 43.31,141.08 v1(43.31,141.22) ; JDIM1.12 45.81,168.82 v1(45.98,168.65) ; v1(46.31,114.84) 46.3,114.82 JDIM1.220 ; v1(43.34,130.6) 43.34,130.98 43.69,131.32 JDIM1.154 ; v1(55.34,125.43) 55.45,125.32 JDIM02.178 ; v1(54.62,169.32) 54.62,169.13 54.99,168.75 55.43,168.75 55.49,168.82 JDIM02.12 ; v1(43.33,129.54) 43.61,129.82 JDIM1.160 ; v1(54.66,163.23) 54.32,163.57 JDIM1.33 ; v1(46,125.27) 45.95,125.32 JDIM1.178 ; v1(66.36,120.39) 66.36,120.33 66.11,120.07 64.85,120.07 ; v1(43.33,132.82) JDIM1.148 ; JDIM02.96 55.58,147.82 55.33,148.07 54.79,148.07 v1(54.73,148) ; v1(55.34,158.5) 55.52,158.32 JDIM02.54 ; JDIM1.54 v1(46.02,158.32) ; JDIM1.130 43.48,139.32 v1(43.34,139.47) ; JDIM1.75 53.99,153.07 v1(54.63,152.43) ; U1.AW32 103.23,142.56 v2(103.61,142.94) ; U1.R32 103.61,158.38 v2(103.61,158.43) ; v1(66.32,162.56) 66.32,163.19 65.94,163.57 JDIM02.33 ; JDIM1.142 43.67,136.32 v1(43.33,135.98) ; v2(103.56,150.21) 103.23,149.88 U1.AH32 ; v1(66.82,110.24) 66.82,110.1 66.3,109.57 64.85,109.57 ; JDIM1.96 v1(43.33,147.82) ; 99.72,142.24 99.5,142.24 v2(99.42,142.16) ; U1.AN32 103.23,146.29 v2(103.56,146.61) ; v1(43.31,144.76) 43.31,144.2 43.68,143.82 JDIM1.112 ; v2(103.56,139.32) 103.23,138.99 U1.BE32 ; JDIM1.241 53.82,109.57 v1(54.23,109.98) ; JDIM1.136 43.57,137.82 v1(43.32,138.08) ; JDIM1.199 v1(54.33,120.07)
  vias: v1(54.15,143.68) v1(54.11,131.14) v1(54.17,134.46) v1(54.16,128.85) v1(54.6,142.83) v1(54.6,140.89) v1(54.61,132.75) v1(54.84,134.46) v1(55.28,143.68) v1(55.26,142.83) v1(55.26,140.93) v1(55.26,138.89) v1(55.27,132.74) v1(55.35,131.52) v1(56.51,134.49) v1(66.11,143.74) v1(66.15,136.26) v1(66.16,138.27) v1(66.22,131.13) v1(66.81,136.28) v1(66.8,131.45) v1(66.95,138.27) v1(71.78,136.34) v1(84.25,176.82) v1(84.92,176.8) v1(85.6,176.8) v1(90.52,189.07) v1(91.18,189.07)
+1.5V: length 28.5
  IN2 w0.508: v1(12.05,40.82) 12.86,41.63 13.12,41.89 25.14,41.89 27.97,39.06 29.21,39.06 30.08,38.18 30.08,36.93 30.8,36.21 30.8,35.62 31.6,34.81 v1(31.6,32.68)
  BOTTOM w0.508: v1(31.6,32.68) 31.6,32.28 31.38,32.06 Q21.2 31.38,31.18 31.42,31.14 R462.2
  vias: v1(12.14,40.08)
+1.05V_DEEP_SUS: length 53.9
  TOP w0.254: R1267.2 126.25,115.03 126.87,115.03 127.56,114.35 v2(128.04,114.35)
  IN4 w0.254: v1(135.09,127.34) 135.09,127.99 137.09,129.99 137.09,130.87 136.56,131.4 135.58,131.4 134.67,132.31 134.67,136.99 131.37,140.3 131.37,140.74 130.47,141.64 129.8,141.64 127.94,143.5 127.35,143.5 126.05,144.8 126.05,147.26 127.77,148.97 127.77,152.07 127.41,152.43 127.03,152.43 126.94,152.33 126.46,152.33 126.11,152.68 126.11,156.88 125.76,157.23 125.76,159.12 127.15,160.51 127.85,160.51 128.17,160.84 128.95,160.84 129.22,160.56 v1(129.22,160.18)
  BOTTOM w0.254: U1.CB14 114.64,128.11 v2(114.46,128.11) 114.45,128.11 U1.CB15 ; v2(128.04,114.35) 128.77,114.35 129.12,114.69 129.12,114.97 129.73,115.58 130.35,115.58 ; v1(129.22,160.18) 130.09,160.18 R83.1 ; U1.CB12 115.79,128.43 v2(115.46,128.76) 115.79,129.08 U1.CA12
  vias: v1(128.9,120.77) v1(128.9,120.11) v1(129.56,120.77) v1(129.56,120.11) v1(130.22,120.77) v1(130.22,120.11) v1(134.85,126.49) v2(110.38,131.36) v2(110.38,130.7) v2(110.38,130.07) v2(111.11,131.35) v2(111.1,130.71) v2(111.13,128.76) v2(112.09,131.36) v2(112.08,128.76) v2(112.83,131.36) v2(112.85,129.41) v2(112.9,128.8)
+1.05V_LAN: length 28.2
  TOP w0.203: 21.77,171.44 21.77,170.95 20.99,170.17 U6521.16 ; U6521.11 23.68,167.81 25.31,169.44 C632.1 ; U6521.40 v1(18.99,161.93) ; U6521.43 v1(20.19,161.92) ; U6521.8 23.7,166.61 25.14,168.06 C631.1 ; U6521.22 18.59,170.02 17.81,170.81 17.81,171.15
  TOP w0.381: C631.1 25.51,167.62 v1(25.29,167.4)
  TOP w0.508: R67599.2 22.28,158.97 R67598.2 v1(23.34,158.93) ; C632.1 25.17,169.71 v1(24.73,170.15) ; v1(16.16,172.47) 16.52,172.83 C634.1 17.81,171.15 ; 21.77,171.44 21.77,173.08 C633.1 v1(21.77,173.84)
  BOTTOM w0.508: v1(23.34,158.93) 22.46,159.81 22.46,161.56 21.4,162.62 20.25,162.62
  vias: v1(16.41,162.33) v1(17.02,161.97) v1(17.1,162.66)
+1.05V_LAN_REGOUT: length 1
  TOP w0.203: U6521.7 23.95,166.21 v1(24.02,166.14)
  vias: v1(10.39,161.59) v1(10.87,161.08) v1(11.36,161.54) v1(11.71,162.51) v1(24.7,166.2) v1(24.81,166.85)
+1.8V: length 245.3
  TOP w0.254: U6516.C1 154.61,212.83 154.51,212.73 154.51,211.89 154.57,211.83
  TOP w0.381: v1(154.75,210.8) 154.89,210.66 C20141.1 155.44,210.95 154.57,211.83
  TOP w0.508: PR9227.1 37.76,125.99 38.22,126.44 PQ9.1 37.67,127.52 37.05,127.52 36.76,127.81 36.25,127.81 36,128.05 36,128.77 35.45,129.32 v1(35.03,129.32)
  IN1 w0.508: v1(154.75,210.8) 154.49,210.8 154.05,210.35 151.79,210.35 151.46,210.03 150.44,210.03 149.39,208.98 149.05,208.98 147.49,207.42 144.59,207.42 143.57,208.44 142.1,208.44 141.71,208.05 141.12,208.05 139.57,206.5 137.64,206.5 136.96,207.17 135.9,207.17 135.62,207.46 132.71,207.46 132.26,207.91 128.23,207.91 127.63,208.52 125.48,208.52 124.81,207.84 124.03,207.84 123.51,207.32 120.41,207.32 120.02,206.93 119.25,206.93 117.22,204.91 117.22,198.9 117.88,198.24 117.88,195.44 117.27,194.83 117.27,188.28 115.27,186.28 114.84,186.28 113.82,185.26 107.12,185.26 106.49,185.9 103.27,185.9 102.44,186.74 102.44,188.13 100.24,190.32 97.17,190.32 96.14,191.35 94.34,191.35 93.69,190.7 88.67,190.7 87.37,189.4 80.21,189.4 76.84,192.77 75.77,192.77 75.22,193.32 72.13,193.32 70.06,195.39 65.5,195.39 62.83,192.72 58.01,192.72 55.65,190.36 53.62,190.36 50.01,186.75 43.82,186.75 42.58,185.51 42.58,180.42 39.31,177.15 38.5,177.15 37.9,176.54 37.9,174.25 37.13,173.49 33.7,173.49 32.9,172.69 30.9,172.69 30.32,173.27 25.86,173.27 v1(25.05,172.46)
  IN3 w0.508: v1(23.36,131.43) 23.36,130.46 24.21,129.61 29.18,129.61 30.77,131.2 33.63,131.2 35.03,129.8 v1(35.03,129.32)
  IN4 w0.508: v1(23.36,131.43) 24.4,131.43 25.05,132.09 25.05,134.7 25.72,135.37 25.72,136.53 21.53,140.72 21.53,144.29 20.96,144.85 20.96,152.71 21.64,153.39 21.64,158.85 22.35,159.56 22.35,162.62 23.27,163.54 23.27,169.29 24.06,170.08 24.06,170.93 25.05,171.92 v1(25.05,172.46)
