# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_DEEP_SUS: length 121.1
  TOP w0.305: v1(122.97,114.39) 122.97,115.47 123.09,115.59 123.09,116.28 R153.2 ; U36.5 185.21,117.11 185.59,116.72 v1(187.07,116.72) 187.07,117.4 187.33,117.65 U35.5
  TOP w0.381: v2(125.99,111.98) 126.56,111.42 R663.1 R662.1
  TOP w0.508: v1(189.78,102.31) 190.64,103.17 190.64,107.91 190.95,108.21 190.95,109.66 190.41,110.2 190.41,115.78 190.12,116.08 190.12,116.11 189.61,116.61 187.18,116.61 v1(187.07,116.72)
  IN1 w0.381: v1(187.07,116.72) 193.72,116.72 194.57,115.88 v1(195.31,115.88)
  IN1 w0.508: v1(122.97,114.39) 122.97,112.67 122.52,112.21 122.52,111.04 124.1,109.46 127.82,109.46 130.96,106.32 137.28,106.32 137.88,105.72 138.33,105.72 139.15,104.9 147.55,104.9 147.93,104.52 148.82,104.52 149.07,104.77 151.08,104.77 151.68,105.36 155.33,105.36 155.83,105.86 156.24,105.86 156.74,105.36 157.77,105.36 158.83,106.42 163.35,106.42 164.01,105.76 166.98,105.76 167.38,105.36 170.24,105.36 172.9,102.7 183.66,102.7 184.62,101.74 189.42,101.74 189.78,102.09 v1(189.78,102.31)
  BOTTOM w0.254: R664.1 194.77,114.14 195.35,114.14 195.67,114.46 195.67,115.51 v1(195.31,115.88) 194.81,115.88 R180.1
  BOTTOM w0.381: v1(123.65,114.4) 123.65,112.38 124.46,111.57 125.57,111.57 v2(125.99,111.98)
+1.8V_S5: length 192.3
  IN2 w0.381: v1(92.88,179.34) 92.31,179.91 92.31,180.81 92.62,181.12 94.46,181.12 94.98,180.61 99.78,180.61 100.38,180.01 102.31,180.01 103.02,179.3 103.02,177.22 104.74,175.5 104.78,175.5 104.95,175.33 104.96,175.32 104.97,175.32 112.62,175.32 116.68,171.26 121.18,171.26 123.64,168.8 v1(127.62,168.8) ; v1(173.97,135.41) 173.51,135.41 170.56,138.36 170.56,138.74 169.75,139.55 169.75,140.25 170.04,140.54 170.04,145.43 172.56,147.95 172.56,150.26 171.92,150.9 171.09,150.9 170.27,151.72 170.27,154.11 169.76,154.62 169.76,154.96 169.39,155.33 169.39,156.01 168.42,156.97 168.42,159.21 167.04,160.59 167.04,164.9 167.77,165.63 167.77,168.15 166.85,169.07 164.35,169.07 162.93,170.49 147.69,170.49 146.75,169.56 143.19,169.56 138.62,174.13 v1(138.62,174.73)
  IN4 w0.381: v1(221.18,120.45) 219.74,120.45 216.54,123.65 215.74,123.65 210.59,128.8 203.38,128.8 202.34,127.76 198.3,127.76 197.71,128.34 189,128.34 186.63,125.98 176.67,125.98 173.25,129.39 173.25,130.38 173.64,130.76 173.64,132.62 174.24,133.21 174.24,134.06 173.97,134.33 v1(173.97,135.41) ; v1(127.62,168.8) 127.62,170 129.37,171.75 136.83,171.75 138.62,173.54 v1(138.62,174.73)
  BOTTOM w0.254: v1(221.18,120.45) 221.38,120.25 CN49.16
  vias: v1(37.94,130.05) v1(37.94,129.39) v1(37.94,128.73) v1(44.43,171.92) v1(44.89,172.41) v1(45.37,172.87) v1(45.87,173.31) v1(46.54,173.32) v1(90.32,186.3) v1(90.98,186.3) v1(92.31,179.78) v1(93.29,178.66) v1(115.64,108.06) v1(116.11,107.59) v1(123.37,111.43) v1(123.98,111.17)
+1.8V_SM:
  vias: v1(211.81,99.39)
+1.35V_GFX: length 31.9
  TOP w0.254: 133.84,187.19 133.84,187.22 133.66,187.4 133.07,187.4 v2(132.84,187.63)
  TOP w0.381: C449.2 134.3,187 v2(134.24,186.94) ; C450.2 132.84,187.91 v2(132.84,187.63)
  BOTTOM w0.254: v2(141.63,188.67) 141.63,188.59 141.2,188.16 140.45,188.16 U8.H26 ; U8.E23 137.67,185.99 v2(137.67,186.13) ; U8.E26 v2(140.01,186.11) ; U8.H24 v2(139.22,187.79)
  BOTTOM w0.305: U8.L26 140.58,190.83 141.3,190.83 141.63,190.5 v2(141.63,190.29) ; v2(140,182.82) 140.38,183.25 U8.B26 ; v2(138.43,190.28) U8.L24
  BOTTOM w0.33: VRAM1.M1 156.51,172.82 v2(156.9,172.42) ; VRAM2.H12 VRAM2.G13 ; VRAM2.B12 153.3,196.83 v2(152.9,197.22) ; v2(153.7,174.8) 153.31,174.42 VRAM1.T3 ; v2(155.5,176.63) 155.7,176.43 VRAM1.N5 ; v2(156.9,173.22) 157.3,173.62 ; VRAM1.L4 156.91,174.82 v2(156.9,174.82) 156.5,174.42 VRAM1.M3 ; v2(153.7,176.67) 153.7,176.42 154.1,176.03 VRAM1.R5 ; VRAM2.L14 160.51,195.22 v2(160.9,194.82) 161.3,195.22 ; v2(156.9,194.82) 156.89,194.82 VRAM2.F14 ; VRAM1.P3 154.91,174.42 v2(155.3,174.8) ; VRAM2.D14 154.9,195.22 v2(154.5,194.82) ; VRAM1.H12 159.7,181.62 v2(160.1,182.02) ; v2(154.5,172.42) 154.9,172.82 VRAM1.P1 ; VRAM2.B14 153.3,195.22 v2(152.9,194.82) ; VRAM1.T1 153.3,172.82 v2(152.9,172.42) ; VRAM2.L13 VRAM2.M12 ; VRAM2.D12 154.5,197.21 v2(154.5,197.22) 154.9,197.62 VRAM2.D11 154.9,197.63 154.5,198.02 v2(154.5,198.04) 154.48,198.04 VRAM2.C10
  BOTTOM w0.356: v2(160.07,197.21) 159.7,196.84 VRAM2.K12 ; VRAM2.E10 155.7,198.65 v2(155.47,198.88) ; VRAM2.G13 VRAM2.F12 156.5,196.82 v2(156.9,197.22) 157.3,197.62 VRAM2.G11
  BOTTOM w0.381: v2(140.01,184.43) 139.63,184.05 U8.C25
  BOTTOM w0.457: v1(146.66,182.62) v1(147.98,182.62) 147.99,182.61 151.4,182.61
  vias: v1(154.53,194.1) v1(155.2,190.75) v1(155.92,190.75) v1(156.64,190.75) v1(157.38,190.75) v1(165,170.59) v1(165.3,171.17) v1(165.63,171.75) v1(165.66,170.59) v1(165.97,171.18) v1(166.14,172.45) v1(166.3,171.75) v1(166.32,170.62) v1(166.66,171.18) v1(166.85,173.89) v1(166.86,173.22) v1(166.85,172.55) v1(167,189.28) v1(166.99,171.76) v1(166.98,170.59) v2(130.14,186.88) v2(130.14,186.05) v2(134.98,186.89) v2(135.84,188.46) v2(136.8,196.85) v2(136.77,195.24) v2(136.77,194.44) v2(136.78,193.65) v2(136.78,190.25) v2(136.78,189.43) v2(136.78,188.61) v2(136.85,191.08) v2(152.9,204.41) v2(153.7,206.02) v2(153.7,182.82) v2(153.7,181.22) v2(153.71,179.64) v2(154.5,206.02) v2(154.5,183.62) v2(155.3,203.63) v2(155.3,181.22) v2(156.1,204.41) v2(156.12,202.04) v2(156.1,179.64) v2(156.9,205.22) v2(156.9,204.41) v2(156.9,202.81) v2(156.9,195.57) v2(156.9,183.62) v2(156.9,182.82) v2(156.9,182.02) v2(156.9,180.42) v2(156.9,175.62) v2(157.7,204.41) v2(157.7,181.22) v2(157.7,172.42) v2(158.5,173.22) v2(158.5,172.42) v2(159.3,176.42) v2(160.1,205.22) v2(160.1,181.22) v2(160.1,175.62) v2(160.1,174.82) v2(160.1,173.22) v2(160.1,172.42) v2(160.9,205.22) v2(160.9,203.63) v2(160.9,183.62) v2(160.9,180.42) v2(160.9,172.42) v2(161.7,202.02) v2(161.7,198.82) v2(161.7,197.22) v2(161.7,182.02) v2(161.7,180.42) v2(161.7,176.42) v2(162.5,206.02) v2(162.5,195.57) v2(162.5,183.62) v2(162.5,182.02) v2(162.5,174.82) v2(162.5,172.42) v2(162.69,176.81) v2(163.3,203.62) v2(163.3,201.91) v2(163.3,198.02) v2(163.3,197.22) v2(163.3,180.42) v2(163.3,179.62) v2(164.1,206.02) v2(164.1,198.02) v2(164.1,195.62) v2(164.1,194.82) v2(164.1,182.02) v2(164.1,181.22) v2(164.1,180.42) v2(164.1,175.62) v2(164.1,173.22) v2(164.1,172.42) v2(164.9,203.62) v2(164.9,196.42) v2(164.9,183.62) v2(164.9,181.22) v2(164.9,179.62) v2(164.9,174.02) v2(165.7,175.62)
+1V8_AON: length 43.4
  TOP w0.254: v2(95.56,199.56) 95.8,199.56 PR9018.1
  IN4 w0.381: v1(109.55,187.9) 107.67,187.9 105.97,189.6 101.82,189.6 100.75,190.67 100.33,190.67 96.8,194.21 96.8,195.65 97.02,195.87 97.02,198.29 96.33,198.98 v2(95.56,199.56)
  BOTTOM w0.203: v1(106.43,183.26) 106.07,183.62 PR9076.2 ; 134.38,175.92 Q13.2 136.21,175.92 136.48,175.65 R362.2 ; 134.38,175.92 134.38,175.12 133.95,174.69 132.39,174.69 R365.2 131.26,175.08 Q6512.2 130.81,175.35 130.26,175.9 129.32,175.9 R25322.2 ; 134.38,175.92 134.38,176.79 134.05,177.12 v2(133.71,177.12) ; 134.38,175.92 Q13.5
  BOTTOM w0.254: U9.5 108.52,184.54 108.68,184.38 108.68,183.99 C433.2 109.45,183.72 109.56,183.83 110.18,183.83 110.69,184.33 R297.2
  BOTTOM w0.356: U8.G12 128.72,187.45 128.17,187.45 127.89,187.17 v2(127.71,187.17) ; U8.G10 v2(126.81,186.9)
  BOTTOM w0.381: v1(109.99,184.65) 110.64,184.65 R297.2 ; R339.1 134.86,177.65 134.81,177.61 134.2,177.61 v2(133.71,177.12)
  vias: v1(96.81,182.02) v1(97.48,182.04) v1(112.04,180.16) v1(120.91,174.63) v1(126.11,186.69)
+1V8_GFX_MAIN: length 36.3
  TOP w0.254: L4.1 131.09,188.09 v2(131.09,188.31)
  TOP w0.381: v2(135.13,199.39) 134.63,198.89 C362.1
  TOP w0.508: v1(161.59,207.98) C392.1 162.52,208.86 PR9103.1 ; L7.1 L8.1 113.72,197.25 v1(113.26,196.79)
  IN1 w0.508: v1(145.1,205.47) 145.62,204.95 147.94,204.95 151.3,208.31 155.68,208.31 156.01,207.98 v1(161.59,207.98)
  BOTTOM w0.254: v2(98.89,195.96) 99.61,196.69 PR9085.1
  BOTTOM w0.305: U8.AF26 v2(140.02,202.65) U8.AE25 ; v2(137.55,201.02) U8.AC23 ; U8.AF27 141.22,203.09 v2(140.83,203.48) ; v2(138.4,201.87) U8.AD24 ; U8.AB22 137.12,199.74 136.33,198.95 U8.AA21 136.29,198.95 v2(135.92,199.33)
  BOTTOM w0.356: v2(127.62,199.36) 127.26,199.01 U8.AA10 ; v2(128.48,199.41) U8.AA12
  BOTTOM w0.381: U8.AA20 135.48,199.03 v2(135.13,199.39) 134.75,199.01 U8.AA19 U8.AA18 133.84,199.07 v2(133.43,199.49) 132.95,199.01 U8.AA16 ; v2(129.31,199.39) 129.68,199.02 U8.AA13
  vias: v1(98.17,186.63) v1(98.17,185.97) v1(115.9,191.74) v1(119.18,192.15) v1(119.17,191.39) v1(143.52,205.43) v1(144.41,205.47) v2(124.74,188.21) v2(125.15,187.73)
+1V8_MAIN_EN_G: length 59.2
  TOP w0.254: PQ9083.3 162.06,210.3 v1(162.39,210.3) ; PR9102.2 155.25,168.94 155.41,169.1 PR9104.1 156.15,170.48 PQ9084.2 161.5,170.48 v1(161.62,170.35) 162.48,169.5 v1(162.48,169.47)
  IN1 w0.254: v1(162.48,169.47) 162.83,169.13 165.76,169.13 166.06,169.43 167.21,169.43 167.49,169.71 167.49,189.54 166.17,190.87 166.17,207.21 165.62,207.75 165.17,207.75 164.8,208.13 164.8,208.58 163.08,210.3 v1(162.39,210.3)
+1V_S5_ON: length 74.7
  TOP w0.114: U37.95 166.12,109.14 v1(165.41,108.43) ; v1(180.49,112.49) v1(180.49,123.06) v1(179.94,123.61)
  IN3 w0.102: v1(165.41,108.43) 166.56,108.43 167.6,109.47 169.03,109.47 169.6,108.9 172.02,108.9 175.19,112.07 180.07,112.07 v1(180.49,112.49)
  IN4 w0.089: v1(147.38,129.63) 149.82,127.19 149.82,125.97 151.43,124.37 155.55,124.37 156.8,123.11 161.12,123.11 161.5,122.73 162.62,122.73 162.83,122.51 163.92,122.51 164.31,122.12 164.31,118.86 165.05,118.12 165.88,118.12 166.12,117.88 168.21,117.88 168.73,118.4 169.04,118.4 169.53,118.88 171.76,118.88 173.04,120.16 175.67,120.16 176.61,121.09 176.61,122.6 177.29,123.28 179.61,123.28 v1(179.94,123.61)
  BOTTOM w0.203: PR274.1 147.38,129.05 v1(147.38,129.63)
+1V_SUS: length 67.2
  TOP w0.508: v1(170.45,150.18) 170.05,149.79 PR7102.2
  IN3 w0.508: v1(154.64,145.82) 155.19,145.27 155.19,144.41 155.85,143.75 157.37,143.75 158.39,142.73 158.39,140.08 157.85,139.54 157.85,138.42 160.67,135.6 163.89,135.6 165.08,136.79 165.08,138.68 164.44,139.32 162.74,139.32 161.5,140.56 161.5,145.06 162.08,145.65 164.36,145.65 167.19,148.48 168.74,148.48 v1(170.45,150.18)
  IN4 w0.508: v1(154.64,145.82) 153.96,145.82 153,144.85 150.12,144.85 148.55,143.28 141.46,143.28 140.22,142.04 140.22,135.52 139.39,134.69 v1(137.86,134.69)
  vias: v1(138.51,134.79)
+2.5V_SUS: length 74
  BOTTOM w1.524: 67.11,104.21 67.68,104.79 67.68,107.62 69.86,109.79 69.86,165.63 67.7,167.79 67.7,175.5 67.21,175.99
  vias: v1(49.99,104.52) v1(50.88,105) v1(51.45,104.62) v1(51.46,105.31) v1(62.74,103.64) v1(62.96,104.34) v1(63.62,104.33) v1(66.89,177.7) v1(67.37,177.22) v1(83.21,185.58) v1(83.9,185.59)
+3.3V_TYPEC_MUX1: length 18.2
  TOP w0.178: C20062.1 16.12,71.61 16.52,71.21 U12.20 ; U12.6 v1(22.65,69.58) ; U12.17 17.72,71.42 17.62,71.53 17.62,72.46 C20065.2
  TOP w0.203: v1(19.36,76.83) R25565.2 R25567.2 ; R25572.2 R25573.2
  TOP w0.254: R208.1 13.79,67.75 14.7,66.84
  TOP w0.381: R178.2 19.54,61.97 ; v1(18.12,71.95) 18.12,72.3 17.89,72.53 C20065.2 ; C20062.1 15.75,72.27 15.22,72.79 R25572.2 14.72,73.5 v1(14.75,73.54)
  IN4 w0.203: v1(19.36,76.83) 19.13,76.6 19.13,71.95
  vias: v1(24.28,67.21) v1(24.94,67.24) v1(25.68,62.81)
+3V: length 576.6
  TOP w0.203: R154.2 v1(85.01,117.48) ; R25376.2 79.48,120.05 R25377.1 78.5,120.42 v1(78.32,120.24) ; R494.1 30.73,124.39 v1(30.28,124.84) ; U67.14 29.68,155.87 v1(29.22,156.33) ; v1(29.68,162.97) 29.67,162.96 R509.1 ; U67.26 29.28,149.43 ; v1(118.28,111.01) 118.23,110.96 R114.1 ; R67606.2 v1(211.25,92.79) ; R502.1 v1(33.5,122.17)
  TOP w0.254: R159.2 82.76,120.72 v1(83.01,120.96) 83.05,121.01 83.8,121.01 ; R25440.2 83.8,121 ; 83.8,121 R25441.2 ; R120.2 84.21,117.48 R25430.1 84.95,117.42 v1(85.01,117.48) ; U23.1 24.92,145.09 C628.2 ; PR9009.1 105.08,193.39 105.11,193.42 v2(105.16,193.42) ; v1(118.28,111.01) 118.82,111.55 R115.1 119.63,111.55 119.87,111.79 Q3.2 ; v1(112.74,187.46) 112.74,185.84 R386.2 ; Q3.5 122.45,111.79 122.62,111.96 122.62,112.71 v1(122.24,113.09)
  TOP w0.305: v1(166.24,158.86) 167.62,158.86 168.1,158.38 PR9088.1
  TOP w0.381: R25312.2 140.63,99.7 140.89,99.44 v1(140.89,99.21) ; 120.82,115.67 120.82,116.51 120.12,117.22 v2(119.38,117.22) ; v1(54.8,131.14) 55.52,130.42 R25598.1 ; v1(32.97,137) 32.56,137 32.14,136.58 32.14,134.35 32.55,133.93 32.55,133.17 R830.2 ; R155.2 88.71,118.54 R25493.2 87.65,118.54 87.25,118.13 85.38,118.13 85.01,117.76 v1(85.01,117.48) ; R25444.2 24.51,160.69 24.65,160.54 27.4,160.54 v1(28.07,159.88) 28.31,159.88 28.87,159.32 Q6531.2
  TOP w0.508: v1(62.49,186.79) 62.26,186.79 61.34,187.7 61.34,189.31 62.42,190.39 66.53,190.39 R25271.2 ; R225.1 43.16,108.23 42.67,107.74 42.67,107.13 43.28,106.53 v1(43.28,106.19) R226.1 ; 29.28,149.43 29.28,148.51 C20011.2 ; 106.47,109.66 105.64,108.84 104.88,108.84 104.46,109.25 R179.2 104.46,109.83 104.48,109.85 R25429.1 103.48,110.49 R25482.1 103.47,110.21 103.08,109.81 102.74,109.81 102.45,109.53 R25428.1 ; R100.2 107.87,110.48 108.23,110.84 108.23,111.74 108.28,111.8 v2(108.28,112.94) ; v2(114.55,113.22) 114.55,112.9 R212.2 ; v1(133.5,213.08) 133.5,213.69 R25625.1 ; R25526.2 v1(33.62,157.03) ; R227.1 43.78,127.94 v1(43.31,127.47) ; PR5006.2 v1(64.98,180.46) ; R25307.1 148.64,107.76 v1(149.21,107.76)
  IN1 w0.508: v1(43.31,127.47) 38.03,127.47 v1(36.98,128.52) ; v1(54.8,131.14) 57.62,128.32 64.95,128.32 66.8,126.47 72.08,126.47 v1(78.32,120.24) 78.72,120.24 79.43,120.96 v1(83.01,120.96)
  IN2 w0.381: v2(105.16,193.42) 105.16,192.45 104.15,191.45 104.15,190.48 105.85,188.79 ; 107.89,186.54 107.95,186.48 107.95,182.65 v1(107.8,182.5) ; v1(6.73,32.38) 6.73,33.29 9.19,35.76 9.19,36.97 13.41,41.19 20.72,41.19 25.76,36.15 28.39,36.15 v1(29.72,34.82) ; 116.49,187.01 116.49,183.66 121.88,178.27 128.19,178.27 v1(129.53,176.93) ; v1(211.25,102.13) 209.84,103.54 199.9,103.54 198.4,102.05 196.58,102.05 196.5,101.96 193.35,101.96 192.3,103.01 191.29,103.01 189.3,101.02 176.87,101.02 176.62,100.77 169.3,100.77 168.31,99.78 166.5,99.78 165.09,98.37 162.61,98.37 162.45,98.21 153.52,98.21 153.32,98.41 151.09,98.41 150.06,99.44 142.62,99.44 141.77,98.59 141.18,98.59 140.89,98.88 v1(140.89,99.21)
  IN2 w0.508: v1(62.49,186.79) 62.79,186.79 63.17,186.41 63.17,182.44 64.98,180.63 v1(64.98,180.46) ; v1(146.68,129.39) 147.08,129 148.09,129 149.86,127.22 149.86,125.61 151.13,124.35 156.25,124.35 157.25,123.35 162.65,123.35 163.39,122.61 165.55,122.61 v1(167.36,124.43) ; v1(167.36,124.43) 168.92,125.99 168.92,128.46 170.31,129.85 170.31,133.04 169.62,133.72 169.62,136.41 168.95,137.07 168.95,139.75 167.61,141.1 167.61,144.07 170.06,146.52 170.06,148.91 170.7,149.55 171.49,149.55 v1(171.86,149.91) ; v1(167.36,124.43) 167.65,124.43 169.65,122.43 171.44,122.43 172.62,123.6 177.99,123.6 178.63,124.24 180.29,124.24 181.64,122.89 v1(181.64,122.16) ; 26.62,31.05 27.57,31.05 28.35,30.27 28.35,29.54 v1(29.75,28.14) ; 26.62,31.05 26.62,33.26 27.23,33.87 28.77,33.87 v1(29.72,34.82) ; 26.62,31.05 26.62,27.91 25.91,27.21 v1(25.24,27.21)
  IN3 w0.508: v1(211.25,92.79) v1(211.25,102.13) 211.25,107.3 v1(209.4,109.15) ; v1(43.31,127.47) 44.38,128.54 47.41,128.54 47.92,129.04 53.09,129.04 54.8,130.75 v1(54.8,131.14) ; v1(27.32,66.99) 27.9,66.41 27.9,64.25 26.05,62.39 26.05,56.96 26.31,56.69 v1(26.31,55.85) 26.92,55.24 27.76,55.24 28.33,54.68 28.33,46.26 27.68,45.62 27.68,41.36 30.45,38.6 30.45,35.98 29.72,35.25 v1(29.72,34.82)
  IN4 w0.381: v1(166.24,158.86) 168.49,156.62 168.49,156.06 169.67,154.88 169.67,152.29 171.54,150.42 171.54,150.24 v1(171.86,149.91)
  IN4 w0.508: v1(181.64,122.16) 182.27,122.79 183.74,122.79 184.22,122.3 187.42,122.3 188.78,120.93 191.01,120.93 192.53,122.46 196.14,122.46 197.15,121.45 201.46,121.45 204.81,124.8 v1(204.81,124.96) ; v1(29.68,162.97) 28.07,161.36 v1(28.07,159.88)
  BOTTOM w0.203: PR9075.1 104.68,187.87 v1(105.1,188.29) ; PR275.1 146.22,129.39 v1(146.68,129.39) ; v1(63.41,105.91) 63.58,106.07 JDIM02.255 ; v1(122.24,113.09) 122.26,113.11 R25436.2 ; v1(107.8,182.5) 107.85,182.55 R385.2 ; v1(63.38,187.66) 63.38,188.01 63.78,188.41 R439.1 ; PR6416.1 6.19,32.38 v1(6.73,32.38) ; v2(119.38,117.22) 119.41,117.24 R25434.2 ; R102.2 R98.2 108.1,113.85 108.1,113.84 R94.2 ; R43.2 v2(118.08,117.22)
  BOTTOM w0.254: PR7068.1 170.41,149.3 171.02,149.91 v1(171.86,149.91) ; 92.1,184.97 92.68,184.97 92.89,184.76 R67858.1 Q6564.5 Q6564.2 92.89,181.37 93.68,180.58 R67857.1 ; R554.2 119.35,117.19 v2(119.38,117.22) ; JDIM1.255 51.53,106.07 v1(51.46,106)
  BOTTOM w0.305: v1(84.92,190.49) 84.92,190.86 84.66,191.12 84.62,191.17 83.84,191.95 83.8,191.95 83.44,192.32 R440.1 81.71,192.32 R25367.2 ; R576.2 166.89,124.94 167.36,124.47 v1(167.36,124.43) ; v2(108.28,112.94) 108.1,113.13 R94.2
  BOTTOM w0.356: R67855.1 93.85,190.23 91.79,188.17 91.2,188.17 90.76,187.74 89.42,187.74 89.03,187.35 89.03,186.1 89.41,185.71 90.66,185.71 90.98,185.39 90.98,185.28 91.29,184.97 92.1,184.97
  BOTTOM w0.381: R25474.2 114.55,113.86 v2(114.55,113.22) 114.55,112.89 114.81,112.63 R25475.1 ; R67888.1 R67865.1 32.8,52.69 32.33,52.22 31.3,52.22 31.04,51.97 30.15,51.97 29.9,52.22 29.9,53.33 27.38,55.85 v1(26.31,55.85) ; v1(129.53,176.93) 129.35,176.93 129.17,177.11 128.92,177.11 R378.2 ; v1(36.98,128.52) 36.98,125.13 34.03,122.17 v1(33.5,122.17) 32.75,122.92 31.54,122.92 30.28,124.18 v1(30.28,124.84) ; U11.5 129.22,209.77 128.31,208.86 C452.2 126.17,209.07 v1(126.17,209.79) ; R732.2 v1(29.72,34.82) ; v1(181.64,122.16) 181.12,121.64 R25372.1 ; v1(29.75,28.14) 29.95,27.94 31.18,27.94 31.39,28.14 R460.1 ; v1(234.9,119.4) 234.9,119.15 233.44,117.69 233.44,115.47 232.29,114.32 230.11,114.32 229.96,114.17 223.88,114.17
  BOTTOM w0.508: v1(25.24,27.21) 24.69,27.21 R452.2 ; R67856.1 204.44,123.97 204.81,124.35 v1(204.81,124.96) ; v1(33.62,157.03) 32.92,156.33 v1(29.22,156.33) 28.66,156.89 28.66,157.44 28.57,157.52 28.57,158.34 28.69,158.46 28.69,159.26 v1(28.07,159.88) ; R67855.1 94.18,190.25 v1(95.85,190.25) ; v1(83.01,120.96) 83.01,120.59 85.01,118.59 v1(85.01,117.48) ; v1(68.87,99.88) 70.16,98.6 70.16,95.46 66.84,92.14 v1(66.84,91.74) ; v1(29.72,34.82) 29.72,35.39 30.59,36.26 30.59,37.88 29.25,39.21 R455.1
  vias: v1(19.13,138.77) v1(19.13,138.11) v1(25.67,138.74) v1(25.67,138.08) v1(26.02,67.4) v1(26.04,66.73) v1(26.39,138.79) v1(26.39,138.13) v1(26.63,67.65) v1(26.7,145.84) v1(26.69,145.18) v1(26.68,144.52) v1(26.66,66.99) v1(32.97,141.63) v1(32.97,140.97) v1(32.97,140.31) v1(32.97,139.64) v1(32.97,138.98) v1(32.97,138.32) v1(32.97,137.66) v1(34.97,128.67) v1(34.97,128) v1(34.97,127.34) v1(36.98,147.24) v1(36.98,146.51) v1(38.65,176.4) v1(38.67,175.67) v1(39.25,176.08) v1(71.2,105.91) v1(71.33,188.87) v1(71.46,107.07) v1(71.95,188.62) v1(72.18,107.06) v1(73.09,195.21) v1(73.77,195.21) v1(98.78,107.26) v1(98.78,106.6) v1(99.3,107.69) v1(118.49,187.65) v1(118.49,186.97) v1(195.34,118.31) v1(195.34,117.65) v1(196.04,118.3) v1(196.04,117.64) v1(208.63,130.72) v1(209.31,130.78) v1(210.02,130.88) v1(210.75,130.98) v1(210.94,130.32) v1(211.44,131.08) v1(222.9,114.21) v1(223.38,114.66) v1(223.84,115.13) v1(234.24,119.4) v1(234.6,120.01)
+3V3_TPM: length 26.6
  TOP w0.203: R580.2 81.84,101.16 v1(81.7,101.31)
  TOP w0.254: C741.1 83.86,97.05 84.13,97.32 U33.22
  TOP w0.381: C741.1 C744.1 83.91,96.29 v1(84.07,96.44)
  IN4 w0.508: v1(87.22,101.74) 85.61,100.14 83.68,100.14 82.59,101.23 82.23,101.23 82.15,101.31 v1(81.7,101.31)
  BOTTOM w0.508: v1(84.07,96.44) 85.16,95.35 91.15,95.35 91.89,96.1 91.89,97.07 v1(87.22,101.74)
  vias: v1(93.32,102.66)
+3V3_TPM_VSB:
  vias: v1(91.82,96.11)
+3V_CR:
  vias: v1(29.19,64.67)
+3V_DEEP_SUS: length 220.4
  TOP w0.203: v2(121.09,114.19) 121.09,114.19 R97.2 ; v2(122.53,115.95) 122.53,115.93 122.56,115.9 R95.2 ; R186.1 85.36,132.58 v1(85.27,132.49) ; R117.2 82.18,131.46 v1(82.36,131.28)
  TOP w0.305: R123.2 114.93,118.03 R67530.2 115.52,118.62 R67529.2
  TOP w0.356: Q6568.5 Q6568.2 116.18,112.59 115.47,111.88 113.11,111.88 v1(113.03,111.97)
  TOP w0.381: v1(76.72,105.9) 77.05,106.23 77.05,116.11 77.35,116.42 77.35,119.36 77.15,119.56 77.15,121.67 78.56,123.08 79.83,123.08 ; Q6554.5 Q6554.2 10.98,165.33 v1(10.96,165.34) ; v2(115.09,117.42) 114.67,117.84 R123.2
  TOP w0.508: v1(126.2,120.81) 125.89,121.12 R1260.2
  IN1 w0.508: v1(81.58,123.88) 81.58,129.01 82.36,129.79 v1(82.36,131.28) ; v1(126.2,120.81) 125.54,120.81 124.87,120.14 124.87,118.16 123.71,117 123.58,117 v2(122.53,115.95) 122.53,115.2 121.53,114.19 v2(121.09,114.19) 120.24,115.04 119.48,115.04 119.39,114.95 116.3,114.95 115.89,114.53 113.05,114.53 112.93,114.42
  IN2 w0.381: v2(115.09,117.42) 115.58,117.91 120.19,117.91 122.16,115.95 v2(122.53,115.95)
  IN2 w0.508: 89.58,114.5 88.26,114.5 87.66,115.09 81.45,115.09 80.71,114.35 80.19,114.35 76.72,110.88 v1(76.72,105.9) 76.47,106.15 69.56,106.15 66.51,103.11 65.39,103.11 63.34,101.06 55.66,101.06 53.34,103.37 50.19,103.37 49.44,102.62 47.89,102.62 46.82,103.69 45.71,103.69 45.12,104.27 45.12,109.76 43.29,111.59 v1(43.29,113.03)
  IN3 w0.508: v1(10.96,165.34) 10.96,162.93 12.12,161.77 12.12,160.18 12.88,159.42 12.88,154.25 11.39,152.76 11.39,148.15 12.14,147.4 v1(13,147.4)
  BOTTOM w0.203: R104.1 113.13,115.02 R1273.2 ; v2(115.09,117.42) 115.09,117.53 115.44,117.89 R103.1
  BOTTOM w0.305: v2(104.31,111.9) 104.31,111.54 103.88,111.12 R1252.2
  BOTTOM w0.381: v1(85.27,132.49) 83.57,132.49 v1(82.36,131.28)
  BOTTOM w0.508: v1(13,147.4) 17.5,142.9 17.5,142.67 18.32,141.86 18.32,139.65 17.81,139.14 17.81,137.79 18.55,137.06 20.02,137.06 20.48,137.51 21.8,137.51 22.38,136.93 25.1,136.93 25.84,136.19 25.84,135.4 26.27,134.97 29.95,134.97 30.79,135.81 34.15,135.81 36.97,132.99 39.25,132.99 41.46,130.78 41.46,114.18 42.6,113.03 v1(43.29,113.03)
  vias: v1(91.73,108.89) v1(92.39,108.88) v1(111.71,114.6) v1(115.2,108.98) v1(115.86,108.98) v2(112.21,114.08) v2(112.33,113.47) v2(112.8,113.92) v2(112.96,113.33)
+3V_EC: length 6
  TOP w0.203: 150.34,105.54 U37.11
  TOP w0.254: v1(147.25,106.98) 146.91,106.64 R25317.2 147.73,105.97 148.07,106.31 R25307.2 148.71,106.31 149.13,105.89 C1189.1 149.55,105.89 149.91,105.54 150.34,105.54
+3V_LAN: length 16.2
  TOP w0.203: 19.85,171.11 19.85,169.82 19.79,169.76 U6521.19 ; U6521.15 21.39,170.06 22.26,170.93 22.26,171.17 ; v1(15.41,167.01) 15.82,167.01 16.22,166.61 U6521.29
  TOP w0.508: v1(13.89,162.18) R67512.1 R67510.1 R67511.1 ; R25445.2 v1(30.01,161.95) ; 19.85,171.11 19.85,172.82 C641.1 ; R67474.1 R9340.2 v1(29.99,163.85) 30.53,164.39 R67475.1 ; R4024.2 v1(11.95,165.87)
  BOTTOM w0.508: v1(15.41,167.01) 15.63,166.78 R67509.1
  vias: v1(22.38,175.08) v1(23.5,175.09) v1(24.19,175.09) v1(24.77,165.02) v1(25.38,165.5)
+3V_LDO_EC: length 366.7
  TOP w0.203: v1(166.78,113.92) 166.5,113.64 R25309.2 ; R361.2 161.79,113.49 v1(161.37,113.92) 161.03,113.58 R369.2 ; v1(163.17,113.69) 162.77,113.69 162.61,113.53 R25314.2 ; v1(17.34,115.03) 17.75,115.44 PD8004.1 18.48,115.44 18.66,115.26 PQ8014.1 19.79,115.26 20.98,114.07 22.81,114.07 PQ8016.4 ; PR8020.2 52.37,196.16 50.81,196.16 50.67,196.3 PR8010.1 49.79,196.67 v1(49.74,196.62) 49.72,196.61 49.72,196.05 48.06,194.38 47.75,194.38 41.99,188.62 41.99,180.7 40.25,178.96 40.25,178.03 39.14,176.92 33.85,176.92 32.94,177.83 v1(25.34,177.83)
  TOP w0.305: v1(170.78,110.22) 170.78,109.57 171.17,109.18 R67871.1
  TOP w0.381: v1(143.6,101.89) 144.01,101.89 144.27,102.15 R25300.2 144.27,103.03 144.2,103.11 D63.1 ; PR6017.1 172.22,132.75 172.22,133.62 v1(171.37,134.47) ; R67486.2 R67487.2 148.72,96.62 147.37,96.62 146.25,97.75 v1(146.25,98.23) 146.25,98.9 147.01,99.67 148.44,99.67 148.52,99.59 R67485.2 R67484.2
  TOP w0.508: v1(170.78,110.22) 170.71,110.15 R25306.1 ; v1(170.69,113.59) 171.07,113.98 R359.1 171.71,115.05 172.68,116.02 172.68,117.39 171.45,118.63 v1(171.45,120.12)
  IN2 w0.381: v1(143.6,101.89) 143.6,102.28 142.96,102.92 134.11,102.92 133.24,103.78 122.81,103.78 122.4,104.19 122.4,104.31 120.25,106.46 118.3,106.46 116.9,105.06 112.66,105.06 112.25,105.47 112.25,106.23 111.62,106.85 110.13,106.85 109.5,106.22 107.7,106.22 107.44,105.95 105.48,105.95 105.01,105.48 102.3,105.48 100.03,103.21 97.41,103.21 96.89,102.69 95.89,102.69 95.6,102.98 91.93,102.98 91.36,102.41 86.73,102.41 85.68,101.36 84.97,101.36 84.05,102.28 80.93,102.28 80.7,102.05 77.91,102.05 77.17,101.32 76.33,101.32 75.81,101.84 73.63,101.84 71.39,99.59 70.65,99.59 67.27,96.21 45.54,96.21 44.86,96.9 39.1,96.9 36.5,99.5 35.16,99.5 34.62,100.04 30.23,100.04 v1(30.12,100.15)
  IN3 w0.381: v1(170.69,113.59) 167.81,113.59 167.49,113.92 v1(166.78,113.92) 166.42,114.27 165.15,114.27 164.57,113.69 v1(163.17,113.69) 162.28,113.69 162.06,113.92 v1(161.37,113.92) 161.37,112.7 160.3,111.62 153.39,111.62 152.84,112.18 150.93,112.18 148.15,109.4 148.15,108.44 147.88,108.17 142.94,108.17 v1(142.79,108.32)
  IN3 w0.508: v1(170.69,113.59) 170.78,113.5 v1(170.78,110.22)
  IN4 w0.203: v1(17.34,115.03) 17.34,116.31 15.27,118.39 15.27,118.91 15.78,119.42 15.78,128.82 17.58,130.62 17.58,131.52 17.25,131.85 17.25,133.23 17.87,133.85 17.87,135.23 20.73,138.09 20.73,143.83 16.46,148.1 16.46,153.92 17.41,154.87 17.41,156.31 21.74,160.65 21.74,162.87 22.43,163.56 22.43,171.32 24.82,173.71 24.82,177.32 v1(25.34,177.83)
  IN4 w0.381: v1(171.45,120.12) 171.33,120.23 171.33,124.5 170.03,125.8 170.03,128.14 171.71,129.81 171.71,132.7 171.81,132.8 171.81,134.03 v1(171.37,134.47) ; v1(26.27,115.74) 27.39,114.62 28.44,114.62 29.42,113.63 29.42,110.37 29.26,110.21 29.26,107.17 28.61,106.52 28.61,104.06 29.68,102.99 29.68,101.82 30.12,101.38 v1(30.12,100.15)
  BOTTOM w0.381: v1(17.34,115.03) 17.63,115.32 25.17,115.32 25.58,115.74 v1(26.27,115.74) ; v1(146.25,98.23) 146.25,99.24 v1(143.6,101.89) 143.6,106.76 142.79,107.57 v1(142.79,108.32)
+3V_RTC: length 219.8
  TOP w0.305: U6525.3 136.91,211.95 136.7,211.75 C96343.1 ; 81.34,105.1 81.34,104.53 81.79,104.08 R979.1 ; 81.34,105.1 81.34,105.59 v1(81.42,105.67) 81.34,105.75 81.34,105.85 R971.1 ; 81.34,105.1 81.37,105.12 R42.2
  TOP w0.381: v1(135.44,204.76) 135.44,205.94 136.06,206.55 137.24,206.55 138.44,207.75 138.44,209.41 136.25,211.59 C96343.1
  TOP w0.508: v1(91.21,109.3) 90.96,109.55 R210.2
  IN1 w0.305: v1(85.21,178.53) 85.79,179.11 85.79,181.57 86.33,182.12 89.53,182.12 93.98,186.57 96.62,186.57 100.89,182.3 102.9,182.3 103.09,182.11 107.02,182.11 107.21,181.92 108.13,181.92 108.29,181.75 109.87,181.75 109.94,181.82 112.37,181.82 113.19,180.99 119.94,180.99 121.52,182.57 121.52,185.18 120.83,185.87 120.83,188.29 120.58,188.55 120.58,192.21 121.52,193.16 121.52,196.34 124.16,198.98 125.14,198.98 125.35,198.77 126.23,198.77 126.52,199.06 126.52,202.77 128.04,204.28 129.06,204.28 129.66,203.69 134.84,203.69 135.44,204.3 v1(135.44,204.76)
  IN2 w0.508: v1(85.21,178.53) 84.63,177.95 83.41,177.95 82.61,177.15 75.79,177.15 74.02,178.92 70.89,178.92 70.22,178.25 69.53,178.25 v1(69.31,178.47)
  IN4 w0.508: v1(91.21,109.3) 90.86,108.94 90.86,108.35 90.46,107.96 86.51,107.96 86.05,107.49 82.4,107.49 81.42,106.51 v1(81.42,105.67)
  BOTTOM w0.305: CN4.4 85.15,99.21 84.65,98.7
  BOTTOM w0.508: v1(77.83,101.11) 77.59,101.35 77.59,102.17 77.92,102.49 79.45,102.49 80.31,103.35 80.31,104.56 v1(81.42,105.67) 81.42,107.21 81.12,107.51 81.12,112.58 82.08,113.54 82.08,114.16 79.63,116.61 79.63,121.24 78.84,122.02 78.84,130.76 79.83,131.75 79.83,134.41 78.84,135.39 78.84,174.08 82.42,177.66 84.33,177.66 v1(85.21,178.53) ; v1(69.31,178.47) 68.82,178.96 R25310.1 ; v1(78.63,98.71) 78.8,98.88 83.24,98.88 83.42,98.7 84.65,98.7
  vias: v1(77.12,100.76)
+3V_RTC_0: length 150
  TOP w0.508: Q28.1 3.32,12.55 v1(2.79,12.55) ; v1(77.16,91.02) v1(77.16,94.23) 77.16,94.59 77.67,95.1 78.49,95.1 R953.1
  IN2 w0.508: v1(2.79,12.55) 5.11,12.55 5.53,12.96 10.41,12.96 11.89,14.45 16.49,14.45 28.24,26.2 31.15,26.2 33.77,28.82 33.77,36.17 33.34,36.6 33.07,36.6 31.83,37.84 31.83,53.28 32.53,53.98 32.53,63.83 31.83,64.53 31.83,76.17 35.31,79.65 35.31,86.23 36.27,87.19 36.27,88.28 38.64,90.66 76.8,90.66 v1(77.16,91.02)
  BOTTOM w0.508: CN1.1 2.79,11.57 v1(2.79,12.55)
+3V_RTC_1: length 3.7
  TOP w0.508: D72.1 77.62,97.37 v1(78.88,96.12) 79.28,95.72 R953.2
+3V_RTC_2: length 1.2
  TOP w0.508: D72.2 76.32,96.96 R978.2
+3V_S5: length 525.4
  TOP w0.203: v1(90.27,128.01) 89.72,128.01 R36.2 ; v1(83.78,123.87) 84.17,123.87 R152.2
  TOP w0.254: R40.2 83.68,122.36 v1(83.53,122.21) ; Q27.5 130.13,100.48 v1(130.45,100.8) ; v1(127.89,112.86) 127.89,112.9 128.93,113.94 128.93,114.73 126.78,116.87 126.57,116.87 126.05,117.4 126.05,118 R25439.2 125.4,118.64 124.89,119.15 124.33,119.15 123.8,119.68 122.83,119.68 121.62,120.89 R25437.2 ; R67889.1 121.92,122.62 121.92,122.26 121.8,122.14 121.8,122.07 R25437.2 ; R25437.2 121.3,122.21 121.3,122.74 R25438.2 ; R25330.1 169.68,114.97 170.25,114.97 v1(170.26,114.97) ; v1(91.28,105.93) 91.1,105.93 90.71,106.32 C2335.2 89.66,106.32 89.51,106.16 U2014.5
  TOP w0.305: R562.2 131.18,99.06 131.62,98.62 ; R67884.2 47.26,190.69 45.12,188.55 44.28,188.55 43.64,187.92 43.64,186.39 44.12,185.91 44.12,184.94 42.49,183.31 42.49,180.49 40.76,178.75 40.76,176.5 39.27,175.01 35.43,175.01 v1(34.85,175.58) ; R60.2 118.49,117.87 R25415.1 116.98,117.87 R25413.1 116.97,117.53 116.99,117.51 v1(116.99,117.19) ; C695.1 133.5,99.61 133.84,99.27 133.84,98.97 134.57,98.24 134.88,98.24 135.14,97.99 R566.2 ; R567.2 129.47,96.19 128.14,96.19 127.3,97.04 R574.2
  TOP w0.381: R41.1 74.26,123.47 74.26,117.34 v1(74.68,116.93) ; Q27.2 127.28,100.48 127.1,100.29 126.73,100.29 126.49,100.05 R559.2 126.08,99.22 126.08,98.44 126.38,98.13 v1(126.38,98.03) 126.38,97.96 126.75,97.59 R574.2 ; R38.2 84.24,135.52 R67883.2 87.11,135.52 87.86,134.77 R33.2 89.07,134.24 v1(89.54,133.78) ; v2(117.14,113.44) 117.56,113.85 117.56,116.82 117.19,117.19 v1(116.99,117.19) ; v1(87.13,124.66) 87.24,124.55 R35.2 87.85,124.7 88.71,125.56 R37.2 ; R25317.1 145.71,106.41 v1(146.89,107.59)
  TOP w0.508: v1(133.54,217.2) 133.54,216.96 R25622.1 ; R25618.2 v1(21.71,178.19) ; R25381.2 109.89,115.04 110.8,114.13 R25382.2 111.07,113.89 111.57,113.38 111.57,113 112.06,112.52 v1(112.52,112.52) ; v1(131.62,98) 131.62,98.86 132.38,99.61 C695.1 133.21,99.66 132.97,99.9 132.97,100.57 134.8,102.39 v1(134.8,104.82)
  IN1 w0.508: v1(89.54,133.78) 89.54,130.52 90.27,129.78 v1(90.27,128.01) 90.27,127.81 v1(87.13,124.66) 86.33,123.87 v1(83.78,123.87) 83.53,123.62 v1(83.53,122.21) 83.82,121.92 83.82,120.69 83.32,120.2 79.75,120.2 78.7,119.15 76.94,119.15 v1(75.22,117.44) ; v1(154.11,160.89) 154.11,164.81 152.25,166.67 150.17,166.67 148.34,168.5 142.08,168.5 136.66,173.92 132.96,173.92 v1(130.82,176.06)
  IN1 w1.016: 40.08,129.97 40.67,129.97 42.47,131.77 43.73,131.77 44.76,132.81 44.76,133.33 46.53,135.09 47.86,135.09 48.5,134.45 50.73,134.45 52.87,132.31 52.87,128.82 53.89,127.8 55.8,127.8 56.7,126.91 56.7,126.58 57.35,125.93 64.23,125.93 68.25,121.9 68.25,120.49 71.27,117.47
  IN2 w0.305: v1(21.71,178.19) 23.16,178.19 24.25,177.1 26.38,177.1 27.28,178 32.9,178 34.85,176.05 v1(34.85,175.58)
  IN2 w0.508: v1(165.37,124.67) 164.93,125.11 151.44,125.11 150.63,125.93 150.63,127.54 148.63,129.54 148.63,131.77 149.47,132.61 156.31,132.61 158.87,135.17 158.87,136.67 158.4,137.14 158.4,141.29 157.58,142.11 157.58,145.41 156.31,146.68 156.31,150 156.77,150.47 156.77,153.7 157.53,154.47 157.53,155.72 156.81,156.44 156.81,156.97 156.1,157.68 154.08,157.68 153.34,158.41 153.34,159.04 153.91,159.61 153.91,160.68 v1(154.11,160.89) ; v1(21.71,178.19) 20.67,177.15 18.22,177.15 12.64,171.58 12.64,168.77 8.71,164.83 8.71,159.4 9.4,158.71 10.04,158.71 10.45,158.31 10.45,148.87 13.07,146.25 14.6,146.25 15.24,145.61 15.24,144.93 18.3,141.87 18.3,139.76 17.59,139.05 17.59,135.59 16,134 16,132.02 15.31,131.33 15.31,118.94 v1(18.19,116.06) ; v1(23.16,66.24) v1(23.16,65.55) 23.16,62.8 15.62,55.26 15.62,47.56 4.71,36.65 4.71,34.73 3.51,33.53 v1(2.9,33.53)
  IN4 w0.508: v1(130.82,176.06) 130.82,176.66 126.82,180.66 126.82,181.61 124.36,184.07 124.36,185.69 124.13,185.93 124.13,188.71 124.44,189.01 124.44,191.95 124.83,192.34 124.83,195.88 124.59,196.11 124.59,197.14 126.73,199.27 126.73,205.77 127.5,206.54 127.5,208.26 132.04,212.8 132.04,215.86 132.46,216.28 133.11,216.28 133.54,216.7 v1(133.54,217.2) ; v1(169.25,119.36) 167.81,119.36 166.69,120.47 166.69,121.56 165.82,122.43 165.82,123.39 165.37,123.84 v1(165.37,124.67) ; v1(35.41,143.06) 37.79,143.06 38.75,142.1 38.75,135.86 37.65,134.76 37.65,132.68 38.75,131.58 v1(38.75,130.06)
  BOTTOM w0.254: R67483.2 111.83,112.71 112.02,112.52 v1(112.52,112.52) ; v2(117.14,113.44) 117.14,113.42 117.57,113 117.57,112.22 R25383.2 116.78,112.01 116.47,112.32 R604.2
  BOTTOM w0.305: v2(105.34,111.25) 105.05,111.55 105.05,111.89 R144.2 ; R605.2 117,117.18 v1(116.99,117.19) 116.99,117.55 R607.2 ; R606.2 116.69,114.06 116.66,114.03 R25477.2 ; v1(131.62,98) 132.6,98.98 CN33.1 132.6,100.45 132.36,100.68 131.44,100.68 131.32,100.8 v1(130.45,100.8)
  BOTTOM w0.381: R606.2 117.17,113.46 v2(117.14,113.44) ; R25397.2 93.49,109.92 92.83,110.58 R25396.2 92.83,111.03 92.56,111.3 92.56,111.83 92.02,112.37 v1(92.02,112.46) ; v1(92.02,114.5) 92.02,116.58 92.87,117.43 R25395.2 92.89,117.45 93.06,117.48 R25390.2 93.9,118.32 94.12,118.32 94.85,119.05 R25389.2 ; v1(134.43,109.89) 134.26,109.89 133.39,110.77 128.27,110.77 127.56,111.48 127.56,112.53 v1(127.89,112.86) ; v2(105.34,111.25) 106.26,111.25 106.68,111.67 R25384.2
  BOTTOM w0.508: R25472.2 132.36,103.61 133.02,102.94 134.54,102.94 Q29.2 135.38,104.24 v1(134.8,104.82) ; v1(126.38,98.03) 126.38,97.4 126.78,96.99 131.24,96.99 131.62,97.38 v1(131.62,98)
  vias: v1(20.32,116.69) v1(38.75,129.4) v1(79.7,111.58) v1(80.27,112.02) v1(81.61,112.34) v1(84.17,109.78) v1(94.33,107.35) v1(94.99,107.35) v1(193.06,118.32) v1(193.43,117.76) v1(193.88,118.26) v1(207.37,126.54) v1(207.37,125.88) v1(208.03,126.54) v1(208.03,125.88) v1(208.69,126.54) v1(208.69,125.88) v1(209.35,126.54) v1(209.35,125.88)
+3V_SM: length 32.4
  TOP w0.381: C20041.1 223.31,97.97 222.7,97.36 222.08,97.36 221.9,97.53 U6509.10 ; 221.78,100.59 221.33,100.13 U6509.14 ; U6509.18 211.88,98.18
  TOP w0.508: v1(209.26,96.69) R25555.1 210.11,96.92 210.88,97.7 C20043.1 211.13,98.18 211.88,98.18 ; v1(218.16,98.07) 218.16,99.88 C20048.1 C20049.2 v1(221.8,101.5) 221.8,100.6 221.78,100.59 ; C20041.1 v1(222.53,98.07)
  IN4 w0.508: v1(209.26,96.69) 210.63,98.07 v1(218.16,98.07) v1(222.53,98.07)
+3V_SSD: length 4
  BOTTOM w0.381: R649.1 18.39,81.38 18.06,81.05 18.06,78.41
  vias: v1(11.59,75.13)
+3V_WLAN_P: length 23.7
  TOP w0.254: R651.2 184.13,109.59 Q33.2 ; Q63.2 183.95,112.16 183.67,111.88 R652.2
  TOP w0.508: 184.73,112.16 184.73,113.23 184.44,113.53 184.44,121.22 185.46,122.25 191.92,122.25 ; 184.73,112.16 185.11,111.78 185.11,110.57 Q33.2 ; 184.73,112.16 Q63.2
  BOTTOM w0.203: R671.2 194.57,111.78 194.59,111.75 v1(194.97,111.75) 194.98,111.77 195.36,111.77 R672.2
  vias: v1(192.73,105.17) v1(192.74,104.46) v1(192.96,121.76) v1(192.99,111.5) v1(193.42,105.17) v1(193.43,104.45) v1(193.63,121.76) v1(194.36,121.78) v1(195.06,121.77) v1(195.74,121.76)
+3VLCD_CON:
  vias: v1(76.48,191.97)
+3VLCD_CON_R:
  vias: v1(72.8,192.1) v1(73.41,191.84) v1(73.38,190.98)
+3VLCD_CON_R_C: length 2.4
  TOP w0.305: v1(74.74,191.83) 75.36,192.44 R25456.2
  BOTTOM w0.305: v1(74.74,191.83) 74.49,191.83 74.15,192.17 CN29.37
+3VPCU: length 376
  TOP w0.254: PR8037.2 18.11,113.74 18.45,113.74 18.88,114.18 v1(19.18,114.18) 19.36,114 PR8058.1 ; PR8048.2 26.16,114.66 v1(26.23,114.73) ; PR8038.1 31.63,116.33 v1(31.91,116.61)
  TOP w0.305: v1(136.78,101.88) 136.78,102.18 135.74,103.22 135.74,105.15 139.54,108.95 v1(141.41,108.95) 142.26,109.79 143.94,109.79 145.65,111.5 R25323.2 ; v1(147.53,108.82) 147.11,108.4 146.26,108.4 146.01,108.14 R25304.2
  TOP w0.381: 172.4,130.55 PR6003.1 ; v1(51.42,195.54) 50.4,194.53 48.98,194.53 48.28,193.83 47.97,193.83 42.53,188.39 42.53,186.26 v1(43.46,185.33) ; v1(147.53,108.82) 147.86,109.15 R383.2 148.18,110.22 R67604.2 ; PR8019.1 53.57,196.69 v1(53.44,196.69) 53.23,196.91 PR8011.1
  TOP w0.508: 172.4,130.55 171.36,131.59 171.36,133.29 v1(171.06,133.59) ; R736.1 v1(24.97,26.5) ; v1(210.1,106.08) C735.2 209.64,101.11 209.14,101.61 v1(209.14,102.07) ; R25519.1 149.99,209.05 v1(149.31,208.37)
  IN1 w0.508: v1(33.92,172.77) 37.28,172.77 40.77,176.26 40.77,177.75 43.19,180.16 43.19,185.06 v1(43.46,185.33) 44.27,186.14 50.26,186.14 53.87,189.75 55.9,189.75 58.26,192.11 63.29,192.11 65.96,194.78 69.8,194.78 71.87,192.71 74.97,192.71 75.52,192.16 76.58,192.16 79.95,188.79 87,188.79 87.16,188.63 v1(88.23,188.63) 88.23,189.24 89.07,190.09 93.08,190.09 93.66,189.51 97.94,189.51 100.97,186.48 101.83,186.48 103.02,185.29 106.24,185.29 107.24,184.28 108.54,184.28 108.78,184.04 110.64,184.04 110.89,184.29 113.45,184.29 113.67,184.52 115.27,184.52 116.22,185.46 116.22,186.37 117.88,188.03 117.88,194.58 118.49,195.19 118.49,196.22 120.95,198.67 120.95,206.09 121.57,206.71 123.76,206.71 124.29,207.23 125.06,207.23 125.74,207.91 127.38,207.91 127.98,207.3 132.01,207.3 132.79,206.52 134.59,206.52 134.87,206.24 135.65,206.24 135.98,206.56 136.71,206.56 137.39,205.89 139.82,205.89 140.74,206.81 147.75,206.81 v1(149.31,208.37)
  IN2 w0.508: v1(171.06,133.59) 171.62,133.59 173.4,131.81 173.4,129.12 176.52,126 178.92,126 179.59,125.32 188,125.32 190.84,128.16 195.72,128.16 ; v1(229.66,123.38) 229.1,122.81 224.95,122.81 223.57,121.43 220.98,121.43 220.49,120.94 214.51,120.94 213.88,120.31 213.04,120.31
  IN3 w0.305: v1(141.41,108.95) 142.1,109.63 146.72,109.63 v1(147.53,108.82)
  IN3 w0.381: v1(155.25,114.15) 155.25,114.63 155.59,114.98 156.81,114.98 157.13,114.66 160.09,114.66 160.83,115.41 162.59,115.41 162.67,115.32 v1(163.51,115.32)
  IN3 w0.508: v1(22.61,44.27) 23.24,44.9 25.41,44.9 v1(25.59,44.72) 25.91,44.41 25.91,35.44 25.63,35.16 25.17,35.16 23.15,33.15 23.15,30.65 24.33,29.47 24.33,26.93 24.76,26.5 v1(24.97,26.5)
  IN4 w0.508: v1(171.06,133.59) 170.94,133.48 170.94,130.18 169.29,128.53 169.29,122.84 v1(168.71,122.25) ; v1(25.59,44.72) 26.27,45.4 26.27,46.19 25.59,46.86 25.59,51.2 23.44,53.35 23.44,58.4 21.88,59.96 21.88,62.91 22.23,63.26 v1(22.23,64.25)
  BOTTOM w0.254: v1(209.14,102.07) 209.42,102.07 209.85,101.65 CN52.2 ; v1(229.66,123.38) 229.25,122.96 CN55.5
  BOTTOM w0.305: v1(209.45,112.04) CN48.6
  BOTTOM w0.381: R25370.1 R25368.2 88.75,189.15 v1(88.23,188.63) ; v1(53.44,196.69) 52.29,195.54 v1(51.42,195.54) ; v1(155.25,114.15) 154.96,114.44 PR204.2
  BOTTOM w0.508: v1(114.28,100.45) 114.4,100.58 114.4,104.39 115.15,105.14 115.15,107.58 114.91,107.82 111.75,107.82 111.58,107.65 R25295.2 ; PR9.2 PR18.2 PR15.2 163.26,115.08 v1(163.51,115.32) 164.48,115.32 164.84,115.68 165.55,115.68 166.1,116.23 166.1,117.78 166.84,118.52 166.84,119.22 167.53,119.9 167.78,119.9 168.71,120.83 v1(168.71,122.25) ; v1(25.59,44.72) 25.98,44.33 26.79,44.33 27.35,43.77 Q6548.2 ; v1(22.61,44.27) 22.72,44.16 Q6566.2
  vias: v1(16.04,115.41) v1(16.07,116.14) v1(22.26,64.91) v1(32.54,172.84) v1(38.59,167.61) v1(38.61,166.93) v1(42.13,118.19) v1(42.14,117.48) v1(42.14,116.82) v1(54.07,100.31) v1(54.73,100.31) v1(55.4,100.31) v1(74.15,98.51) v1(75.44,97.18) v1(75.52,98.54) v1(76.98,98.54) v1(195.47,127.37) v1(196.16,127.38) v1(196.95,130.14) v1(197.63,130.16)
+3VPCU_EC: length 170.2
  TOP w0.152: U37.92 167.88,107.94 167.99,108.05
  TOP w0.203: 155.76,112.04 U37.121 ; U37.114 158.56,112.07 158.71,112.21 158.98,112.21 159.24,112.47 C6575.1 159.16,112.72 v1(158.7,112.72) ; U37.26 150.12,99.54 149.5,98.93 C6578.1 ; U37.50 159.76,96.58 v1(159.87,96.69) ; v1(169.9,96.36) 169.85,96.31 C6570.1
  TOP w0.254: L29.1 173.23,100.86 173.94,100.15 175.72,100.15 176.15,99.72 176.15,97.61 v1(176.13,97.58) ; 155.76,112.04 155.48,112.32 155.17,112.32
  TOP w0.381: v1(147.04,98.23) 147.04,98.46 147.67,99.08 148.06,99.08 148.22,98.93 C6577.1 C6578.1 ; v1(153.24,112.87) 153.29,112.83 C6574.1 154.52,112.32 155.17,112.32
  TOP w0.508: L30.2 149.85,112.86 150.43,113.43 152.81,113.43 153.24,113 v1(153.24,112.87)
  IN2 w0.508: v1(178.41,113.89) 176.34,113.89 171.49,109.04 v1(168.84,109.04) ; v1(208.6,102.84) 208,102.84 206.1,100.95 200.22,100.95 199.07,99.8 196.87,99.8 196.16,100.5 193.38,100.5 192.73,99.85 192.73,99.51 192.16,98.93 177.75,98.93 176.93,98.11 176.93,97.88 176.63,97.58 v1(176.13,97.58) 176.13,97.86 175.54,98.45 172.75,98.45 172.55,98.24 170.26,98.24 169.9,97.89 v1(169.9,96.36) 169.7,96.36 169.17,96.9 165.76,96.9 165.15,96.29 160.28,96.29 v1(159.87,96.69)
  IN3 w0.508: v1(201.3,110.07) 199.36,110.07 198.14,108.85 194.48,108.85 190.39,112.94 186.62,112.94 186,113.56 180.52,113.56 180.19,113.89 v1(178.41,113.89) 177.95,113.43 172.52,113.43 171.59,114.37 170.45,114.37 170.38,114.29 168.1,114.29 167.43,114.97 164.78,114.97 164.2,114.39 162.62,114.39 162.3,114.71 161.12,114.71 160.19,113.78 159.7,113.78 159.29,113.36 159.29,113.12 158.89,112.72 v1(158.7,112.72) 158.3,112.32 153.79,112.32 v1(153.24,112.87)
  IN4 w0.508: v1(208.6,102.84) 202.83,108.62 202.83,109.02 201.78,110.07 v1(201.3,110.07)
  BOTTOM w0.508: v1(147.04,98.23) 147.04,97.68 147.47,97.25 152.5,97.25 153.73,96.02 159.53,96.02 159.87,96.36 v1(159.87,96.69)
  vias: v1(168.66,108.25)
+3VPCU_ECPLL: length 3.8
  TOP w0.203: 153.13,112.25 153.36,112.01 U37.127
  TOP w0.254: 153.13,112.25 152.76,112.25 152.65,112.14 C6573.1
  TOP w0.381: L30.1 150.86,112.14 C6573.1
+3VSPI: length 48.6
  TOP w0.203: R586.2 81.5,100.51 v1(81.56,100.56)
  TOP w0.305: v1(80.06,100.48) 80.15,100.39 80.15,98.13 80.83,97.45 81.14,97.45 81.49,97.1 R583.2
  IN1 w0.508: v1(80.06,100.48) 80.14,100.56 v1(81.56,100.56)
  IN2 w0.762: 120.73,101.2 119.98,100.45 118.83,100.45 117.67,99.28 110.58,99.28 109.74,100.13 108.66,100.13 107.81,99.28 100.61,99.28 100.53,99.37 96.45,99.37 95.86,98.78
  IN4 w0.508: v1(81.56,100.56) 81.56,100.08 82.7,98.93 93.79,98.93 94.03,98.69 v1(94.03,98.25)
  vias: v1(93.81,99.49) v1(94.69,98.25) v1(117.3,107.67) v1(118.01,107.69) v1(120.37,101.88) v1(121.07,101.89)
+4.6V_PD_C1: length 16.3
  TOP w0.381: PR8063.2 24.11,109.89 v1(23.77,110.22)
  TOP w0.508: PU8001.5 35.85,109.51 34.39,110.98 33.35,110.98 33.05,111.27 PC8009.1 32.11,111.27 32.09,111.29 PC8010.1 31.34,110.61 PR8053.1 29.63,110.31 PQ8017.3 28.33,110.57 28.01,110.89 v1(28.01,111.32)
  BOTTOM w0.381: v1(28.01,111.32) 24.87,111.32 v1(23.77,110.22)
+5V: length 174.7
  TOP w0.381: U6509.13 221.61,99.48 222.11,99.98 ; v1(12.05,158.17) 12.49,157.74 R25528.1 ; 221.95,93.52 221.84,93.63 U6509.4 ; v1(9.35,162.56) 9.35,161.53 R25529.1
  TOP w0.508: v1(57.31,91.7) 57.31,93 57.26,93.04 R67565.2 ; v1(223.31,101.77) C20044.1 C20045.2 222.23,100.1 222.11,99.98 ; v1(223.31,92.12) C20039.1 222.48,92.99 221.95,93.52
  IN1 w0.381: v1(9.35,162.56) 9.35,160.87 v1(12.05,158.17) 14.16,156.07 14.16,155.52 15.22,154.47 17.17,154.47 20.89,150.74 v1(21.65,150.74)
  IN1 w1.016: 22.29,40.9 21.71,41.48 15.52,41.48 14.94,42.06 11.42,42.06 10,40.64 10,34.91
  IN4 w1.016: 10.17,36.3 10.17,42.05 15.95,47.83 15.95,54.77 15.32,55.4 15.32,55.94 11.85,59.41 11.85,63.73 11.15,64.43 11.15,67.1 11.63,67.57 11.63,69.4 10.87,70.16 10.87,71.4 10.82,71.44 10.82,74.42 13.59,77.18 14.12,77.18 18.81,81.87 18.81,84.92 17.52,86.21 17.52,95.13 16.82,95.83 16.82,99.08 17.33,99.59 17.33,99.74 18.08,100.49 18.08,101.21 17.33,101.96 17.33,104.16 18.22,105.05 18.22,108.96 18.24,108.98 18.24,110.36 20.4,112.53 20.4,114.79 19.32,115.88 19.32,117.99 18.4,118.91 18.4,120.25 18.73,120.59 18.73,134.59 19.52,135.37
  BOTTOM w0.381: v1(167.48,116.66) 167.48,119.01 167.78,119.31 168.03,119.31 169.4,120.67 169.4,122.45 168.44,123.41 R25373.1
  BOTTOM w0.508: Q30.1 214.54,123.27 214.39,123.12 C734.2 213.29,122.64 212.9,122.26 R579.1 212.9,121.16 v1(213.03,121.03)
  vias: v1(9.96,33.18) v1(10.48,33.65) v1(20.75,136.79) v1(20.75,136.13) v1(20.75,135.47) v1(21.41,136.79) v1(21.41,136.13) v1(22.27,151.15) v1(22.29,150.46) v1(23.96,40.71) v1(24.66,40.74) v1(29.7,160.94) v1(29.7,160.28) v1(29.88,176.95) v1(30.45,176.58) v1(30.36,160.94) v1(30.36,160.28) v1(30.62,161.57) v1(30.92,177.07) v1(31.02,160.94) v1(31.02,158.04) v1(31.63,158.31) v1(34.55,192.22) v1(35.21,192.22) v1(35.86,192.59) v1(61.9,195.87) v1(62.28,195.33) v1(62.68,195.87) v1(72.88,189.94) v1(72.89,189.27) v1(73.5,189.62) v1(166.81,116.66) v1(214.06,123.79) v1(217.66,120.9) v1(222.19,110.33) v1(222.21,109.67) v1(222.2,109.01) v1(222.2,108.35)
+5V_FAN:
  vias: v1(172.93,111.17)
+5V_HDD:
  vias: v1(225.33,105.99) v1(225.76,104.82) v1(226.11,104.21) v1(226.57,104.82) v1(226.88,104.21)
+5V_HDMIC:
  vias: v1(12.64,132.84) v1(13.08,132.21) v1(13.41,132.86) v1(13.77,132.2) v1(14.35,133.19)
+5V_KB:
  vias: v1(218.57,122.73) v1(219.02,123.46) v1(219.69,123.45) v1(222.56,133.91) v1(223.22,133.91)
+5V_PD: length 102.7
  TOP w0.381: PQ8018.4 26.74,111.12 27.21,110.64
  TOP w0.508: v1(16.18,56.95) 19.15,59.92 21.62,59.92 22.58,60.87 25.68,60.87 28.45,63.64 v1(28.45,72.87) 29.02,73.44 29.02,77.9 25.18,81.73 20.14,81.73 v1(19.22,80.81) ; 27.21,110.64 27.4,110.46 v1(27.4,110.2) 27.83,109.77 28.79,109.77 29.34,109.22 PD8005.1 29.68,107.68 29.97,107.39 PR8051.2
  IN4 w0.508: v1(17.67,43.49) 16.79,44.38 16.79,45.61 17.8,46.62 17.8,54.14 16.18,55.76 v1(16.18,56.95) ; v1(27.4,110.2) 26.63,110.2 24.51,108.09 24.51,106.7 23.62,105.81 21.4,105.81 20.46,106.76 19.93,106.76 19.08,105.91 19.08,104.69 18.72,104.34 18.72,101.78 18.94,101.56 18.94,100.13 18.72,99.91 18.72,99.77 17.68,98.73 17.68,96.19 18.39,95.48 18.39,88.83 19.3,87.92 19.3,86.59 19.8,86.09 19.8,81.39 v1(19.22,80.81)
  BOTTOM w0.508: v1(17.67,43.49) 17.93,43.24 R25589.1
+5V_PVDD: length 4.7
  BOTTOM w0.203: U20.46 21.01,36.09 21.77,36.85 ; U20.41 19.01,36.46 18.84,36.63 18.84,37.93 19.21,38.3
  vias: v1(21.77,37.18)
+5V_S5: length 292.1
  TOP w0.203: PR9091.2 168.46,157.35 168.8,157.7 169.12,157.7 v3(169.19,157.77)
  TOP w0.508: v1(155.55,146.42) 155.55,146.03 155.97,145.6 156.68,145.6 157.13,145.15 158.89,145.15 159.88,144.17 PR7103.2 159.31,143.03 159.31,141.82 159.66,141.48 159.93,141.48 PR7064.1 159.5,140.66 159.5,139.88 160.28,139.11 160.28,137.07 160.74,136.61 160.74,134.1 160.92,133.92 v1(160.92,132.73) 160.92,132.33 161.78,131.46 PR7116.1 ; PR9100.1 158.27,168.55 v1(158.01,168.28) 155.67,165.94 155.67,163.32 154.94,162.6 v1(153.15,162.6) ; v1(79.92,192.37) 79.63,192.37 79.14,191.88 79.14,189.93 78.12,188.9 77.31,188.9 76.72,188.31 74.85,188.31 74.55,188.61 73.71,188.61 73.17,188.07 PR5003.1 ; v1(105.66,200.74) 104.93,200.74 PR9001.1
  IN1 w0.508: v1(48.26,195.52) 48.77,196.03 50.61,196.03 51.5,196.92 52.75,196.92 53.16,197.33 54.19,197.33 54.96,196.56 63.05,196.56 63.34,196.27 70.3,196.27 72.46,194.12 75.55,194.12 76.1,193.57 77.27,193.57 78.47,192.37 v1(79.92,192.37)
  IN2 w0.508: v1(137.13,174.73) 137.13,174.39 136.3,173.55 123.95,173.55 121.51,175.99 117.53,175.99 116.99,176.54 v1(116.99,177.22) ; v1(153.15,162.6) 153.15,159.92 152.58,159.36 152.58,158.1 153.76,156.92 155.79,156.92 156.01,156.69 156.01,150.78 155.55,150.32 v1(155.55,146.42) ; v1(79.92,192.37) 79.92,192.73 82.92,195.73 83.02,195.83 89.51,195.83 93.91,200.23 95.92,200.23 97.64,201.96 101.77,201.96 102.99,200.74 v1(105.66,200.74) 105.66,199.48 103.61,197.43 103.61,194.51 104.37,193.75 104.37,193.14 v1(103.81,192.58)
  IN3 w0.508: v1(158.01,168.28) 158.01,168.97 157.13,169.84 154.75,169.84 154.01,170.59 151.19,170.59 150.14,169.54 141.14,169.54 137.13,173.54 v1(137.13,174.73) ; v1(116.99,177.22) 116.99,187.13 117.42,187.57 117.42,189.82 116.56,190.68 114.78,190.68 114.43,190.33 114.43,189.89 113.78,189.24 111.94,189.24 111.26,188.56 107.17,188.56 105.1,190.62 105.1,191.29 v1(103.81,192.58) ; v1(35.55,159.29) 36.51,160.25 36.51,163.52 36.01,164.03 36.01,165.44 36.83,166.27 36.83,167.73 36.15,168.41 36.15,171.1 40.23,175.18 40.23,177.83 42.83,180.42 42.83,188.31 45.64,191.13 45.64,192.91 v1(48.26,195.52)
  IN4 w0.508: v1(158.01,168.28) 158.09,168.37 164.29,168.37 166.33,166.33 166.33,161.2 168.57,158.96 168.57,158.4 v3(169.19,157.77)
  BOTTOM w0.508: PR9013.1 104.68,192.77 104.68,192.18 PR9074.1 104.42,191.97 v1(103.81,192.58) ; v1(155.55,146.42) 155.14,146.42 PR7080.1 ; PR9087.1 168.5,157.82 169.15,157.82 v3(169.19,157.77) ; v1(160.92,132.73) 160.92,132.33 161.5,131.75 162.48,131.75 164.13,133.4 PR7065.1 164.32,133.9 164.32,134.77 PR7069.1 ; PR7112.1 154.59,162.75 PR7108.1 153.47,161.86 153.47,162.28 v1(153.15,162.6)
  vias: v1(22.63,93.72) v1(31.32,108.89) v1(32.5,112.59) v1(32.46,111.94) v1(33.12,111.96) v1(33.16,112.62) v1(33.37,110.29) v1(34.23,159.29) v1(34.23,158.63) v1(34.23,157.97) v1(34.89,159.29) v1(34.89,158.63) v1(34.89,157.97) v1(34.91,109.37) v1(35.55,158.63) v1(35.55,157.97) v1(42.72,99.31) v1(43.38,99.31) v1(44.04,99.31) v1(44.7,99.31) v1(45.36,99.31) v1(46.02,99.31) v1(216.66,110.17) v1(217.09,109.5) v1(217.32,110.12) v1(217.63,109.11) v1(217.99,110.17) v1(218.65,110.3) v1(219.28,110.53)
+5VA:
  vias: v1(14.15,28.29)
+5VPCU: length 247.3
  TOP w0.203: PR6023.1 35.64,169.47 v1(36.82,169.47)
  TOP w0.381: v1(19.61,102.51) 17.45,102.51 16.19,101.25 16.19,100.11 15.29,99.2 R418.1 15.29,98.31 R417.1 ; v1(28.42,107.63) PR8049.1 ; v1(207.65,130.66) 206.81,129.82 202.41,129.82 PR6013.1
  TOP w0.508: PR9069.1 v1(87.8,184.17) ; v1(147.13,127.15) 146.35,127.93 PR104.1 146.35,128.72 145.95,129.12 145.95,129.85 v1(146.09,129.99) ; v1(9.43,11.33) 9.43,11.83 9.46,11.87 R67361.1 9.46,13.02 9.18,13.3 R67360.1 ; v1(168.14,118.6) 168.14,119.34 170.64,121.84 175.98,121.84 179.23,125.09 186.69,125.09 v1(188,126.4)
  IN1 w0.508: v1(9.43,11.33) 9.43,12.29 11.33,14.2 16.27,14.2 26.55,24.47 26.55,40.83 24.89,42.5 19.53,42.5 17.55,44.48 14.36,44.48 v1(13.72,43.84)
  IN1 w1.524: 177.37,126.04 177.61,125.8 178.52,125.8 178.86,125.46 187.06,125.46 v1(188,126.4) 190.26,128.66 196.81,128.66
  IN2 w1.524: 152.85,168.5 152.06,169.29 148.19,169.29 147.25,168.35 142.69,168.35 139.39,171.65 129.73,171.65 129.17,171.08 123.52,171.08 121.23,173.38 116.26,173.38 113.12,176.52 108.54,176.52 105.53,179.53 105.5,179.53 104.83,180.2 104.83,180.23 103.53,181.53
  IN4 w0.381: v1(23.57,100.69) 23.57,101.15 23.12,101.59 20.53,101.59 v1(19.61,102.51)
  IN4 w0.508: v1(168.14,118.6) 167.49,118.6 165.92,120.17 165.22,120.17 164.87,120.52 164.87,122.34 164.15,123.06 163.06,123.06 162.46,123.66 159.05,123.66 157.79,124.92 151.66,124.92 150.37,126.2 150.37,127.79 147.85,130.31 146.86,130.31 146.54,129.99 v1(146.09,129.99)
  BOTTOM w0.203: PR98.2 147.13,126.8 v1(147.13,127.15)
  BOTTOM w0.508: v1(13.72,43.84) 13.82,43.94 13.82,45.81 12.59,47.04
  BOTTOM w1.016: 29.02,113.38 31.36,113.38 32.56,114.59 34.6,114.59 35.94,115.94 37.27,115.94 40.49,112.72 40.49,105.89 42.3,104.07 42.99,104.07 46.62,100.44 49.03,100.44
  vias: v1(9.29,46.91) v1(9.95,46.92) v1(10.7,46.95) v1(11.41,46.94) v1(11.82,48.83) v1(11.82,48.17) v1(12.48,48.83) v1(12.48,48.17) v1(15.55,57.55) v1(15.59,58.22) v1(21.85,99.56) v1(22.91,100.03) v1(22.91,99.37) v1(23.57,100.03) v1(23.57,99.37) v1(27.72,113.09) v1(28.03,112.48) v1(32.52,165.19) v1(32.49,164.49) v1(33.23,165.1) v1(33.2,164.4) v1(36.7,164.92) v1(36.7,164.24) v1(37.33,165.17) v1(37.33,164.45) v1(39.34,180.74) v1(39.79,181.24) v1(39.88,180.31) v1(40.29,181.69) v1(40.35,180.79) v1(42.01,178.01) v1(41.99,177.34) v1(42.43,178.54) v1(89.81,188.63) v1(103.44,186.93) v1(104.11,186.95) v1(161.61,132.58) v1(161.97,133.13) v1(162.45,133.58) v1(222.9,126.36) v1(223.31,126.88) v1(223.59,126.28)
