# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ33: length 61.8
  IN3 w0.084: v2(104.86,149.34) 104.49,148.98 103.29,148.98 103.24,148.93 102.26,148.93 99.67,146.33 99.67,145.14 98.99,144.46 92.43,144.46 90.2,142.23 84.92,142.23 71.25,128.57 68.15,128.57 67.5,127.92 63.1,127.92 63.01,127.83 63.01,127.64 62.93,127.55 62.76,127.55 62.68,127.63 62.68,127.83 62.59,127.92 62.42,127.92 62.34,127.83 62.34,127.53 62.26,127.46 62.09,127.46 62,127.55 62,127.83 61.92,127.92 60.58,127.92 60.4,127.75 60.4,127.45 60.51,127.35 61.4,127.35 61.52,127.23 v1(61.52,126.92)
  BOTTOM w0.102: v2(104.86,149.34) 104.53,149.02 U1.AJ30
  BOTTOM w0.114: v1(61.52,126.92) 61.52,127.4 61.86,127.74 63.67,127.74 63.84,127.57 JDIM02.169
M_B_DQ34: length 62.2
  IN3 w0.084: v1(58.7,124.99) 59.34,124.35 61.85,124.35 63.18,125.68 70.51,125.68 78.09,133.26 79.28,133.26 79.59,133.58 79.59,134.1 79.36,134.34 79.36,134.53 82.86,138.03 82.98,138.03 83.19,137.82 83.3,137.82 83.42,137.94 83.42,138.06 83.21,138.27 83.21,138.39 83.34,138.51 83.45,138.51 83.66,138.3 83.78,138.3 83.9,138.42 83.9,138.53 83.69,138.74 83.69,138.86 83.81,138.98 83.93,138.98 84.14,138.77 84.26,138.77 84.38,138.89 84.38,139.01 84.17,139.22 84.17,139.34 84.29,139.46 84.41,139.46 84.62,139.25 84.74,139.25 84.86,139.37 84.86,139.49 84.65,139.7 84.65,139.82 84.77,139.94 84.89,139.94 85.1,139.73 85.22,139.73 85.34,139.85 85.34,139.97 85.13,140.18 85.13,140.3 85.49,140.66 90.36,140.66 92.32,142.62 98.47,142.62 100.47,144.62 100.47,145.75 101.48,146.76 102.06,146.76 102.78,147.48 v2(102.88,147.48)
  BOTTOM w0.102: v2(102.88,147.48) 103.23,147.13 U1.AM32
  BOTTOM w0.114: v1(58.7,124.99) 58.03,124.32 JDIM02.182
M_B_DQ35: length 62.2
  IN3 w0.084: v2(103.56,147.52) 103.47,147.52 103.01,147.07 102.7,147.07 102.15,146.53 101.61,146.53 100.7,145.62 100.7,144.55 98.5,142.35 92.39,142.35 90.35,140.31 86.27,140.31 83.4,137.44 82.75,137.44 81.17,135.86 81.17,135.75 81.35,135.56 81.35,135.47 81.23,135.35 81.09,135.35 80.93,135.51 80.81,135.51 80.69,135.39 80.69,135.27 80.85,135.11 80.85,134.99 80.73,134.87 80.61,134.87 80.45,135.03 80.34,135.03 79.93,134.62 79.93,133.36 79.48,132.91 78.22,132.91 70.65,125.34 63.32,125.34 61.94,123.95 60.11,123.95 60.05,123.89 60.05,123.38 59.91,123.24 59.75,123.24 59.65,123.34 59.65,123.86 59.56,123.95 58.8,123.95 58.68,123.84 58.68,123.76 v1(58.98,123.47)
  BOTTOM w0.102: U1.AM31 103.88,147.2 v2(103.56,147.52)
  BOTTOM w0.114: JDIM02.186 57.72,123.32 57.99,123.06 58.56,123.06 v1(58.98,123.47)
M_B_DQ36: length 63
  IN3 w0.084: v1(62.78,123.48) 62.78,124.32 63.46,125 63.8,125 63.88,124.92 63.88,124.48 63.97,124.4 64.14,124.4 64.22,124.48 64.22,124.92 64.31,125 64.48,125 64.56,124.92 64.56,124.48 64.64,124.4 64.81,124.4 64.9,124.48 64.9,124.92 64.98,125 65.15,125 65.24,124.92 65.24,124.48 65.32,124.4 65.49,124.4 65.57,124.48 65.57,124.92 65.66,125 65.83,125 65.91,124.92 65.91,124.48 66,124.4 66.17,124.4 66.25,124.48 66.25,124.92 66.33,125 66.5,125 66.59,124.92 66.59,124.48 66.67,124.4 66.84,124.4 66.92,124.48 66.92,124.92 67.01,125 67.18,125 67.26,124.92 67.26,124.48 67.35,124.4 67.52,124.4 67.6,124.48 67.6,124.92 67.68,125 67.85,125 67.94,124.92 67.94,124.6 68.02,124.52 68.2,124.52 68.28,124.6 68.28,124.92 68.36,125 70.79,125 78.34,132.55 79.62,132.55 80.27,133.2 80.27,133.83 81.69,135.25 81.69,135.9 82.89,137.1 83.54,137.1 83.89,137.45 86.4,139.95 90.46,139.95 91.7,141.19 97.62,141.19 100.94,144.51 100.94,145.53 101.75,146.35 102.23,146.35 102.77,146.89 103.07,146.89 103.33,147.15 103.83,147.15 v2(104.21,147.52)
  BOTTOM w0.102: U1.AM30 104.53,147.2 v2(104.21,147.52)
  BOTTOM w0.114: JDIM02.183 63.26,124.07 62.78,123.59 v1(62.78,123.48)
M_B_DQ37: length 62.9
  IN3 w0.084: v2(104.86,147.52) 104.32,146.98 103.4,146.98 103.13,146.71 102.85,146.71 102.3,146.17 101.88,146.17 101.12,145.41 101.12,144.38 97.69,140.95 91.78,140.95 90.43,139.6 86.52,139.6 83.34,136.42 83.23,136.42 83.02,136.63 82.9,136.63 82.78,136.51 82.78,136.4 82.99,136.19 82.99,136.07 82.87,135.95 82.75,135.95 82.54,136.16 82.42,136.16 82.3,136.04 82.3,135.92 82.51,135.71 82.51,135.59 80.61,133.69 80.61,133.06 79.76,132.22 78.48,132.22 70.93,124.66 69.58,124.66 69.31,124.39 69.03,124.39 68.98,124.45 68.98,124.58 68.9,124.65 68.67,124.65 68.61,124.6 68.61,124.33 68.34,124.06 64.17,124.06 64,123.89 64,123.23 63.75,122.99 60.87,122.99 60.73,123.12 60.73,123.45 60.87,123.58 61.36,123.58 v1(61.46,123.48)
  BOTTOM w0.102: v2(104.86,147.52) 105.18,147.2 U1.AM29
  BOTTOM w0.114: v1(61.46,123.48) 61.9,123.04 63.75,123.04 63.79,123.07 JDIM02.187
M_B_DQ38: length 60
  IN3 w0.084: v2(104.21,149.34) 103.73,149.82 102.62,149.82 99.27,146.48 99.27,145.34 98.82,144.89 92.04,144.89 90.09,142.95 84.62,142.95 70.92,129.24 67.87,129.24 67.22,128.59 61.78,128.59 61.64,128.74 58.93,128.74 58.59,128.4 v1(58.59,126.83)
  BOTTOM w0.102: U1.AJ31 103.88,149.02 v2(104.21,149.34)
  BOTTOM w0.114: JDIM02.174 57.67,126.32 57.68,126.32 58.46,126.32 58.59,126.45 v1(58.59,126.83)
M_B_DQ39: length 60.5
  IN3 w0.084: v2(103.56,149.34) 103.25,149.65 102.71,149.65 99.46,146.4 99.46,145.22 98.93,144.69 92.24,144.69 90.14,142.59 84.77,142.59 71.08,128.9 68.01,128.9 67.36,128.26 61.64,128.26 61.5,128.4 59.17,128.4 59.05,128.27 59.05,127.92 59.16,127.81 59.72,127.81 59.92,127.61 v1(59.92,126.87)
  BOTTOM w0.102: U1.AJ32 103.23,149.02 v2(103.56,149.34)
  BOTTOM w0.114: v1(59.92,126.87) 59.47,127.32 JDIM02.170
M_B_DQ40: length 61.2
  IN3 w0.084: v2(104.21,145.7) 104.21,146.12 104.12,146.2 103.35,146.2 103.27,146.29 102.68,146.29 102.38,145.99 102.07,145.99 101.3,145.21 101.3,144.21 99.8,142.71 99.8,142.04 99.51,141.75 98.85,141.75 97.79,140.68 91.83,140.68 91.08,139.93 91.08,139.42 90.65,138.99 86.74,138.99 81.2,133.44 81.2,132.81 80.01,131.62 78.72,131.62 71.17,124.07 69.82,124.07 69.22,123.47 65.07,123.47 63.98,122.38 60.56,122.38 60.33,122.61 58.7,122.61 58.57,122.48 v1(58.57,121.83)
  BOTTOM w0.102: v2(104.21,145.7) 103.88,145.37 U1.AR31
  BOTTOM w0.114: v1(58.57,121.83) 58.07,122.32 JDIM02.190
M_B_DQ41: length 61
  IN3 w0.084: v1(59.89,121.83) 59.89,121.97 60.04,122.12 60.33,122.12 60.44,122.02 64.1,122.02 65.21,123.13 69.36,123.13 69.96,123.73 71.31,123.73 74.81,127.24 75.92,127.24 77.12,128.44 77.12,129.55 78.86,131.29 80.15,131.29 81.54,132.67 81.54,133.3 86.87,138.63 90.72,138.63 91.43,139.34 91.43,139.94 91.94,140.45 97.81,140.45 98.93,141.57 99.58,141.57 100.04,142.03 100.04,142.68 101.48,144.11 101.48,145.09 102.2,145.81 102.45,145.81 102.76,146.11 103.17,146.11 v2(103.58,145.7)
  BOTTOM w0.102: U1.AR32 103.23,145.35 v2(103.58,145.7)
  BOTTOM w0.114: JDIM02.194 58.71,121.32 58.86,121.18 59.82,121.18 60,121.36 60,121.72 v1(59.89,121.83)
M_B_DQ42: length 63.6
  IN3 w0.084: v2(104.22,143.87) 103.85,143.5 103.41,143.5 103.06,143.16 103.06,142.72 98.29,137.95 97.9,137.95 97.26,137.3 92.73,137.3 91.41,135.99 89.97,135.99 85.59,131.61 84.55,131.61 84.21,131.26 84.21,130.45 83.07,129.32 82.06,129.32 77.41,124.67 75.8,124.67 71.75,120.61 68.16,120.61 66.48,118.93 65.77,118.93 65.62,118.77 65.62,117.69 65.51,117.58 65.2,117.58 65.1,117.68 65.1,118.16 64.99,118.27 64.81,118.27 64.73,118.19 64.73,117.53 64.66,117.46 64.33,117.46 64.25,117.55 64.25,118 64.16,118.09 63.99,118.09 63.91,118 63.91,117.55 63.83,117.46 60.37,117.46 v1(59.89,117.94)
  BOTTOM w0.102: v2(104.22,143.87) 104.53,143.55 U1.AV30
  BOTTOM w0.114: v1(59.89,117.94) 58.62,119.21 57.93,119.21 57.8,119.08 57.54,118.82 JDIM02.204
M_B_DQ43: length 63.8
  IN3 w0.084: v1(58.57,117.94) 59.44,117.07 66,117.07 66.7,117.76 66.7,118.67 68.3,120.28 68.64,120.28 68.73,120.19 68.73,119.68 68.8,119.61 68.97,119.61 69.06,119.71 69.06,120.19 69.15,120.28 69.32,120.28 69.4,120.19 69.4,119.68 69.47,119.61 69.64,119.61 69.74,119.71 69.74,120.19 69.82,120.28 71.89,120.28 75.94,124.33 77.55,124.33 82.2,128.98 83.24,128.98 84.38,130.12 84.83,130.12 85.16,130.45 85.16,130.68 90.12,135.63 91.46,135.63 92.89,137.06 97.27,137.06 97.98,137.77 98.36,137.77 103.23,142.63 103.23,143.09 103.48,143.33 104.31,143.33 v2(104.86,143.88)
  BOTTOM w0.102: v2(104.86,143.88) 105.18,143.55 U1.AV29
  BOTTOM w0.114: JDIM02.208 57.46,117.82 57.78,117.5 58.12,117.5 v1(58.57,117.94)
M_B_DQ44: length 62.2
  IN3 w0.084: v2(104.86,145.7) 104.48,145.33 103.07,145.33 100.31,142.56 100.31,142.02 99.66,141.37 99.01,141.37 98.47,140.83 98.47,140.57 97.4,139.5 92.03,139.5 90.8,138.28 87.11,138.28 81.87,133.03 81.87,132.53 80.29,130.95 79.02,130.95 78.78,130.71 78.78,130.59 79.16,130.21 79.16,130.09 79.04,129.97 78.92,129.97 78.54,130.35 78.42,130.35 78.3,130.23 78.3,130.11 78.71,129.71 78.71,129.6 78.59,129.47 78.46,129.47 78.06,129.87 77.94,129.87 77.82,129.75 77.82,129.63 78.34,129.12 78.34,129 76.24,126.9 74.95,126.9 71.45,123.39 70.1,123.39 69.5,122.79 65.35,122.79 64.22,121.66 61.9,121.66 v1(61.54,121.3)
  BOTTOM w0.102: v2(104.86,145.7) 104.53,145.37 U1.AR30
  BOTTOM w0.114: JDIM02.195 64,121.07 63.64,120.71 62.08,120.71 61.54,121.26 v1(61.54,121.3)
M_B_DQ45: length 62.4
  IN3 w0.084: v2(105.51,145.7) 104.97,145.16 103.16,145.16 100.53,142.53 100.53,141.94 99.77,141.18 99.07,141.18 98.7,140.8 98.7,140.48 97.52,139.3 94.69,139.3 94.59,139.21 92.16,139.21 90.87,137.92 87.24,137.92 86.14,136.82 86.14,136.71 86.41,136.44 86.41,136.33 86.29,136.21 86.16,136.21 85.9,136.47 85.78,136.47 85.66,136.35 85.66,136.23 85.95,135.94 85.95,135.82 85.83,135.7 85.71,135.7 85.42,135.99 85.31,135.99 85.18,135.87 85.18,135.75 85.48,135.46 85.48,135.34 85.36,135.22 85.24,135.22 84.95,135.51 84.83,135.51 84.71,135.39 84.71,135.27 85,134.98 85,134.86 84.88,134.74 84.76,134.74 84.47,135.03 84.35,135.03 84.23,134.91 84.23,134.79 84.52,134.5 84.52,134.38 84.4,134.26 84.28,134.26 83.99,134.55 83.87,134.55 83.75,134.43 83.75,134.32 84.04,134.02 84.04,133.91 76.7,126.56 75.09,126.56 71.59,123.06 70.24,123.06 69.64,122.45 65.49,122.45 63.8,120.77 63.2,120.77 v1(62.84,121.13)
  BOTTOM w0.102: U1.AR29 105.18,145.37 v2(105.51,145.7)
  BOTTOM w0.114: JDIM02.191 63.28,122.07 62.84,121.64 v1(62.84,121.13)
M_B_DQ46: length 62.1
  IN3 w0.084: v1(61.27,117.94) 61.27,118.75 60.93,119.09 59.71,119.09 59.6,119.2 59.6,119.49 59.71,119.6 66.2,119.6 67.88,121.29 71.47,121.29 75.52,125.35 77.13,125.35 81.78,130 82.74,130 83.49,130.75 83.49,131.55 88.64,136.7 91.36,136.7 92.47,137.81 94.7,137.81 95.57,138.68 98.44,138.68 101.31,141.55 101.31,142.38 102.79,143.86 102.96,143.86 v2(102.98,143.87)
  BOTTOM w0.102: U1.AV32 103.23,143.62 v2(102.98,143.87)
  BOTTOM w0.114: v1(61.27,117.94) 61.89,117.32 63.25,117.32 64,118.07 JDIM02.207
M_B_DQ47: length 62.3
  IN3 w0.084: v2(103.6,143.88) 103.52,143.88 103.08,143.44 102.84,143.44 102.79,143.39 102.57,143.39 101.49,142.3 101.49,141.48 98.49,138.48 95.67,138.48 94.77,137.58 92.63,137.58 91.39,136.34 89.82,136.34 85.44,131.96 84.41,131.96 83.85,131.41 83.85,130.6 82.91,129.66 81.92,129.66 77.27,125.01 75.66,125.01 71.61,120.95 68.02,120.95 66.34,119.26 64.95,119.26 64.86,119.18 64.86,118.72 64.77,118.63 64.6,118.63 64.53,118.7 64.53,119.18 64.44,119.26 64.27,119.26 64.19,119.18 64.19,118.51 64.1,118.42 63.93,118.42 63.85,118.51 63.85,119.18 63.77,119.26 63.6,119.26 63.51,119.18 63.51,118.51 63.43,118.42 63.26,118.42 63.17,118.51 63.17,119.18 63.09,119.26 61.88,119.26 61.77,119.15 61.77,118.93 61.85,118.85 62.51,118.85 62.59,118.76 v1(62.59,117.94)
  BOTTOM w0.102: v2(103.6,143.88) 103.88,143.6 U1.AV31
  BOTTOM w0.114: v1(62.59,117.94) 63.72,119.07 JDIM02.203
M_B_DQ48: length 59.8
  IN3 w0.084: v1(59.28,115.37) 61.16,116.14 66.39,116.14 68.93,118.68 71.61,118.68 76.33,123.4 77.93,123.4 82.58,128.05 83.67,128.05 84.44,128.82 84.84,128.82 89,132.97 89.87,132.97 91.63,134.73 92.25,134.73 93.45,135.93 97.3,135.93 98.07,136.71 98.33,136.71 98.71,137.08 98.71,137.24 99.26,137.79 99.82,137.79 100.34,138.32 100.34,139.2 103.2,142.05 v2(103.56,142.05)
  BOTTOM w0.102: v2(103.56,142.05) 103.56,141.68 103.48,141.6 U1.BA32
  BOTTOM w0.114: v1(59.28,115.37) 57.83,116.82 JDIM02.212
M_B_DQ49: length 60.7
  IN3 w0.084: v2(103.56,141.14) 102.87,141.14 100.7,138.98 100.7,138.17 99.97,137.43 99.41,137.43 99.09,137.11 99.09,136.83 98.46,136.2 98.27,136.2 97.48,135.4 93.83,135.4 92.45,134.01 92.11,134.01 87.42,129.33 86.32,129.33 85.09,128.11 84.73,128.11 84.21,127.59 84.21,126.92 82.26,124.97 80.46,124.97 78.21,122.73 76.61,122.73 71.89,118.01 69.21,118.01 66.67,115.46 64.83,115.46 64.31,114.94 64.13,114.94 63.99,115.08 63.99,115.38 63.9,115.46 63.73,115.46 63.65,115.38 63.65,114.91 63.57,114.82 61.55,114.82 v1(61.01,115.36)
  BOTTOM w0.102: v2(103.56,141.14) 103.88,141.47 U1.BA31
  BOTTOM w0.114: JDIM02.211 62.73,117.07 v1(61.01,115.36)
M_B_DQ50: length 62.5
  IN3 w0.084: v2(104.21,139.32) 103.83,138.94 103.31,138.94 99.97,135.61 99.86,135.61 97.85,133.6 96.19,133.6 95,132.4 95,131.9 94.27,131.17 92.69,131.17 86.26,124.74 86.26,124.23 83.63,121.6 81.21,121.6 78.86,119.25 76.37,119.25 72.83,115.7 70.76,115.7 66.35,111.29 64.03,111.29 63.37,110.63 61.12,110.63 60.56,111.2 v1(60.56,111.47)
  BOTTOM w0.102: v2(104.21,139.32) 103.88,139.64 U1.BD31
  BOTTOM w0.114: JDIM02.229 63.98,112.57 63.08,111.68 63.08,111.42 62.63,110.96 61.06,110.96 v1(60.56,111.47)
M_B_DQ51: length 62.2
  IN3 w0.084: v1(60.1,113.74) 61.48,112.36 64.9,112.36 65.16,112.63 65.16,113.14 65.26,113.24 65.53,113.24 65.62,113.15 65.62,112.5 65.76,112.36 65.99,112.36 66.1,112.48 66.1,113.18 66.24,113.31 66.93,113.31 70.34,116.72 72.41,116.72 77.17,121.48 78.74,121.48 80.52,123.27 81.69,123.27 81.92,123.49 82.47,123.49 87.15,128.17 88.18,128.17 93.59,133.58 93.59,133.73 93.86,134 95.23,134 95.74,134.5 97.68,134.5 99.43,136.25 99.87,136.25 102.83,139.21 102.83,139.66 103.4,140.23 v2(103.56,140.23)
  BOTTOM w0.102: U1.BD32 103.23,139.91 v2(103.56,140.23)
  BOTTOM w0.114: JDIM02.228 59.18,112.82 v1(60.1,113.74)
M_B_DQ52: length 61.5
  IN3 w0.084: v1(57.96,115.37) 59.07,116.48 66.25,116.48 68.79,119.02 70.31,119.02 70.39,119.1 70.39,119.6 70.47,119.68 70.64,119.68 70.73,119.6 70.73,119.1 70.81,119.02 71.47,119.02 76.19,123.74 77.79,123.74 82.44,128.39 83.51,128.39 84.29,129.17 84.72,129.17 88.88,133.33 89.72,133.33 91.47,135.07 92.15,135.07 93.24,136.17 97.22,136.17 97.97,136.92 98.26,136.92 98.52,137.18 98.52,137.33 99.25,138.06 99.77,138.06 100.1,138.39 100.1,139.22 103.34,142.45 103.8,142.45 v2(104.21,142.05)
  BOTTOM w0.102: v2(104.21,142.05) 104.53,141.73 U1.BA30
  BOTTOM w0.114: v1(57.96,115.37) 57.5,115.82 JDIM02.216
M_B_DQ53: length 62.5
  IN3 w0.084: v1(62.34,115.35) 62.79,115.8 66.53,115.8 69.07,118.34 71.75,118.34 76.47,123.06 78.07,123.06 80.59,125.59 80.81,125.59 81.09,125.31 81.24,125.31 81.4,125.48 81.4,125.58 81.05,125.94 81.05,126.04 81.21,126.2 81.33,126.2 81.95,125.57 82.08,125.57 82.19,125.69 82.19,125.81 81.57,126.44 81.57,126.56 81.69,126.68 81.8,126.68 82.23,126.25 82.35,126.25 82.47,126.38 82.47,126.49 82.04,126.92 82.04,127.04 82.64,127.63 83.11,127.63 83.3,127.44 83.3,127.32 83.38,127.25 83.64,127.25 83.73,127.34 83.73,127.6 84.58,128.46 84.97,128.46 86.19,129.69 87.28,129.69 91.98,134.39 92.36,134.39 93.67,135.7 97.41,135.7 98.17,136.47 98.39,136.47 98.91,136.99 98.91,137.19 99.34,137.61 99.89,137.61 100.52,138.24 100.52,139.12 102.92,141.52 104.33,141.52 v2(104.86,142.05)
  BOTTOM w0.102: U1.BA29 105.18,141.73 v2(104.86,142.05)
  BOTTOM w0.114: v1(62.34,115.35) 63.06,116.07 JDIM02.215
M_B_DQ54: length 63.5
  IN3 w0.084: v2(104.86,139.34) 104.5,139.7 103.42,139.7 103.19,139.47 103.19,139.06 99.95,135.82 99.71,135.82 97.79,133.91 96.01,133.91 95.33,133.22 94.79,133.22 94.35,132.78 93.8,132.78 88.51,127.49 87.49,127.49 87.25,127.25 87.25,127.14 87.37,127.02 87.37,126.89 87.25,126.77 87.15,126.77 87.02,126.9 86.9,126.9 86.78,126.78 86.78,126.66 87.17,126.27 87.17,126.15 87.05,126.03 86.93,126.03 86.54,126.42 86.42,126.42 86.3,126.3 86.3,126.18 86.69,125.79 86.69,125.67 86.26,125.25 85.18,125.25 84.75,124.82 84.75,123.76 83.81,122.82 82.26,122.82 82.01,122.56 81.69,122.56 79.93,120.81 77.45,120.81 72.69,116.04 70.62,116.04 66.21,111.63 63.52,111.63 62.86,110.97 62.37,110.97 v1(61.88,111.47)
  BOTTOM w0.102: v2(104.86,139.34) 105.18,139.67 U1.BD29
  BOTTOM w0.114: JDIM02.225 63.98,113.57 63.51,113.1 62.93,113.1 61.88,112.04 v1(61.88,111.47)
M_B_DQ55: length 63
  IN3 w0.084: v1(58.78,113.76) 58.78,112.91 59.72,111.97 66.07,111.97 70.48,116.38 72.55,116.38 77.31,121.15 79.79,121.15 81.55,122.9 81.87,122.9 82.12,123.16 83.67,123.16 84.41,123.9 84.41,124.96 87.29,127.83 88.35,127.83 93.63,133.12 94.21,133.12 94.63,133.53 95.16,133.53 95.8,134.18 97.67,134.18 99.51,136.02 99.89,136.02 103.01,139.14 103.01,139.55 103.33,139.87 104.5,139.87 v2(104.86,140.23)
  BOTTOM w0.102: v2(104.86,140.23) 104.53,139.91 U1.BD30
  BOTTOM w0.114: JDIM02.224 57.53,113.82 57.96,114.25 58.28,114.25 v1(58.78,113.76)
M_B_DQ56: length 63.1
  IN3 w0.084: v1(59.27,111.43) 59.29,111.43 62.21,108.51 66.81,108.51 67.92,109.62 67.92,110.58 69.99,112.65 70.95,112.65 72.26,113.95 73.38,113.95 77.41,117.98 79.38,117.98 81.19,119.8 83.97,119.8 85.01,120.84 86,120.84 87.37,122.21 87.37,122.43 95.34,130.4 95.62,130.4 96.56,131.34 96.74,131.34 99.65,134.25 100.18,134.25 100.49,134.56 100.49,135.21 103.3,138.02 103.84,138.02 v2(104.21,138.38)
  BOTTOM w0.102: v2(104.21,138.38) 103.88,138.06 U1.BG31
  BOTTOM w0.114: v1(59.27,111.43) 58.59,110.75 57.76,110.75 57.68,110.82 JDIM02.236
M_B_DQ57: length 62.9
  IN3 w0.084: v1(62.24,109.78) 62.24,109.61 62.94,108.91 66.73,108.91 67.58,109.76 67.58,111.21 69.98,113.61 70.1,113.61 70.71,113 70.83,113 70.95,113.12 70.95,113.24 70.34,113.85 70.34,113.97 70.46,114.09 70.58,114.09 71.19,113.48 71.31,113.48 71.43,113.6 71.43,113.72 70.82,114.33 70.82,114.45 71.15,114.77 73.73,114.77 77.27,118.32 79.24,118.32 81.05,120.14 83.51,120.14 85.83,122.46 86.9,122.46 95.19,130.75 95.47,130.75 96.39,131.67 96.69,131.67 99.49,134.47 100.07,134.47 100.28,134.67 100.28,135.33 103.35,138.4 v2(103.53,138.4)
  BOTTOM w0.102: v2(103.53,138.4) 103.23,138.1 U1.BG32
  BOTTOM w0.114: JDIM02.233 63.84,111.57 63.68,111.41 63.68,111.29 62.26,109.87 62.26,109.8 v1(62.24,109.78)
M_B_DQ58: length 62.9
  IN3 w0.084: v2(103.57,135.68) 103.53,135.68 100.55,132.7 100.55,131.79 95,126.24 95,125.47 94.48,124.95 93.28,124.95 85.39,117.05 81.53,117.05 80.15,115.68 78.92,115.68 77.17,113.93 77.05,113.93 76.8,114.18 76.69,114.18 76.56,114.06 76.56,113.94 76.81,113.69 76.81,113.57 76.69,113.45 76.57,113.45 76.33,113.7 76.21,113.7 76.09,113.58 76.09,113.46 76.33,113.21 76.33,113.09 76.21,112.97 76.1,112.97 75.85,113.22 75.73,113.22 75.61,113.1 75.61,112.98 75.86,112.73 75.86,112.62 75.62,112.38 75.5,112.38 75.25,112.62 75.13,112.62 74.96,112.45 74.96,112.37 75.12,112.21 75.12,112.09 74.81,111.78 73.16,111.78 67.42,106.04 64.41,106.04 63.85,105.47 62.3,105.47 v1(61.87,105.9)
  BOTTOM w0.102: U1.BK32 103.23,136.02 v2(103.57,135.68)
  BOTTOM w0.114: v1(61.87,105.9) 61.87,106.15 63.29,107.57 JDIM02.249
M_B_DQ59: length 64.2
  IN3 w0.084: v2(104.18,135.68) 103.76,135.26 103.48,135.26 100.79,132.56 100.79,130.71 97.57,127.5 96.7,126.88 95.8,125.98 95.3,125.27 94.64,124.61 93.42,124.61 85.53,116.72 81.67,116.72 80.29,115.34 79.06,115.34 75.16,111.44 73.3,111.44 67.56,105.7 64.55,105.7 63.99,105.13 61.31,105.13 v1(60.55,105.9)
  BOTTOM w0.102: v2(104.18,135.68) 104.18,135.83 U1.BK31
  BOTTOM w0.114: JDIM02.245 62.38,108.57 60.55,106.74 v1(60.55,105.9)
M_B_DQ60: length 64
  IN3 w0.084: v1(63.55,109.78) 63.55,109.97 63.76,110.18 63.98,110.18 64.04,110.12 64.04,109.39 64.14,109.3 64.32,109.3 64.46,109.44 64.46,110.57 64.53,110.64 64.81,110.64 64.88,110.58 64.88,109.41 64.99,109.3 65.18,109.3 65.28,109.39 65.28,110.62 65.34,110.69 65.56,110.69 65.67,110.58 65.67,109.49 65.78,109.39 66.73,109.39 67.25,109.9 67.25,110.56 67.01,110.8 67.01,111.11 71.01,115.11 73.59,115.11 77.13,118.66 79.1,118.66 80.92,120.47 83.34,120.47 86.49,123.62 87.56,123.62 95.33,131.39 95.58,131.39 96.26,132.08 96.71,132.08 99.55,134.91 99.55,134.98 99.95,135.39 100.05,135.39 103.16,138.5 103.16,138.56 103.38,138.78 105.11,138.78 v2(105.51,138.38)
  BOTTOM w0.102: v2(105.51,138.38) 105.18,138.06 U1.BG29
  BOTTOM w0.114: JDIM02.237 63.65,110.57 63.48,110.4 63.48,109.85 v1(63.55,109.78)
M_B_DQ61: length 63.6
  IN3 w0.084: v2(104.86,138.38) 104.32,137.85 103.4,137.85 100.72,135.16 100.72,134.53 100.21,134.02 99.79,134.02 96.8,131.04 96.77,131.04 95.78,130.04 95.49,130.04 87.73,122.28 87.73,122.06 86.15,120.48 85.39,120.48 84.37,119.46 81.33,119.46 79.52,117.65 77.55,117.65 73.52,113.62 72.4,113.62 70.86,112.08 70.46,112.08 68.45,110.07 68.45,109.67 66.9,108.12 62.08,108.12 60.5,109.7 59.69,109.7 v1(57.98,111.41)
  BOTTOM w0.102: U1.BG30 104.53,138.06 v2(104.86,138.38)
  BOTTOM w0.114: JDIM02.232 57.57,111.82 v1(57.98,111.41)
M_B_DQ62: length 64.7
  IN3 w0.084: v1(59.32,105.42) 60.27,106.38 67.28,106.38 73.02,112.11 74.15,112.11 76.7,114.67 76.96,114.67 77.14,114.49 77.25,114.49 78.25,115.49 78.25,115.73 78.54,116.01 80.01,116.01 81.96,117.96 85.82,117.96 98.43,130.57 99.03,130.57 100.33,131.87 100.33,132.81 101.64,134.12 101.64,134.89 102.81,136.05 104.5,136.05 v2(104.83,135.72)
  BOTTOM w0.102: U1.BK30 104.83,135.82 v2(104.83,135.72)
  BOTTOM w0.114: JDIM02.246 57.47,108.32 57.71,108.09 57.71,107.59 59.32,105.98 v1(59.32,105.42)
M_B_DQ63: length 65.2
  IN3 w0.084: v2(104.79,136.58) 104.42,136.22 102.74,136.22 101.43,134.91 101.43,134.24 100.07,132.88 100.07,131.99 98.98,130.91 98.29,130.91 85.68,118.3 81.82,118.3 79.87,116.35 77.91,116.35 77.67,116.11 77.67,115.99 77.91,115.75 77.91,115.63 77.79,115.51 77.67,115.51 77.43,115.76 77.31,115.76 77.19,115.63 77.19,115.52 77.43,115.27 77.43,115.15 77.31,115.03 77.2,115.03 76.95,115.28 76.83,115.28 74.01,112.45 72.88,112.45 67.14,106.72 58.94,106.72 v1(58.11,105.89)
  BOTTOM w0.102: v2(104.79,136.58) 105.18,136.19 U1.BK29
  BOTTOM w0.114: JDIM02.250 57.6,107.32 58.11,106.81 v1(58.11,105.89)
M_B_DQSN0: length 62
  IN3 w0.079: v2(107.93,162.2) 107.67,162.47 107.56,162.47 107.38,162.64 107.38,163.47 106.92,163.93
  IN3 w0.089: 106.92,163.93 106.92,163.93 104.04,166.81 102.65,166.81 101,168.46 96.56,168.46 96.35,168.67 81.1,168.67 80.99,168.56 80.99,168.14 80.73,167.87 80.27,167.87 80.03,168.11 80.03,168.55 79.91,168.66 79.6,168.66 79.49,168.55 79.49,168.12 79.28,167.91 78.84,167.91 78.64,168.11 78.64,168.44 78.52,168.56 78.25,168.56 78.13,168.44 78.13,168.08 77.91,167.85 70.89,167.85 67.55,164.51 61.38,164.51 60.22,163.35 59.42,163.35 59.23,163.54 59.23,164.02 59.15,164.1 v1(58.65,164.1)
  BOTTOM w0.102: v1(58.65,164.1) 59.01,164.1 59.13,163.99 59.13,163.47 59,163.34 58.22,163.34 57.89,163.68 57.61,163.68 57.46,163.82 JDIM02.32 ; U1.H24 108.3,161.84 v2(107.93,162.2)
M_B_DQSN1: length 68.2
  IN3 w0.089: v2(106.91,170.74) 107.2,170.74 107.29,170.83 107.29,171 106.78,171.51 105.97,171.51 105,172.48 98.37,172.48 97.88,172.97 96.1,172.97 95.48,173.59 95.42,173.65 94.12,173.65 93.86,173.91 91.64,173.91 91.03,173.29 88.46,173.29 87.67,172.51 73.21,172.51 72.34,171.64 69.11,171.64 67.82,170.34 59.3,170.34 59.19,170.23 59.19,169.91 59.27,169.82 v1(59.89,169.82)
  BOTTOM w0.079: U1.C23 109.02,164.59 108.94,164.51 108.86,164.51 108.77,164.57 108.75,164.71 108.75,164.81 108.78,164.98 108.78,165.19 108.75,165.29 108.75,165.49 108.78,165.62 108.78,165.94 108.54,166.19 108.54,169.47 108.59,169.53 108.59,170.39 108.04,170.94 107.54,170.94 107.33,170.74 v2(106.91,170.74)
  BOTTOM w0.102: JDIM02.11 63.91,169.07 63.72,168.88 63.53,168.88 62.74,169.68 61.29,169.68 60.93,169.33 59.38,169.33 59.13,169.58 59.13,169.72 59.23,169.82 v1(59.89,169.82)
M_B_DQSN2: length 55.5
  IN3 w0.079: v2(104.86,162.11) 104.65,162.33 104.65,162.43 104.43,162.64 102.57,162.64 102.46,162.75 101.87,162.75 101.36,163.26 101.36,163.27 101.35,163.28
  IN3 w0.089: v1(61.74,158.62) 61.41,158.62 61.29,158.5 61.29,158.11 61.38,158.02 62.47,158.02 62.87,158.42 62.87,158.92 63.05,159.09 63.6,159.09 63.78,158.92 63.78,158.42 63.85,158.35 64.34,158.35 64.42,158.43 64.42,158.87 64.6,159.05 67.34,159.05 68.89,160.59 70.22,160.59 73.88,164.25 93.11,164.25 93.28,164.42 100.21,164.42 101.35,163.28
  BOTTOM w0.102: v2(104.86,162.11) 104.86,162.2 104.53,162.53 U1.G30 ; JDIM02.53 63.89,158.57 63.76,158.44 63.18,158.44 62.75,158.01 61.27,158.01 60.91,158.37 60.91,158.49 61.05,158.62 v1(61.74,158.62)
M_B_DQSN3: length 55
  IN3 w0.079: v2(104.79,159.34) 104.52,159.61 104.52,159.72 104.35,159.89 102.67,159.89 102.22,160.35 101.25,160.35 101.23,160.36
  IN3 w0.089: v1(59.86,152.43) 59.51,152.43 59.37,152.29 59.37,151.96 59.43,151.9 60.64,151.9 61.63,152.89 65.02,152.89 65.92,153.79 68.85,153.79 75.37,160.32 93.75,160.32 93.89,160.17 98,160.17 98.9,159.58 99.07,159.58 100.69,160.14 100.91,160.36 101.23,160.36
  BOTTOM w0.102: U1.L30 104.53,159.6 v2(104.79,159.34) ; v1(59.86,152.43) 59.5,152.43 59.4,152.53 59.4,152.73 58.91,153.22 57.83,153.22 57.73,153.32 JDIM02.74
M_B_DQSN4: length 61.3
  IN3 w0.079: v2(103.58,148.43) 103.81,148.2 103.81,148.12 103.76,148.06 103.23,148.06 103.18,148.02 101.95,148.02 101.61,147.68
  IN3 w0.089: v1(60.02,125.03) 60.24,125.03 60.41,125.2 60.41,126.01 60.74,126.35 70.23,126.35 85.24,141.36 90.36,141.36 92.16,143.17 97.75,143.17 98.47,143.89 99.06,143.89 100.08,144.91 100.08,146.15 101.61,147.68
  BOTTOM w0.102: U1.AL31 103.88,148.11 103.58,148.41 v2(103.58,148.43) ; JDIM02.177 63.78,125.57 63.64,125.43 62.77,125.43 62.24,125.96 60.8,125.96 60.59,125.74 60.59,125.25 60.37,125.03 v1(60.02,125.03)
M_B_DQSN5: length 61.4
  IN3 w0.079: 102.45,144.13 102.73,144.42 103.73,144.42 103.84,144.53 103.84,144.71 103.76,144.79 v2(103.56,144.79)
  IN3 w0.089: 102.45,144.13 100.83,142.52 100.83,141.78 98.14,139.1 95,139.1 94.84,138.93 92.54,138.93 91.72,138.11 91.72,138.11 91.01,137.4 88.35,137.4 82.79,131.84 82.79,131.11 82.35,130.67 81.5,130.67 76.85,126.02 75.25,126.02 71.19,121.96 66.01,121.96 64.32,120.27 61.63,120.27 60.75,121.15 59.65,121.15 59.41,120.92 59.41,120.67 58.94,120.2 v1(58.74,120.2)
  BOTTOM w0.102: U1.AU31 103.88,144.46 v2(103.56,144.79) ; JDIM02.198 57.49,120.32 57.65,120.16 57.65,119.98 57.9,119.73 58.91,119.73 59.07,119.89 59.07,120.12 58.99,120.2 v1(58.74,120.2)
M_B_DQSN6: length 61.8
  IN3 w0.079: 102.98,140.32 103.26,140.61 103.83,140.61 v2(104.21,140.23)
  IN3 w0.089: v1(61.52,113.75) 61.85,113.75 62.03,113.56 62.03,113.26 62.23,113.07 64.23,113.07 64.92,113.76 64.92,114.58 65.11,114.78 65.64,114.78 65.77,114.65 65.77,114.02 65.98,113.8 66.55,113.8 66.83,114.09 66.83,114.65 69.39,117.21 72.2,117.21 76.97,121.98 78.54,121.98 80.86,124.3 82.54,124.3 86.9,128.66 87.95,128.66 94.18,134.89 97.71,134.89 99.29,136.47 99.81,136.47 102.51,139.18 102.51,139.86 102.98,140.32
  BOTTOM w0.102: v1(61.52,113.75) 61.75,113.75 61.87,113.87 61.87,114.34 62.12,114.58 63.35,114.58 63.84,115.07 JDIM02.219 ; U1.BC31 103.88,140.56 v2(104.21,140.23)
M_B_DQSN7: length 63.6
  IN3 w0.079: v2(104.18,137.5) 104.18,137.2 104.08,137.1 103,137.1 102.84,136.94
  IN3 w0.089: v1(59.56,107.98) 59.36,107.98 59.14,107.76 59.14,107.5 59.22,107.42 66.89,107.42 72.6,113.12 73.73,113.12 77.63,117.02 79.59,117.02 81.54,118.97 85.4,118.97 97.65,131.21 97.65,131.35 100.07,133.77 100.38,133.77 100.99,134.38 100.99,135.09 102.84,136.94
  BOTTOM w0.102: U1.BH31 104.18,137.34 v2(104.18,137.5) ; v1(59.56,107.98) 59.1,107.98 58.97,108.11 58.97,108.79 58.37,109.39 57.92,109.39 57.49,109.82 JDIM02.240
M_B_DQSN8: length 4.8
  TOP w0.114: R25611.2 65.71,148.55 66.44,148.55 v1(66.48,148.51) 67.17,147.81 v1(67.26,147.81)
  BOTTOM w0.114: JDIM02.95 65.7,148.07 65.91,148.28 66.79,148.28 v1(67.26,147.81)
M_B_DQSP0: length 62
  IN3 w0.079: 107.17,163.93 107.54,163.56 107.54,162.71 107.63,162.62 107.74,162.62 v2(107.94,162.83)
  IN3 w0.089: 107.17,163.93 107,164.1 106.91,164.19 104.12,166.98 102.73,166.98 101.07,168.64 96.63,168.64 96.43,168.85 81.03,168.85 80.81,168.63 80.81,168.21 80.65,168.05 80.34,168.05 80.21,168.18 80.21,168.62 79.99,168.84 79.53,168.84 79.32,168.63 79.32,168.2 79.2,168.09 78.91,168.09 78.81,168.19 78.81,168.51 78.59,168.73 78.17,168.73 77.95,168.51 77.95,168.15 77.83,168.03 70.82,168.03 67.48,164.69 61.31,164.69 60.15,163.53 59.5,163.53 59.41,163.61 59.41,164.03 59.49,164.1 v1(59.97,164.1)
  BOTTOM w0.102: v2(107.94,162.83) 108.28,162.49 U1.G24 ; JDIM02.34 57.45,163.32 57.6,163.47 57.81,163.47 58.14,163.14 59.09,163.14 59.33,163.38 59.33,163.78 59.65,164.1 v1(59.97,164.1)
M_B_DQSP1: length 68.2
  IN3 w0.089: v1(58.62,169.82) 58.83,169.82 59.01,170.01 59.01,170.3 59.23,170.52 67.74,170.52 69.04,171.81 72.26,171.81 73.13,172.68 87.6,172.68 88.39,173.47 90.95,173.47 91.57,174.09 93.94,174.09 94.2,173.83 95.49,173.83 95.55,173.77 96.17,173.15 97.95,173.15 98.44,172.65 105.08,172.65 106.04,171.69 106.86,171.69 107.47,171.07 107.47,170.75 107.32,170.6 107.32,170.46 v2(107.45,170.33)
  BOTTOM w0.079: v2(107.45,170.33) 107.45,170.63 107.6,170.79 107.98,170.79 108.44,170.33 108.44,169.59 108.38,169.54 108.38,166.12 108.61,165.89 108.62,165.88 108.62,165.63 108.59,165.51 108.59,165.27 108.62,165.17 108.62,164.99 108.59,164.83 108.59,164.69 108.63,164.47 108.81,164.35 108.94,164.35 109.02,164.27 U1.D23
  BOTTOM w0.102: JDIM02.13 63.84,168.57 63.73,168.68 63.45,168.68 62.65,169.48 61.37,169.48 61.02,169.13 59.29,169.13 58.92,169.49 58.92,169.65 58.75,169.82 v1(58.62,169.82)
M_B_DQSP2: length 55.5
  IN3 w0.079: 101.25,163.13 101.27,163.13 101.51,162.88 101.81,162.59 102.4,162.59 102.5,162.49 104.37,162.49 104.49,162.36 104.49,162.18 104.41,162.1 v2(104.25,162.1)
  IN3 w0.089: 101.25,163.13 100.14,164.24 93.35,164.24 93.18,164.07 73.95,164.07 70.29,160.42 68.97,160.42 67.42,158.87 64.67,158.87 64.6,158.8 64.6,158.36 64.41,158.17 63.77,158.17 63.6,158.34 63.6,158.84 63.53,158.92 63.12,158.92 63.05,158.85 63.05,158.35 62.55,157.84 61.31,157.84 61.11,158.04 61.11,158.42 60.9,158.62 v1(60.47,158.62)
  BOTTOM w0.102: U1.H30 104.45,161.73 104.35,161.83 104.35,162 v2(104.25,162.1) ; JDIM02.55 63.9,158.07 63.74,158.24 63.27,158.24 62.84,157.81 61.18,157.81 60.71,158.28 60.71,158.38 v1(60.47,158.62)
M_B_DQSP3: length 55
  IN3 w0.079: 104.16,159.34 104.36,159.54 104.36,159.66 104.29,159.74 102.61,159.74 102.53,159.81 102.15,160.19 101.72,160.19 101.72,160.19 101.29,160.19 101.28,160.18
  IN3 w0.089: v1(58.59,152.43) 59.07,152.43 59.19,152.31 59.19,151.89 59.36,151.72 60.71,151.72 61.7,152.71 65.09,152.71 66,153.62 68.92,153.62 75.44,160.14 93.67,160.14 93.82,159.99 97.95,159.99 98.85,159.4 99.1,159.4 100.78,159.98 100.98,160.18 101.28,160.18 ; 104.16,159.34 v2(104.13,159.34)
  BOTTOM w0.102: v1(58.59,152.43) 59.1,152.43 59.2,152.53 59.2,152.64 58.83,153.02 57.83,153.02 57.63,152.82 JDIM02.76 ; v2(104.13,159.34) 104.53,158.94 U1.N30
M_B_DQSP4: length 61.3
  IN3 w0.079: v2(104.21,148.43) 103.97,148.2 103.97,148.05 103.82,147.9 103.29,147.9 103.25,147.86 102.03,147.86 101.74,147.57
  IN3 w0.089: 101.74,147.57 100.25,146.08 100.25,144.84 99.13,143.72 98.54,143.72 97.81,142.99 92.24,142.99 90.43,141.18 85.32,141.18 70.3,126.17 60.81,126.17 60.58,125.94 60.58,125.18 60.73,125.03 v1(61.29,125.03)
  BOTTOM w0.102: U1.AL30 104.53,148.11 v2(104.21,148.43) ; JDIM02.179 63.88,125.07 63.72,125.23 62.68,125.23 62.16,125.75 60.89,125.75 60.79,125.65 60.79,125.14 60.89,125.03 v1(61.29,125.03)
M_B_DQSP5: length 61.5
  IN3 w0.079: 102.55,144.01 102.81,144.26 103.79,144.26 104,144.46 104,144.67 104.11,144.79 v2(104.21,144.79)
  IN3 w0.089: 102.55,144.01 101,142.45 101,141.71 98.19,138.91 95.07,138.91 94.91,138.75 92.61,138.75 91.89,138.03 91.08,137.22 88.42,137.22 82.97,131.77 82.97,131.04 82.42,130.49 81.57,130.49 76.92,125.84 75.32,125.84 71.27,121.78 66.08,121.78 64.4,120.1 61.56,120.1 60.68,120.97 59.72,120.97 59.59,120.84 59.59,120.62 v1(60.01,120.2)
  BOTTOM w0.102: U1.AU30 104.53,144.46 v2(104.21,144.79) ; JDIM02.200 57.53,119.82 57.82,119.53 58.99,119.53 59.33,119.87 59.33,119.99 59.55,120.2 v1(60.01,120.2)
M_B_DQSP6: length 61.8
  IN3 w0.079: v2(104.21,141.14) 104.21,140.84 104.13,140.76 103.18,140.76 102.84,140.42
  IN3 w0.089: v1(62.79,113.75) 62.3,113.75 62.21,113.65 62.21,113.34 62.3,113.24 64.15,113.24 64.74,113.84 64.74,114.66 65.04,114.96 65.72,114.96 65.95,114.73 65.95,114.09 66.05,113.98 66.48,113.98 66.65,114.16 66.65,114.73 69.31,117.39 72.13,117.39 76.89,122.15 78.46,122.15 80.79,124.48 82.47,124.48 86.83,128.84 87.88,128.84 94.11,135.07 97.64,135.07 99.21,136.64 99.74,136.64 102.34,139.25 102.34,139.93 102.84,140.42
  BOTTOM w0.102: U1.BC30 104.53,140.82 v2(104.21,141.14) ; JDIM02.221 63.93,114.57 63.88,114.62 63.67,114.62 63.43,114.38 62.2,114.38 62.08,114.25 62.08,113.83 62.16,113.75 v1(62.79,113.75)
M_B_DQSP7: length 63.6
  IN3 w0.079: v2(104.18,136.58) 104.18,136.86 104.1,136.94 103.08,136.94 102.97,136.83
  IN3 w0.089: 102.97,136.83 101.15,135.02 101.15,134.31 100.44,133.59 100.14,133.59 97.82,131.27 97.82,131.14 85.48,118.79 81.61,118.79 79.67,116.85 77.7,116.85 73.8,112.95 72.67,112.95 66.97,107.24 59.15,107.24 58.96,107.42 58.96,107.79 58.77,107.98 v1(58.29,107.98)
  BOTTOM w0.102: v2(104.18,136.58) 104.53,136.94 U1.BH30 ; JDIM02.242 57.71,109.32 57.84,109.19 58.28,109.19 58.77,108.7 58.77,108.18 58.57,107.98 v1(58.29,107.98)
M_B_DQSP8: length 2
  TOP w0.114: R25607.2 v1(66.11,147.72)
  BOTTOM w0.114: JDIM02.97 65.97,147.57 v1(66.11,147.72)
M_B_PARITY: length 56.2
  IN3 w0.102: v2(98.84,150.78) 97.97,149.91 91.67,149.91 90.17,148.4 81.11,148.4 68.53,135.83 64.81,135.83 64.43,135.44 60.67,135.44 v1(60.53,135.3)
  BOTTOM w0.079: v2(98.84,150.78) 99.06,150.55 99.7,150.55 99.89,150.74 100.36,150.74 100.45,150.72 100.67,150.72 100.77,150.74 101.02,150.74 101.14,150.72 101.5,150.72 101.52,150.69 102.04,150.69 102.18,150.84 U1.AE34
  BOTTOM w0.14: v1(60.53,135.3) 63.45,135.3 63.72,135.04 65.46,135.04 65.81,135.39 65.81,135.91 65.66,136.07 JDIM02.143
M_B_RAS#: length 58.6
  IN3 w0.102: v2(97.44,149.48) 97.44,149.08 97.6,148.92 97.89,148.92 97.98,148.84 97.98,148.57 97.89,148.49 91.68,148.49 90.37,147.18 81.69,147.18 69.11,134.61 68.17,134.61 68.05,134.49 68.05,133.99 67.98,133.91 67.7,133.91 67.59,134.02 67.59,134.5 67.49,134.61 67.29,134.61 67.19,134.5 67.19,134.02 67.09,133.91 66.88,133.91 66.78,134.02 66.78,134.5 66.68,134.61 66.48,134.61 66.37,134.5 66.37,134.02 66.27,133.91 66.07,133.91 65.97,134.02 65.97,134.5 65.87,134.61 65.66,134.61 65.56,134.5 65.56,134.02 65.46,133.91 62.67,133.91 v1(62.6,133.84)
  BOTTOM w0.079: U1.AJ34 101.97,149.1 101.64,149.43 100.61,149.43 100.35,149.53 100.04,149.53 99.87,149.36 98.67,149.36 98.35,149.04 97.86,149.04 97.44,149.45 v2(97.44,149.48)
  BOTTOM w0.14: v1(62.6,133.84) 62.12,133.37 61.34,133.37 59.88,131.9 57.82,131.9 57.74,131.82 JDIM02.152
M_B_WE#: length 58.7
  IN3 w0.102: v2(92.85,147.73) 92.48,147.36 91.46,147.36 90.08,145.98 87.26,145.98 87.16,146.09 87.16,146.26 87.06,146.36 86.85,146.36 86.75,146.26 86.75,146.09 86.65,145.98 86.45,145.98 86.35,146.09 86.35,146.26 86.24,146.36 86.04,146.36 85.94,146.26 85.94,146.09 85.84,145.98 85.64,145.98 85.53,146.09 85.53,146.26 85.43,146.36 85.23,146.36 85.13,146.26 85.13,146.09 85.03,145.98 84.82,145.98 84.72,146.09 84.72,146.26 84.62,146.36 84.42,146.36 84.31,146.26 84.31,146.09 84.21,145.98 84.01,145.98 83.91,146.09 83.91,146.26 83.81,146.36 83.6,146.36 83.5,146.26 83.5,146.09 83.4,145.98 83.2,145.98 83.1,146.09 83.1,146.26 82.99,146.36 82.79,146.36 82.69,146.26 82.69,146.09 82.59,145.98 82.38,145.98 82.28,146.09 82.28,146.26 82.22,146.33 82.06,146.33 80.94,145.21 80.94,145.07 81.12,144.89 81.12,144.75 80.98,144.6 80.83,144.6 80.65,144.78 80.51,144.78 80.36,144.64 80.36,144.49 80.54,144.31 80.54,144.17 80.4,144.03 80.26,144.03 80.08,144.21 79.93,144.21 79.79,144.06 79.79,143.92 79.97,143.74 79.97,143.6 79.83,143.45 79.68,143.45 79.5,143.63 79.36,143.63 79.21,143.49 79.21,143.34 79.39,143.16 79.39,143.02 79.25,142.88 79.11,142.88 78.93,143.06 78.78,143.06 78.64,142.91 78.64,142.77 78.82,142.59 78.82,142.44 78.68,142.3 78.53,142.3 78.35,142.48 78.21,142.48 78.06,142.34 78.06,142.19 78.24,142.01 78.24,141.87 78.1,141.73 77.96,141.73 77.78,141.91 77.63,141.91 77.49,141.76 77.49,141.62 77.67,141.44 77.67,141.29 77.53,141.15 77.38,141.15 77.2,141.33 77.06,141.33 76.91,141.19 76.91,141.04 77.09,140.86 77.09,140.72 76.95,140.58 76.81,140.58 76.63,140.76 76.48,140.76 76.34,140.61 76.34,140.47 76.52,140.29 76.52,140.14 76.38,140 76.23,140 76.05,140.18 75.91,140.18 75.76,140.04 75.76,139.89 75.94,139.71 75.94,139.57 75.8,139.43 75.66,139.43 75.48,139.61 75.33,139.61 75.19,139.46 75.19,139.32 75.37,139.14 75.37,138.99 75.22,138.85 75.08,138.85 74.9,139.03 74.76,139.03 68.83,133.1 63.48,133.1 v1(62.85,132.47)
  BOTTOM w0.079: v2(92.85,147.73) 93.64,148.52 98.54,148.52 98.88,148.86 100.08,148.86 100.09,148.85 100.35,148.85 100.42,148.88 100.67,148.88 100.75,148.85 101.28,148.85 U1.AJ35
  BOTTOM w0.14: JDIM02.151 63.84,132.07 63.72,132.2 63.13,132.2 v1(62.85,132.47)
MAIND: length 219.6
  TOP w0.114: PR59.2 59.46,180.51 59.12,180.17 PC51.1 58.3,178.76 58.3,178.51 58.05,178.26 57.63,178.26 57.16,177.8 57.16,177.37 PQ6.3 56.27,176.48 v1(55.86,176.48) 55.16,177.18 55.16,177.83 54.84,178.15 53.79,178.15 v1(53.59,177.94) ; PR2060.1 130.31,125.56 v1(130.68,125.19) ; PQ9.2 35.72,126.98 35.42,126.68 v1(34.95,126.68)
  IN1 w0.089: v1(34.95,126.68) 36.44,126.68 37.34,125.78 38.76,125.78 43.08,121.46 v1(43.27,121.46)
  IN3 w0.102: v1(108.64,96.21) 108.55,96.31 108.55,99.79 110.77,102 113.83,102 117.06,105.23 121.13,105.23 126.55,110.65 126.94,110.65 128.53,112.24 128.53,112.57 128.59,112.62 128.59,112.85 128.73,112.99 128.73,115.15 129.87,116.28 129.87,118.71 131.02,119.87 131.02,122.74 130.68,123.09 v1(130.68,125.19)
  IN4 w0.089: v1(34.95,126.68) 35.45,127.18 35.45,134.41 34.1,135.75 34.1,142.63 35.04,143.57 35.04,145.14 35.83,145.93 35.83,156.59 37.98,158.73 37.98,168.32 38.6,168.95 38.6,172.48 43.76,177.64 53.28,177.64 v1(53.59,177.94) ; v1(108.64,96.21) 108.35,96.21 108.04,95.9 102.2,95.9 100.8,97.3 97.95,97.3 97.76,97.11 92.39,97.11 92.04,97.46 88.96,97.46 88.75,97.25 84.66,97.25 84.59,97.32 83.59,97.32 83.02,96.74 81.76,96.74 81.11,97.39 76.86,97.39 75.91,96.45 75.16,96.45 74.17,97.44 71.63,97.44 70.85,96.66 68.28,96.66 67.2,95.58 58.5,95.58 57.28,96.79 54.93,96.79 49.46,102.26 47.96,102.26 46.4,103.82 45.94,103.82 44.83,104.93 44.83,106.97 42.69,109.11 42.69,115.4 42.89,115.6 42.89,121.09 v1(43.27,121.46)
MAINON: length 572.3
  TOP w0.114: PQ16.2 54.38,176.94 55.35,175.97 59.27,175.97 PR120.1 ; v1(197.03,131.45) 197.55,130.93 PR6016.2 ; v1(149.79,95.98) 149.45,95.98 R890.1 149.25,95.5 149.36,95.4 150.07,95.4 150.3,95.63 150.3,96.59 150.05,96.83 150.05,97.67 150.32,97.94 U37.30 ; PR6028.2 v1(34.09,169.47)
  TOP w0.508: v1(62.09,181.93) v1(60.91,180.75) 60.91,177.61 PR120.1
  IN1 w0.089: v1(34.09,169.47) 34.05,169.43 34.05,167.17 33.55,166.66 28.91,166.66 v1(28.7,166.87) ; v1(14.57,117.73) 15.26,118.43 22.83,118.43 23.71,117.54 28.46,117.54 v1(29.18,118.26)
  IN3 w0.102: v1(43.32,162.07) 42.63,162.75 42.63,170.87 46.36,174.6 54.94,174.6 57.25,176.91 60.57,176.91 62.09,178.43 v1(62.09,181.93) 62.44,182.28 62.44,185.18 64.1,186.84 69.3,186.84 v1(69.63,186.51) ; v1(170.84,135.46) 170.99,135.46 172.24,134.21 172.24,133.45 173.89,131.8 173.89,128.95 175.67,127.17 178.48,127.17 179.46,126.19 187.08,126.19 190.44,129.55 195.12,129.55 v1(197.03,131.45) ; v1(170.13,120.13) 170.13,120.09 172.77,117.45 180.42,117.45 182.01,115.86 186.48,115.86 186.76,115.58 191.17,115.58 193.88,112.87 197.81,112.87 199.38,114.44 200.64,114.44 205.2,109.88 205.98,109.88 206.91,108.95 206.91,108.26 206.02,107.37 206.02,104.51 203.97,102.46 203.97,101 203.1,100.13 203.1,98.94 201.47,97.3 195.93,97.3 194.28,95.65 175.3,95.65 174.66,96.29 172.65,96.29 172.01,95.65 169.6,95.65 169.01,96.24 166.46,96.24 165.65,95.42 153.5,95.42 152.82,96.11 149.91,96.11 v1(149.79,95.98) 149.59,95.98 148.65,96.92 144.27,96.92 143.51,96.16 142.37,96.16 138.63,99.9 131.14,99.9 130.63,99.4 124.06,99.4 122.48,97.82 120.9,97.82 119.8,96.72 115.56,96.72 v1(114.95,96.11)
  IN4 w0.089: v1(114.95,96.11) 113.59,94.76 98.63,94.76 97.61,95.77 93.18,95.77 92.67,95.27 79.03,95.27 78.25,94.48 76.01,94.48 73.96,92.43 68.67,92.43 68.51,92.58 51.54,92.58 51.09,93.03 51.09,94.74 49.03,96.81 45.9,96.81 45.48,97.23 38.02,97.23 35.06,100.19 34.16,100.19 33.43,100.92 30.35,104 30.35,109.55 30.57,109.78 30.57,114.91 30.09,115.38 30.09,117.35 v1(29.18,118.26) 29.01,118.43 29.01,129.11 27.99,130.13 27.99,134.02 28.73,134.76 28.73,142.38 27.45,143.66 27.45,147.25 27.61,147.41 27.61,148.87 27.23,149.25 27.23,150.36 27.61,150.74 27.61,154.08 25.75,155.94 25.75,162.83 26.36,163.44 27.81,163.44 28.72,164.36 28.72,166.85 v1(28.7,166.87) ; v1(14.57,117.73) 15.36,117.73 16.94,116.15 16.94,113.82 17.59,113.17 17.59,109.25 16.17,107.83 16.17,92.51 16.09,92.43 16.09,87.02 16.25,86.86 16.25,80.23 13.85,77.83 13.31,77.83 10.17,74.69 10.17,72.08 9.25,71.16 9.25,70.73 8.72,70.2 8.72,69.51 8.97,69.25 8.97,64.6 10.19,63.39 10.19,60.15 14.61,55.72 14.61,47.93 10.77,44.08 6.15,44.08 4.09,42.03 v1(4.09,41.53) ; v1(170.13,120.13) 170.13,120.37 169.25,121.25 168.24,121.25 167.71,121.78 167.71,124.23 167.76,124.28 167.76,125.39 168.14,125.78 168.14,128.8 169.95,130.6 169.95,134.57 v1(170.84,135.46)
  BOTTOM w0.114: v1(170.84,135.46) 170.54,135.17 170.54,134.14 169.95,133.55 PR9268.1 ; v1(4.09,41.53) 3.86,41.3 3.86,40.28 4.04,40.1 PR6417.1 ; v1(62.09,181.93) 61.95,181.93 61.3,182.58 PR9270.1 ; v1(28.7,166.87) 30.72,164.85 30.72,162.79 31.13,162.38 31.72,162.38 33.09,161.01 42.26,161.01 v1(43.32,162.07) ; PR5000.1 70.57,186.99 70.11,186.99 v1(69.63,186.51)
MAINON_ON_G: length 278.4
  TOP w0.114: PQ9050.2 35.86,121.02 v1(35.86,120.37) 35.86,119.19 34.16,117.5 33.52,117.5 32.5,116.48 32.5,114.91 31.85,114.25 30,114.25 v1(29.69,114.56) ; v1(131.62,118.26) 133.08,116.79 PQ14.2 ; PQ16.3 52.81,178.27 v1(53.38,178.84) 53.8,178.42 57.16,178.42 PQ6.2 v1(57.76,180.86) PR116.2 56.75,181.86 PR118.1 ; PQ12.2 103.65,107.7 104.11,107.24 v1(104.11,106.7) ; v1(18.9,148.19) 18.9,147.45 PQ19.2
  IN3 w0.102: v1(131.62,118.26) 131.62,115.35 132.71,114.25 132.71,111.6 128.9,107.78 128.9,104.96 127.78,103.84 120.69,103.84 119.53,105 117.15,105 113.92,101.77 110.86,101.77 109.05,99.96 v1(109.05,99.37) 109.05,98.67 109.23,98.49 109.23,95.67 108.78,95.22 98.8,95.22 98.17,95.86 93.15,95.86 92.51,95.22 78.9,95.22 77.24,93.56 75.97,93.56 74.69,92.28 61.27,92.28 61.08,92.09 v1(61.08,91.75)
  IN4 w0.089: v1(29.69,114.56) 30,114.25 30,110.01 29.75,109.76 29.75,106.97 29.1,106.32 29.1,104.44 33.92,99.62 34.82,99.62 37.78,96.66 45.24,96.66 45.66,96.24 48.55,96.24 49.67,95.11 49.67,91.57 50.07,91.17 60.5,91.17 v1(61.08,91.75) ; v1(53.38,178.84) 53.38,178.4 52.81,177.83 43.68,177.83 38.41,172.56 38.41,169.03 37.79,168.4 37.79,158.81 34.12,155.14 v1(34.12,154.47) 34.12,153.97 35.64,152.45 35.64,146.01 34.85,145.22 34.85,143.65 33.91,142.71 33.91,135.67 35.26,134.33 35.26,130.62 34.39,129.75 34.39,125.69 34.73,125.34 34.73,121.5 v1(35.86,120.37) ; v1(104.11,106.7) 104.74,106.7 106.24,105.2 106.68,105.2 106.97,104.91 106.97,103.83 108.65,102.15 108.65,99.77 v1(109.05,99.37)
  BOTTOM w0.114: v1(18.9,148.19) 18.9,150.07 24.2,155.36 27.53,155.36 27.83,155.06 33.53,155.06 v1(34.12,154.47)
MBCLK: length 302.7
  TOP w0.114: U37.110 160.16,112.07 160.36,112.28 161.12,112.28 R361.1 162.05,112.95 162.21,113.1 162.21,113.76 162.61,114.17 164.06,114.17 165.33,115.45 v1(165.33,116.42) 165.33,116.97 166.91,118.56 166.91,118.92 170.45,122.46 171.04,122.46 172.54,123.96 v1(172.54,124.3) ; v1(211.16,122.29) v1(211.16,121.43) 211.16,121.17 210.96,120.98 210.96,115.03 208.31,112.39 208.31,109.29 205.82,106.79 205.82,105.39 203.66,103.24 203.66,97.7 v1(204.05,97.31)
  IN1 w0.089: v1(106.57,104.75) 107.24,105.41 111.35,105.41 112.06,104.7 118.11,104.7 119.51,103.29 122.27,103.29 123.07,102.5 131.18,102.5 131.71,101.96 135.34,101.96 136.41,100.89 138.95,100.89 139.52,100.32 145.45,100.32 145.8,99.97 151.04,99.97 152.55,101.48 154.38,101.48 155.7,100.17 160.45,100.17 161.85,98.76 166.02,98.76 166.52,98.26 169.59,98.26 169.99,98.67 180.83,98.67 181.58,97.92 182.93,97.92 183.95,96.9 193.01,96.9 194.11,98 203.36,98 v1(204.05,97.31)
  IN3 w0.102: v1(134.76,174.72) 134.76,175.45 135.58,176.26 138.43,176.26 140,174.69 140,172.08 141.88,170.2 149.87,170.2 150.91,171.25 154.28,171.25 155.02,170.5 157.75,170.5 159.41,168.84 164.12,168.84 166.38,166.58 166.38,160.88 168.41,158.85 168.41,157 169.3,156.1 169.3,153.03 171.63,150.7 172.06,150.7 172.52,150.24 172.52,148.1 170.04,145.63 170.04,143.65 170.18,143.51 170.18,142.54 170.04,142.4 170.04,140.58 169.7,140.24 169.7,139.71 170.61,138.8 170.61,136.77 169.74,135.9 169.74,125.83 170.57,125.01 170.99,125.01 171.26,124.74 172.1,124.74 v1(172.54,124.3)
  IN4 w0.089: v1(165.33,116.42) 165.87,116.42 166.57,117.12 168.53,117.12 169.04,117.63 169.36,117.63 169.84,118.12 172.08,118.12 173.36,119.4 175.99,119.4 178.34,121.75 179.9,121.75 182.39,124.24 187.13,124.24 188.18,123.19 189.65,123.19 189.91,123.46 192.78,123.46 193.49,124.17 198.46,124.17 198.87,124.59 202.7,124.59 204.01,125.9 206.52,125.9 208.04,124.38 208.39,124.38 210.48,122.29 v1(211.16,122.29)
  BOTTOM w0.114: v1(134.76,174.72) 134.76,174.96 135.08,175.27 Q13.3 ; v1(165.33,116.42) 165.33,116.42 164.5,116.42 163.9,117.02 PR17.1 ; PD4.1 112.05,106.9 109.21,106.9 PC11.1 PR12.2 107.36,106.33 106.57,105.54 v1(106.57,104.75)
MBCLK_THM: length 159.4
  IN1 w0.089: v1(91.62,182.42) 91.74,182.42 93.49,180.67 99.28,180.67 100.48,179.47 104.68,179.47 105.16,178.99 109.3,178.99 109.73,178.56 110.86,178.56 111.65,177.77 116.1,177.77 116.47,178.14 120.01,178.14 125.73,172.42 125.73,171.04 126.73,170.05 126.73,166.29 127.37,165.65 127.37,165.06 130.01,162.43 130.63,162.43 132.53,160.53 132.53,158.49 132.06,158.02 132.06,156.66 132.41,156.31 132.41,155.32 134.08,153.65 135.05,153.65 140.42,148.28 140.42,134.38 141.89,132.91 142.44,132.91 142.6,132.75 146.67,132.75 147.33,132.09 149.34,132.09 149.98,132.73 153.25,132.73 153.51,132.99 158.6,132.99 160.45,131.14 161.58,131.14 163.04,129.68 166.96,129.68 168.14,128.5 168.14,123.92 169.46,122.6 172.51,122.6 173.12,123.21 175.18,123.21 175.42,123.45 179.52,123.45 180.22,122.75 185.24,122.75 185.4,122.59 190.25,122.59 190.79,123.12 190.79,123.6 192.02,124.83 v1(192.02,125.28)
  BOTTOM w0.114: v1(91.62,182.42) 92.24,183.04 Q6564.4 92.24,183.92 92.44,184.12 R67858.2 91.84,184.45 v1(91.7,184.3) 91.27,184.3 90.9,184.66 89.09,184.66 88.26,185.49 88.26,186.83 88.02,187.08 88.02,187.24 87.75,187.51 U2.8 ; v1(192.02,125.28) 192.72,125.99 193.79,125.99 193.94,125.84 U6517.8
MBDATA: length 302.1
  TOP w0.114: v1(211.11,122.95) 210.69,122.53 210.69,115.15 208.05,112.5 208.05,109.95 v1(207.81,109.71) 207.81,109.16 205.55,106.9 205.55,105.5 203.39,103.35 v1(203.39,97.13) ; U37.111 159.76,112.05 160.25,112.55 160.74,112.55 161.03,112.84 R369.1 160.76,112.95 160.61,113.1 160.61,113.87 161.12,114.38 162.45,114.38 162.5,114.44 163.94,114.44 164.82,115.31 164.82,116.84 v1(164.86,116.88) 166.65,118.67 166.65,119.03 170.44,122.82 171.02,122.82 171.88,123.68 v1(171.88,124.31)
  IN1 w0.089: v1(203.39,97.13) 202.72,97.81 194.19,97.81 193.09,96.71 183.87,96.71 182.85,97.73 181.5,97.73 180.75,98.48 170.07,98.48 169.67,98.07 166.44,98.07 165.94,98.57 161.78,98.57 160.37,99.97 155.62,99.97 154.3,101.29 152.63,101.29 151.12,99.78 145.72,99.78 145.37,100.13 139.44,100.13 138.87,100.7 136.33,100.7 135.26,101.77 131.63,101.77 131.1,102.31 122.99,102.31 122.19,103.1 119.44,103.1 118.03,104.51 111.98,104.51 111.27,105.22 109.49,105.22 v1(109.03,104.76)
  IN3 w0.102: v1(133.02,177.15) 133.02,175.67 134.44,174.25 134.92,174.25 135.24,174.56 135.24,175.6 135.67,176.04 138.34,176.04 139.77,174.6 139.77,171.99 141.79,169.97 149.96,169.97 151.01,171.02 154.18,171.02 154.93,170.27 157.65,170.27 159.32,168.61 164.02,168.61 166.15,166.48 166.15,160.79 168.18,158.76 168.18,156.9 169.07,156.01 169.07,152.94 171.53,150.48 171.96,150.48 172.29,150.15 172.29,148.2 169.81,145.73 169.81,143.56 169.95,143.42 169.95,142.63 169.81,142.5 169.81,140.68 169.47,140.33 169.47,139.62 170.38,138.71 170.38,136.86 169.51,136 169.51,125.74 170.47,124.78 170.9,124.78 171.37,124.31 v1(171.88,124.31)
  IN4 w0.089: v1(164.86,116.88) 165.99,116.88 166.42,117.31 168.45,117.31 168.96,117.82 169.28,117.82 169.76,118.31 172,118.31 173.28,119.59 175.91,119.59 178.26,121.94 179.82,121.94 182.31,124.43 187.21,124.43 188.26,123.38 189.57,123.38 189.83,123.65 192.7,123.65 193.41,124.36 198.38,124.36 198.79,124.78 202.62,124.78 203.93,126.09 206.6,126.09 208.12,124.57 208.47,124.57 210.09,122.95 v1(211.11,122.95)
  BOTTOM w0.114: v1(164.86,116.88) 164.43,116.88 164.07,117.24 163.51,117.24 PR19.1 ; Q13.6 133.02,176.82 v1(133.02,177.15) ; v1(109.03,104.76) 109.18,104.92 109.18,105.86 PR13.2 PC10.1 110.97,106.63 111.64,106.63 112.24,106.03 PD3.1
MBDATA_THM: length 161
  IN1 w0.089: v1(193.5,125.49) 192.95,125.49 190.98,123.52 190.98,123.04 190.33,122.39 185.32,122.39 185.16,122.56 180.14,122.56 179.44,123.25 175.5,123.25 175.19,122.95 174.1,122.95 173.57,122.41 169.38,122.41 167.95,123.84 167.95,128.42 166.88,129.49 162.97,129.49 161.5,130.95 160.38,130.95 158.53,132.8 153.59,132.8 153.33,132.54 150.06,132.54 149.42,131.9 147.25,131.9 146.59,132.55 142.52,132.55 142.36,132.72 141.81,132.72 140.23,134.3 140.23,148.2 134.97,153.46 134,153.46 132.22,155.24 132.22,156.24 131.87,156.58 131.87,158.1 132.34,158.57 132.34,160.45 130.55,162.24 129.93,162.24 127.18,164.98 127.18,165.57 126.54,166.22 126.54,169.97 125.54,170.96 125.54,172.34 119.93,177.95 116.55,177.95 116.18,177.58 111.57,177.58 110.78,178.37 109.65,178.37 109.23,178.79 105.09,178.79 104.6,179.28 100.4,179.28 99.2,180.48 94.48,180.48 v1(94,180)
  BOTTOM w0.114: Q6564.1 93.54,181.26 93.73,181.07 94.08,181.07 94.22,180.93 R67857.2 94.22,180.22 v1(94,180) 93.78,179.78 v1(93.4,179.78) 93.25,179.93 92.74,179.93 92.48,180.19 92.48,180.76 92.22,181.02 91.57,181.02 91.11,181.48 91.11,184.08 90.79,184.4 88.98,184.4 88,185.38 88,186.6 87.74,186.86 U2.7 ; v1(193.5,125.49) 193.8,125.19 U6517.7
MCT1: length 3.5
  TOP w0.114: v1(38.03,187.65) 38.03,186.99 v1(38,186.97)
  TOP w0.508: R516.2 38,186.17 v1(38,186.97)
  BOTTOM w0.508: U25.24 v1(38,186.97)
