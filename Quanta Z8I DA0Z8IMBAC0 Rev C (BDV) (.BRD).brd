# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IDCHG_R: length 137.7
  TOP w0.114: v1(171.22,97.58) 170.75,98.05 169.72,98.05 169.25,98.52 PC20.2 169.09,98.85 168.8,99.14 U37.70
  IN1 w0.089: v1(165.97,121.37) 166.36,121.37 166.74,121.75 168.05,121.75 168.28,121.52 173.95,121.52 174.44,122.01 180.25,122.01 180.82,121.44 188.22,121.44 188.98,122.2 191.67,122.2 194.37,124.91 v1(196.12,124.91)
  IN2 w0.102: v1(171.22,97.58) 171.91,96.89 176.81,96.89 177.32,97.4 181.02,97.4 181.76,98.14 183.09,98.14 183.99,97.25 192.5,97.25 193.29,98.03 202.69,98.03 205.05,100.39 210.26,100.39 213.21,103.35 213.21,105.44 215.95,108.18 218,108.18 221.67,111.84 221.67,117.11 v1(221.05,117.74)
  IN3 w0.102: v1(196.12,124.91) 196.33,124.7 200.16,124.7 201.64,126.18 206.44,126.18 207.26,125.37 210.74,125.37 211.65,126.28 212.96,126.28 216.02,123.22 216.55,123.22 217.13,122.64 217.13,120.32 218.5,118.96 219.82,118.96 v1(221.05,117.74)
  BOTTOM w0.114: v1(165.97,121.37) 165.67,121.67 165.24,121.67 v1(164.85,121.28) 164.7,121.13 164.24,121.13 163.71,120.6 PR26.1
IDEA_G_3VLDO: length 3
  TOP w0.114: PQ8014.2 21.55,115.69 PR8044.1 22.48,115.84 23.13,115.84 23.28,115.69 PQ8016.3
IDEA_G_5VS5_PD_C1: length 2.9
  TOP w0.114: PQ8017.2 27.89,109.1 27.35,109.1 PR8059.1 26.74,109.07 PQ8018.3
ILIM_HI: length 6.1
  TOP w0.114: U14.16 21.36,97.72 22.07,98.44 23.77,98.44 v1(24.72,99.39) 25.11,99.78 R414.2
ILIM_LO: length 4
  TOP w0.114: U14.15 21.23,97.22 21.96,97.95 R415.2 24.05,97.95 v1(24.16,97.84)
IMON_CORE: length 3.6
  BOTTOM w0.203: PU7000.1 166.3,139.34 166.47,139.16 166.47,138.44 166.48,138.43 166.48,137.67 166.98,137.17 166.98,136.83 PR7014.2
IMON_GT: length 3.2
  BOTTOM w0.203: PU7000.30 163.9,147.37 164.13,147.6 PC423.1 164.13,148.54 PR7004.2
IMON_SA: length 5
  BOTTOM w0.203: PU7000.39 167.94,144.21 168.1,144.36 168.31,144.36 169.05,145.1 169.9,145.1 v1(170.01,145.21) 170.06,145.26 PC7003.2 170.06,146.69 PR7005.1
IMVP_PWRGD: length 196
  TOP w0.114: Q85.2 109.13,109.39 v1(110.32,110.58) ; v1(204.99,102.73) 205.01,102.75 v1(205.01,103.45)
  IN1 w0.089: v1(110.32,110.58) 110.63,110.26 111.15,110.26 111.59,110.7 117.98,110.7 120.94,107.74 127.57,107.74 130.38,104.93 133.6,104.93 134.2,104.33 137.75,104.33 138.57,103.51 144.22,103.51 145.08,102.64 147.19,102.64 147.3,102.76 150.72,102.76 151,103.03 151.31,103.03 151.73,103.45 163.58,103.45 164.34,104.21 165.56,104.21 166.28,103.49 169.01,103.49 169.84,102.65 169.84,101.96 170.43,101.37 181.84,101.37 182.19,101.03 183.25,101.03 183.87,100.41 192.01,100.41 192.96,101.36 195.6,101.36 196.41,102.17 198.39,102.17 198.87,101.69 204.59,101.69 204.99,102.09 v1(204.99,102.73)
  IN3 w0.102: v1(170.79,120.05) 172.98,117.85 180.59,117.85 181.52,116.92 185.98,116.92 186.92,115.98 191.34,115.98 193.11,114.22 195.63,114.22 196.26,114.85 200.81,114.85 204.17,111.49 206.57,111.49 207.78,110.29 207.78,104.56 207.05,103.84 206.11,103.84 205.03,102.76 205.01,102.76 v1(204.99,102.73)
  IN4 w0.089: v1(170.95,148.87) 170.2,148.12 170.2,144.39 169.87,144.06 169.87,140.8 169.52,140.44 169.52,139.37 170.68,138.21 170.68,136.73 171.3,136.11 171.3,135.29 170.34,134.33 170.34,130.43 168.54,128.63 168.54,125.61 168.15,125.23 168.15,124.12 168.1,124.07 168.1,122 168.46,121.65 169.42,121.65 170.79,120.28 v1(170.79,120.05)
  BOTTOM w0.114: PR7067.1 170.2,148.85 PR7068.2 170.38,148.85 170.39,148.87 v1(170.95,148.87) ; R25359.2 115.04,110.35 113.16,110.35 112.95,110.13 U6504.2 110.77,110.13 v1(110.32,110.58)
IN_AUX: length 170.2
  TOP w0.102: C882.1 31.54,126.06 31.54,125.83 31.68,125.69 32.51,125.69 35.58,122.62 36.93,122.62 37.98,123.66 38.58,123.66 38.7,123.79 v1(38.7,123.98)
  IN3 w0.102: v1(38.7,123.98) 38.7,123.79 38.84,123.65 39.09,123.65 39.29,123.85 39.29,124.9 42.57,128.18 42.57,155.9 43.14,156.48 43.44,156.48 43.88,156.92 43.88,170.76 45.66,172.53 46.39,172.53 47.96,174.1 55.22,174.1 56.35,175.23 58.12,175.23 59.23,176.34 60.68,176.34 62.95,178.61 62.95,183.73 63.49,184.27 66.95,184.27 68.41,185.72 70.79,185.72 72.29,187.22 74.27,187.22 74.88,187.83 78.5,187.83 79.39,186.94 82.12,186.94 82.35,186.71 86.09,186.71 87.78,185.02 89.46,185.02 89.84,184.64 90.45,184.64 93.51,181.58 99.8,181.58 99.96,181.43 102.63,181.43 105.22,178.84 106.31,178.84 111.54,173.6 113.44,173.6 114.62,172.43 114.62,168.69 115.07,168.25 115.07,154.8 116.21,153.66 117.51,153.66 117.63,153.77 118.81,153.77 119.3,153.28 v2(119.3,153.12)
  BOTTOM w0.079: U1.AC6 119.52,152.9 v2(119.3,153.12)
IN_AUX#: length 170.2
  TOP w0.102: C883.1 31.98,125.48 32.42,125.48 35.49,122.41 37.01,122.41 38.06,123.46 38.45,123.46 v1(38.7,123.21)
  IN3 w0.102: v2(119.29,152.23) 118.88,152.64 118.88,153.44 118.73,153.58 117.71,153.58 117.59,153.47 116.13,153.47 114.88,154.72 114.88,168.17 114.43,168.62 114.43,172.35 113.36,173.41 111.47,173.41 106.23,178.65 105.15,178.65 102.56,181.24 99.88,181.24 99.72,181.39 93.43,181.39 90.37,184.45 89.76,184.45 89.38,184.83 87.7,184.83 87.65,184.89 86.01,186.52 82.27,186.52 82.04,186.75 79.31,186.75 78.42,187.64 74.96,187.64 74.35,187.03 72.37,187.03 70.87,185.53 68.48,185.53 67.03,184.08 63.57,184.08 63.14,183.65 63.14,178.53 60.76,176.15 59.31,176.15 58.2,175.04 56.43,175.04 55.3,173.91 48.04,173.91 46.47,172.34 45.73,172.34 44.07,170.68 44.07,156.84 43.52,156.29 43.22,156.29 42.76,155.83 42.76,128.1 39.48,124.82 39.48,123.77 39.16,123.46 38.94,123.46 v1(38.7,123.21)
  BOTTOM w0.079: U1.AC7 118.87,152.52 119.17,152.23 v2(119.29,152.23)
IN_AUXN: length 3.3
  TOP w0.102: U30.51 28.73,126.61 28.82,126.7 29.18,126.7 30.26,125.61 30.49,125.61 C883.2
IN_AUXP: length 3.3
  TOP w0.102: U30.52 28.72,127.01 28.83,126.9 29.26,126.9 30.35,125.82 30.52,125.82 C882.2
IN_D0N: length 4.8
  TOP w0.102: C811.2 28.71,131.63 28.71,131.4 28.59,131.27 27.29,131.27 26.34,130.31 26.34,130.01 26.22,129.9 U30.4
IN_D0P: length 4.8
  TOP w0.102: U30.3 26.62,129.9 26.54,129.98 26.54,130.23 27.38,131.07 28.67,131.07 28.92,131.31 28.92,131.62 C809.2
IN_D1N: length 3.8
  TOP w0.102: C813.2 26.31,131.62 26.31,131.41 25.99,131.1 25.55,131.1 25.12,130.66 25.12,129.99 25.02,129.9 U30.7
IN_D1P: length 3.8
  TOP w0.102: C812.2 26.51,131.62 26.51,131.33 26.08,130.89 25.64,130.89 25.32,130.58 25.32,130 25.42,129.9 U30.6
IN_D2N: length 3
  TOP w0.102: C815.2 23.92,131.6 23.92,129.99 23.82,129.89 U30.10
IN_D2P: length 3
  TOP w0.102: C814.2 24.12,131.65 24.12,130 24.22,129.9 U30.9
IN_D3N: length 3.8
  TOP w0.102: C817.2 21.02,132.22 21.48,131.77 21.48,131.58 21.76,131.31 22,131.31 22.72,130.59 22.72,129.98 22.62,129.88 U30.13
IN_D3P: length 3.8
  TOP w0.102: C816.2 22.1,132.22 21.68,131.8 21.68,131.67 21.84,131.51 22.09,131.51 22.92,130.67 22.92,130 23.02,129.9 U30.12
IN_DDC_SCL: length 5.1
  TOP w0.114: U30.50 28.87,126.21 29.77,125.31 29.77,124.66 30.66,123.77 31.23,123.77 R67596.2
IN_DDC_SDA: length 5
  TOP w0.114: U30.49 28.9,125.81 29.51,125.2 29.51,124.55 30.55,123.5 31.21,123.5 R67595.2
IN_HPD: length 10.2
  TOP w0.114: R67398.2 33.2,132.31 33.19,132.32 R830.1 32.06,131.75 30.97,131.75 R832.2 30.3,132.02 30.3,131.54 29.6,130.84 v1(29.47,130.84) ; U30.5 v1(25.82,130.36)
  IN3 w0.102: v1(29.47,130.84) 26.3,130.84 v1(25.82,130.36)
INT6_SENSOR_HUB: length 3.9
  TOP w0.079: U6516.D4 155.37,214.9 155.76,214.9 155.91,215.04 156.24,215.04
  TOP w0.114: 156.24,215.04 156.54,215.04 156.92,215.43 156.92,215.8 156.8,215.92 v1(156.8,216.28) 157.55,216.28 R25648.1
INT_AMIC-VREFO: length 6.8
  TOP w0.114: C564.1 15.49,27.36 R447.2 16.28,27.85 14.92,29.22 v1(14.92,30.7)
  BOTTOM w0.102: v1(14.92,30.7) 15.23,31.01 U20.27
INT_BTN_L: length 4.8
  TOP w0.114: 204.64,98.02 204.76,97.89 205.57,97.89 R67861.1 ; 204.64,98.02 v1(204.63,98.02) ; 204.64,98.02 204.64,98.23 204.9,98.49 v1(205.11,98.49)
  BOTTOM w0.114: CN52.10 205.85,100.35 205.11,99.61 v1(205.11,98.49)
INT_EDP_AUXN: length 109.9
  IN1 w0.102: v1(67.08,189.6) 67.28,189.41 67.28,189.23 67.28,188.57 67.79,188.06 67.79,182.9 67.27,182.38 67.27,180.63 68.31,179.58 69.91,179.58 70.28,179.21 70.28,177.11 71.06,176.33 72.59,176.33 75.31,173.61 94.9,173.61 95.72,172.78 98.51,172.78 101.91,176.18 104.55,176.18 104.77,176.41 109.96,176.41 110.88,175.49 115.69,175.49 117.4,173.78 118.62,173.78 123.79,168.6 124.85,168.6 125.53,167.92 125.53,163.78 126.29,163.01 126.29,162.24 126.9,161.63 126.9,159.94 127.32,159.52 127.32,155.78 129.16,153.94 129.16,149.43 127.16,147.43 126.54,147.43 125.66,146.55 124.94,146.55 124.84,146.65 124.84,146.81 v2(125.05,147.02)
  BOTTOM w0.079: U1.AH4 121.43,149.52 121.72,149.8 122.14,149.8 122.31,149.63 122.82,149.63 123.31,149.14 123.31,148.44 124.16,147.59 124.65,147.59 124.82,147.42 124.82,147.25 v2(125.05,147.02)
  BOTTOM w0.102: v1(67.08,189.6) 67.26,189.79 67.26,189.98 C556.2
INT_EDP_AUXN_C: length 3.4
  TOP w0.102: R25271.1 66.81,191.14 66.95,191.29 66.95,191.66 v1(66.69,191.92)
  BOTTOM w0.102: C556.1 67.05,191.36 67.05,191.56 v1(66.69,191.92) 66.79,191.92 66.9,192.03 66.9,192.28 66.65,192.53 CN29.22
INT_EDP_AUXP: length 109.9
  IN1 w0.102: v1(67.75,189.61) 67.59,189.61 67.48,189.49 67.48,189.23 67.48,188.65 67.99,188.14 67.99,182.82 67.47,182.3 67.47,180.71 68.4,179.79 69.99,179.79 70.49,179.29 70.49,177.2 71.14,176.54 72.67,176.54 75.4,173.81 94.98,173.81 95.81,172.99 98.42,172.99 101.82,176.39 104.46,176.39 104.68,176.61 110.05,176.61 110.97,175.69 115.78,175.69 117.49,173.98 118.7,173.98 123.88,168.8 124.93,168.8 125.73,168.01 125.73,163.86 126.5,163.09 126.5,162.32 127.1,161.71 127.1,160.03 127.52,159.61 127.52,155.86 129.36,154.03 129.36,149.34 127.25,147.22 126.62,147.22 125.74,146.34 124.86,146.34 124.64,146.57 124.64,146.89 124.52,147 v2(124.43,147)
  BOTTOM w0.079: v2(124.43,147) 124.66,147.24 124.66,147.36 124.58,147.43 124.1,147.43 123.16,148.38 123.16,149.07 122.75,149.47 122.25,149.47 122.2,149.52 U1.AH3
  BOTTOM w0.102: C557.2 67.54,190.39 67.47,190.31 67.47,189.85 67.71,189.61 v1(67.75,189.61)
INT_EDP_AUXP_C: length 3.5
  TOP w0.102: v1(67.35,191.92) 67.16,191.73 67.16,191.26 67.27,191.14 R25270.1
  BOTTOM w0.102: CN29.23 67.15,192.12 v1(67.35,191.92) 67.3,191.87 67.3,191.46 67.6,191.17 C557.1
INT_EDP_TXN0: length 106.6
  IN1 w0.102: v2(126.22,148.65) 126.03,148.47 126.03,148.24 126.1,148.18 126.76,148.18 128.29,149.71 128.29,152.24 127.71,152.82 127.71,153.33 126.19,154.85 126.19,161.25 125.26,162.19 125.26,162.82 124.68,163.39 124.68,165.26 119.33,170.61 119.33,172.19 118.41,173.11 117.2,173.11 115.47,174.84 110.6,174.84 109.65,175.8 105.07,175.8 104.82,175.54 102.16,175.54 98.76,172.15 95.35,172.15 94.55,172.95 73.39,172.95 66.49,179.85 66.49,182.62 66.74,182.87 66.74,186.09 65.29,187.53 65.29,189.38 v1(65.08,189.59)
  BOTTOM w0.079: U1.AG4 121.28,150.37 121.76,150.36 121.99,150.47 122.05,150.49 122.12,150.51 122.33,150.51 122.44,150.45 122.62,150.45 122.73,150.49 123.16,150.49 123.96,149.69 125.59,149.69 125.95,149.33 125.95,148.92 v2(126.22,148.65)
  BOTTOM w0.102: v1(65.08,189.59) 65.23,189.75 65.23,189.98 C553.2
INT_EDP_TXN0_C: length 2
  BOTTOM w0.102: CN29.19 65.15,192.46 65.27,192.34 65.27,191.61 C553.1
INT_EDP_TXN1: length 103.6
  IN1 w0.102: v2(124.33,148.63) 124.48,148.78 124.48,149.27 124.99,149.78 125.5,149.78 125.62,149.66 126.82,149.66 127.59,150.42 127.59,152.07 127.1,152.56 127.1,153.07 125.53,154.64 125.53,160.48 124.62,161.38 124.62,162.18 123.85,162.96 123.85,165.15 117.78,171.21 117.78,172.21 117.49,172.5 116.87,172.5 115.18,174.19 110.3,174.19 109.34,175.16 105.47,175.16 102.62,172.31 99.92,172.31 99.15,171.54 95.1,171.54 94.29,172.34 73.12,172.34 65.56,179.9 65.56,180.98 63.89,182.65 63.89,188.01 63.29,188.62 63.29,189.33 v1(63.09,189.52)
  BOTTOM w0.079: U1.AG2 122.48,149.82 122.94,149.82 123.76,149 124.44,149 124.52,148.93 124.52,148.81 v2(124.33,148.63)
  BOTTOM w0.102: C555.2 63.23,189.94 63.23,189.67 v1(63.09,189.52)
INT_EDP_TXN1_C: length 2.3
  BOTTOM w0.102: CN29.16 63.65,192.4 63.27,192.02 63.27,191.31 63.13,191.17 C555.1
INT_EDP_TXP0: length 106.6
  IN1 w0.102: v1(65.75,189.6) 65.6,189.6 65.5,189.49 65.5,187.62 66.94,186.17 66.94,182.79 66.69,182.54 66.69,179.94 73.48,173.15 94.63,173.15 95.43,172.35 98.68,172.35 102.07,175.75 104.73,175.75 104.99,176 109.73,176 110.69,175.05 115.56,175.05 117.29,173.32 118.49,173.32 119.53,172.27 119.53,170.69 124.88,165.34 124.88,163.48 125.46,162.9 125.46,162.27 126.39,161.34 126.39,154.93 127.91,153.41 127.91,152.9 128.49,152.33 128.49,149.62 126.84,147.98 126.01,147.98 125.83,148.16 125.83,148.42 v2(125.61,148.65)
  BOTTOM w0.079: v2(125.61,148.65) 125.79,148.83 125.79,149.26 125.52,149.53 123.9,149.53 123.09,150.34 122.76,150.34 122.65,150.29 122.4,150.29 122.31,150.34 122.15,150.34 122.04,150.32 U1.AG3
  BOTTOM w0.102: C552.2 65.56,190.39 65.43,190.26 65.43,189.91 v1(65.75,189.6)
INT_EDP_TXP0_C: length 2
  BOTTOM w0.102: C552.1 65.47,191.54 65.47,192.31 65.65,192.49 CN29.20
INT_EDP_TXP1: length 103.6
  IN1 w0.102: v2(124.94,148.63) 124.84,148.63 124.68,148.78 124.68,149.19 125.07,149.58 125.41,149.58 125.54,149.45 126.9,149.45 127.79,150.34 127.79,152.16 127.3,152.64 127.3,153.16 125.73,154.73 125.73,160.56 124.83,161.47 124.83,162.26 124.05,163.04 124.05,165.23 117.99,171.3 117.99,172.29 117.57,172.71 116.96,172.71 115.27,174.4 110.39,174.4 109.42,175.37 105.39,175.37 102.53,172.52 99.84,172.52 99.06,171.74 95.18,171.74 94.38,172.54 73.2,172.54 65.76,179.98 65.76,181.07 64.1,182.73 64.1,188.1 63.49,188.71 63.49,189.24 v1(63.76,189.51)
  BOTTOM w0.079: U1.AG1 122.96,149.99 122.99,149.99 123.82,149.16 124.5,149.16 124.67,148.99 124.67,148.72 124.77,148.63 v2(124.94,148.63)
  BOTTOM w0.102: v1(63.76,189.51) 63.45,189.82 63.45,190.31 63.53,190.39 C554.2
INT_EDP_TXP1_C: length 2.3
  BOTTOM w0.102: CN29.17 64.15,192.41 64.04,192.3 63.84,192.3 63.48,191.94 63.48,191.5 C554.1
INT_HDMICLK+_OUT: length 23.9
  TOP w0.089: R67396.1 17.72,129.18 v1(17.7,129.2) ; v1(18.45,142.75) 18.45,142.89 18.55,142.99 20.1,142.99 20.21,142.88 U23.10
  IN1 w0.089: v1(17.7,129.2) 17.84,129.06 17.84,128.66 17.76,128.57 17.56,128.57 17.35,128.77 16.17,128.77 15.98,128.96 15.98,132.62 16.89,133.53 18.53,133.53 18.85,133.85 18.85,134.41 18.52,134.75 18.23,134.75 18.08,134.9 18.08,135.13 18.6,135.66 18.6,141.75 17.72,142.64 17.72,142.93 17.89,143.1 18.38,143.1 18.45,143.03 v1(18.45,142.75)
INT_HDMICLK-_OUT: length 23.9
  TOP w0.089: U23.9 20.26,143.38 20.14,143.26 18.7,143.26 v1(18.45,143.51) ; R67397.1 17.71,128.03 v1(17.7,128.03)
  IN1 w0.089: v1(18.45,143.51) 18.36,143.42 17.75,143.42 17.4,143.07 17.4,142.5 18.29,141.62 18.29,135.79 17.76,135.26 17.76,134.77 18.1,134.43 18.38,134.43 18.54,134.28 18.54,133.98 18.4,133.84 16.76,133.84 15.66,132.75 15.66,128.83 16.04,128.46 17.22,128.46 17.65,128.03 v1(17.7,128.03)
INT_HDMITX0N_OUT: length 23.1
  TOP w0.089: v1(19.75,140.51) 19.95,140.31 20.11,140.31 20.18,140.38 U23.15 ; R67391.1 17.74,126.18 v1(17.68,126.12)
  IN1 w0.089: v1(19.75,140.51) 19.87,140.39 20.38,140.39 20.7,140.07 20.7,138.48 19.6,137.39 19.6,132.73 19.22,132.35 16.88,132.35 16.75,132.22 16.75,131.9 16.88,131.77 18.25,131.77 18.58,131.44 18.58,130.86 18.27,130.55 17.73,130.55 17.61,130.43 17.61,130.17 17.7,130.08 18.19,130.08 18.58,129.69 18.58,126.87 18.03,126.33 17.89,126.33 v1(17.68,126.12)
INT_HDMITX0P_OUT: length 23
  TOP w0.089: U23.16 20.25,139.88 20.09,140.04 19.88,140.04 19.75,139.91 v1(19.75,139.75) ; v1(17.7,127.29) 17.71,127.27 R67390.1
  IN1 w0.089: v1(19.75,139.75) 19.75,139.94 19.88,140.07 20.24,140.07 20.38,139.94 20.38,138.61 19.28,137.52 19.28,132.86 19.09,132.67 16.75,132.67 16.43,132.35 16.43,131.76 16.75,131.45 18.12,131.45 18.26,131.3 18.26,130.99 18.14,130.86 17.6,130.86 17.3,130.57 17.3,130.04 17.57,129.76 18.05,129.76 18.26,129.56 18.26,127 17.9,126.65 17.62,126.65 17.56,126.7 17.56,127.16 v1(17.7,127.29)
INT_HDMITX1N_OUT: length 24.8
  TOP w0.089: v1(17.6,141.51) 17.85,141.26 20.15,141.26 20.27,141.38 U23.13 ; R67393.1 17.73,124.27 v1(17.7,124.25)
  IN1 w0.089: v1(17.6,141.51) 17.42,141.33 17.05,141.33 16.76,141.04 16.76,138.87 17.26,138.37 17.26,135.82 14.9,133.46 14.9,125.41 15.62,124.68 17.25,124.68 17.69,124.25 v1(17.7,124.25)
INT_HDMITX1P_OUT: length 24.8
  TOP w0.089: v1(17.6,140.75) 17.85,140.99 20.16,140.99 20.28,140.88 U23.14 ; R67392.1 17.71,125.42 v1(17.69,125.44)
  IN1 w0.089: v1(17.6,140.75) 17.6,140.89 17.48,141.01 17.18,141.01 17.08,140.91 17.08,139 17.57,138.51 17.57,135.69 15.21,133.33 15.21,125.54 15.75,125 17.38,125 17.65,124.74 17.85,124.74 17.9,124.79 17.9,125.22 v1(17.69,125.44)
INT_HDMITX2N_OUT: length 24.9
  TOP w0.089: R67395.1 17.77,122.45 v1(17.72,122.39) ; U23.11 20.23,142.38 20.14,142.29 19.95,142.29 v1(19.73,142.51)
  IN1 w0.089: v1(19.73,142.51) 19.84,142.4 20.9,142.4 21.42,141.88 21.42,138.15 20.31,137.05 20.31,132.44 19.3,131.43 19.3,126.59 18.94,126.22 18.94,122.89 18.59,122.54 17.87,122.54 v1(17.72,122.39)
INT_HDMITX2P_OUT: length 24.9
  TOP w0.089: U23.12 20.24,141.88 20.09,142.03 19.79,142.03 19.73,141.97 v1(19.73,141.75) ; v1(17.72,123.57) 17.78,123.51 R67394.1
  IN1 w0.089: v1(17.72,123.57) 17.72,122.92 17.78,122.86 18.46,122.86 18.62,123.03 18.62,126.36 18.98,126.72 18.98,131.56 20,132.57 20,137.18 21.1,138.28 21.1,141.75 20.77,142.08 19.81,142.08 19.73,142 v1(19.73,141.75)
INT_HUB_TO_CPU: length 41.8
  TOP w0.079: 155.67,212.62 155.36,212.93 155.36,213.4 U6516.D2
  TOP w0.114: v1(129.77,216.48) 129.79,216.5 R25639.2 R25634.2 131.24,215.93 131.24,215.31 131.36,215.19 v1(131.36,213.17) Q6540.3 ; v1(155.67,212.62) 155.67,212.62
  IN1 w0.089: v1(131.36,213.17) 131.36,209.93 132.44,208.84 135.42,208.84 136.5,207.76 138.04,207.76 139.59,209.32 141.34,209.32 141.53,209.13 143.41,209.13 143.71,209.44 149.28,209.44 150.28,210.43 151.3,210.43 151.62,210.75 153.81,210.75 v1(155.67,212.62)
  BOTTOM w0.114: R25628.1 153.75,210.79 153.77,210.82 R25647.1 154.08,210.87 155.67,212.46 v1(155.67,212.62)
INTRUDER#_R: length 42.3
  TOP w0.114: R42.1 82.96,104.67 v1(82.99,104.64) 83.27,104.36 v1(83.27,103.99)
  BOTTOM w0.079: U1.BR35 101.31,132.93 101.11,132.93 101,132.96 100.77,132.96 100.72,132.93 100.4,132.93 100.22,133.02 98.54,133.02 97.09,131.56 96.13,131.56 95.14,130.58 95.01,130.58
  BOTTOM w0.114: v1(83.27,103.99) 83.27,104.2 84.04,104.97 84.04,107.38 83.12,108.31 83.12,111.79 84.05,112.72 84.05,115.65 86.09,117.69 86.09,117.76 86.65,118.32 86.65,121.54 92.51,127.4 92.51,129.47 93.62,130.58 95.01,130.58
IRQ_R: length 79.5
  TOP w0.114: v1(59.33,91.78) 59.33,92.15 59.36,92.19 R67557.2 R67555.1 58.79,93.13 Q6555.3
  IN1 w0.089: v1(59.33,91.78) 60.32,91.78 60.72,92.18 63.8,92.18 64.12,91.86 64.12,91.57 64.86,90.83 73.9,90.83 76.86,93.79 78.13,93.79 79.09,94.76 92.71,94.76 93.39,95.44 95.82,95.44 96.32,94.95 v1(96.32,94.59)
  BOTTOM w0.079: 106.05,115.72 106.05,118.39 106.33,118.67 106.33,120.16 105.58,120.91 105.58,122.55 105.94,122.91 U1.CM28
  BOTTOM w0.114: v1(96.32,94.59) 96.31,94.59 96.31,94.88 98.74,97.31 98.74,99.24 97.48,100.5 97.48,108.37 98.36,109.24 100.11,109.24 100.74,109.87 100.74,111.22 101.64,112.12 101.64,112.6 102.04,113 102.04,113.44 102.93,114.32 105.66,114.32 106.05,114.72 106.05,115.72
ISEN1N_CORE: length 39.9
  TOP w0.114: PC7025.2 165.21,139.29 v1(165.08,139.16)
  TOP w0.203: v2(163.6,138.45) 163.6,138.51 164.28,139.19 PC7047.2 164.28,139.68 164.29,139.69 PR7075.2 164.56,140.16 164.85,139.88 PC7025.2
  IN3 w0.203: v2(163.6,138.45) 162.75,137.6 162.75,137.02 162.05,136.32 160.64,136.32 158.53,138.42 158.53,139.29 159.05,139.81 159.05,142.75 157.75,144.05 157.75,144.89 155.38,147.27 148.98,147.27 145.2,151.05 145.2,154.11 144.96,154.34 144.66,154.34 v1(144.48,154.16)
  BOTTOM w0.203: PU7000.7 163.9,138.81 163.6,138.51 v2(163.6,138.45) ; PR7074.2 143.87,154.59 144.31,154.16 v1(144.48,154.16)
ISEN1N_GT: length 58
  TOP w0.114: v1(136.3,165.38) v1(137.01,165.38)
  TOP w0.203: v1(160.96,149.7) PR7100.2 161.77,149.01 PC7100.2 PC7097.2 162.89,149.02 v1(162.41,149.49)
  IN3 w0.203: v1(160.96,149.7) 160.49,149.24 160.01,149.24 159.01,150.24 159.01,150.97 160.22,152.18 160.22,157.18 159.57,157.84 157.55,157.84 157.08,158.31 157.08,163.72 155.43,165.37 155.43,166.74 153.44,168.73 139.45,168.73 139.2,168.99 137.45,168.99 136.92,169.52 v1(135.76,169.52) 135.76,168.82 137.01,167.57 v1(137.01,165.38)
  BOTTOM w0.203: PU7000.28 163.1,146.53 162.98,146.65 162.98,147.12 162.68,147.42 PC7030.2 162.41,148.26 v1(162.41,149.49) ; PR7101.2 v1(135.76,169.52) ; PR7097.2 v1(137.01,165.38)
ISEN1N_SA: length 34.8
  TOP w0.114: PC7029.2 171.56,147.16 v1(172.14,147.16)
  TOP w0.203: v2(169.16,143.67) 169.37,143.87 169.71,143.87 170.15,144.31 PC7079.2 170.15,145.32 PC7099.2 170.18,146.08 PR7092.2 170.74,146.64 170.83,146.64 171.1,146.91 PC7029.2
  IN3 w0.203: v1(155.22,128.68) 155.38,128.84 157.46,128.84 159.23,130.61 159.23,131.08 v1(159.42,131.26) 160.13,131.26 160.35,131.04 162.34,131.04 164.14,132.84 164.14,133.17 165.07,134.11 165.07,134.53 166.73,136.2 166.73,137.29 167.68,138.23 167.68,143.35 167.89,143.56 169.05,143.56 v2(169.16,143.67)
  BOTTOM w0.203: PU7000.41 167.74,143.41 167.77,143.44 168.18,143.44 168.33,143.59 168.34,143.59 168.35,143.59 168.95,143.59 168.99,143.63 169.12,143.63 v2(169.16,143.67) ; PR7089.2 155.06,128.84 v1(155.22,128.68) ; v1(159.42,131.26) PR7093.2
ISEN1P_CORE: length 4.2
  TOP w0.203: PR7075.1 163.51,139.86 163.5,139.84 PC7047.1 162.66,139.2 PR7076.2 162.55,138.7 v2(162.27,138.43)
  BOTTOM w0.152: v2(162.27,138.43) 162.37,138.52 162.37,138.83 162.7,139.16 PU7000.10
ISEN1P_GT: length 5.5
  TOP w0.203: v2(163.47,146.85) 163.86,147.24 v1(164.01,147.24) 164.01,147.95 PR7098.2 163.86,148.08 PC7097.1 PC7100.1 161.86,148.01 PR7099.1
  BOTTOM w0.203: PU7000.29 163.5,146.82 v2(163.47,146.85)
ISEN1P_SA: length 6.5
  TOP w0.114: PR7090.1 167.95,145.21 v1(168.38,145.64)
  TOP w0.203: PR7090.1 168.09,144.8 v2(168.76,144.13) 168.85,144.13 168.98,144.26 169.25,144.26 PC7079.1 169.37,145.32 PC7099.1 169.4,146.12 169.44,146.16 PR7091.2
  BOTTOM w0.203: PU7000.40 168.05,143.81 168.24,144.01 168.63,144.01 v2(168.76,144.13)
ISEN2N_CORE: length 28.8
  TOP w0.114: v1(145.82,138.4) 145.82,138.16 v1(146.22,137.76)
  IN3 w0.203: v1(162.97,134.54) 162.72,134.54 161.78,133.6 161.3,133.6 159.73,135.16 158.43,135.16 156.07,132.8 149.2,132.8 148.36,133.64 147.54,133.64 146.54,134.64 146.54,137.44 v1(146.22,137.76)
  BOTTOM w0.203: v1(162.97,134.54) 162.8,134.71 162.8,135.3 162.8,135.3 PC7027.2 162.8,136.08 162.71,136.17 PR7085.1 162.71,136.91 162.7,136.91 PC7065.2 162.87,137.43 163.65,136.65 PR7066.1 ; PR7083.2 v1(146.22,137.76)
ISEN2P_CORE: length 8.5
  BOTTOM w0.114: v1(162.56,132.84) 163.35,133.62 PR7065.2
  BOTTOM w0.152: PC7065.1 162.75,138.26 162.75,138.77 163.1,139.12 PU7000.9
  BOTTOM w0.203: PR7065.2 163.09,133.71 162.45,134.35 162.45,135.05 162.04,135.46 PR7084.2 161.94,135.93 161.93,135.94 PR7085.2 161.93,137.42 PC7065.1
ISOLATEB: length 9.1
  TOP w0.114: R9340.1 28.49,163.13 R509.2 27.64,161.94 v1(27.64,161.69) 27.64,161.46 27.49,161.31 25.03,161.31 24.85,161.49 24.85,161.93 R510.2 24.18,163.22 23.59,163.81 U6521.1
JTAG_TCK: length 7.8
  BOTTOM w0.114: U8.AE5 122.81,202.25 122.41,202.65 119.69,202.65 119.3,202.25 116.54,202.25 TP70.1
JTAG_TCK_PCH: length 12.2
  TOP w0.102: v2(119.34,154.96) 119.77,154.52 120.49,154.52 121.01,154.01 122.64,154.01 122.87,154.24 127.43,154.24 128.08,154.88 129.36,154.88 TP50.1 129.69,154.57 R17.2
  BOTTOM w0.102: U1.W6 119.52,155.15 119.34,154.97 v2(119.34,154.96)
JTAG_TDI: length 8.3
  BOTTOM w0.114: TP72.1 119.26,201.61 119.46,201.81 123.48,201.81 U8.AE6
JTAG_TDI_PCH: length 12.3
  TOP w0.102: v2(126.85,158.49) 127.36,158.49 R3.1
  BOTTOM w0.079: R13.2 126.01,158.87 126.07,158.82 126.69,158.82 126.85,158.67 v2(126.85,158.49) 126.72,158.36 126.42,158.36 125.92,157.86 125.92,157.55 125.4,157.03 125.4,155.72 124.75,155.06 123.93,155.06 123.72,155.27 123.72,155.49 123.49,155.72 122.99,155.72 122.39,156 121.41,156 121.23,156.18 121.23,156.41 121.06,156.59 120.78,156.59 120.54,156.35 U1.U5
JTAG_TDO: length 9.1
  BOTTOM w0.114: TP73.1 116.9,203.22 119.25,203.22 119.42,203.4 122.38,203.4 122.64,203.15 122.64,202.85 122.84,202.65 123.52,202.65 U8.AF6
JTAG_TDO_PCH: length 13.6
  TOP w0.102: v2(120.38,155.87) 121.61,154.64 127.26,154.64 127.91,155.29 128.81,155.29 129.05,155.53 129.31,155.53 129.99,156.22 130.39,156.22 130.74,156.56 R4.1
  TOP w0.114: R4.1 131.31,156.56 131.67,156.93 R14.2
  BOTTOM w0.079: v2(120.38,155.87) 120.17,155.65 U1.W5
JTAG_TMS: length 9
  BOTTOM w0.114: TP71.1 119.02,200.25 119.17,200.1 123.23,200.1 123.54,200.4 123.54,201.07 U8.AD6
JTAG_TMS_PCH: length 13.6
  TOP w0.102: 124.81,163.54 123.14,163.54 122.02,162.42 121.24,162.42 120.86,162.04 120.86,160.26 121.27,159.86 121.27,159.49 v2(120.42,158.64)
  TOP w0.114: 124.81,163.54 126.3,163.54 126.58,163.25 127.87,163.25 128.17,162.96 R5.1 128.55,162.96 128.64,163.05 R12.2
  BOTTOM w0.079: v2(120.42,158.64) 120.17,158.39 U1.P5
JTAG_TRST#: length 7.4
  BOTTOM w0.114: R396.1 116.78,204.69 120.48,204.69 120.93,204.24 121.82,204.24 U8.AG4
JTAGX_PCH: length 27
  TOP w0.102: 130.86,160.21 R7.1 ; v2(119.38,157.74) 119.38,157.69 118.85,157.16 118.85,156.24 118.74,156.14 118.74,155.44 118.84,155.34 118.84,152.93 119.08,152.7 120.76,152.7 121.01,152.45 122.31,152.45 123.29,153.42 127.77,153.42 128.24,153.89 v2(128.6,153.89)
  TOP w0.114: v2(128.54,160.11) 128.91,159.73 129.62,159.73 130.08,160.19 R7.1 ; R11.2 131.14,160.65 130.86,160.37 130.86,160.21
  IN4 w0.089: v2(128.54,160.11) 127.96,159.53 127.96,158.72 127.31,158.06 127.31,155.2 128.6,153.91 v2(128.6,153.89)
  BOTTOM w0.102: U1.P6 119.52,157.88 v2(119.38,157.74)
KB_BL_LED: length 75
  TOP w0.114: U37.113 158.96,110.39 158.02,109.45 v1(158.02,108.74)
  IN3 w0.102: v1(158.02,108.74) 158.66,108.1 159.45,108.1 160.4,107.15 163.44,107.15 164.09,107.79 166.25,107.79 166.88,108.43 171.87,108.43 175.29,111.84 180.55,111.84 180.93,112.22 180.93,112.7 181.23,113 182.85,113 184.47,111.38 190,111.38 194.45,106.94 197.16,106.94 198.59,108.37 200.77,108.37 v1(201.28,108.88)
  BOTTOM w0.114: Q31.2 214.32,118.38 v1(213.57,117.62) 212.66,116.72 212.66,111.69 209.55,108.58 207.27,108.58 206.11,107.42 203.29,107.42 202.42,108.28 202.42,109.04 202.14,109.33 201.73,109.33 v1(201.28,108.88)
L_SPK+: length 81.7
  IN4 w1.016: 38.5,94.18 36.31,94.18 32.84,97.65 27.57,97.65 23.86,93.94 23.86,88.67 28.4,84.13 28.4,71.05 28.95,70.5 28.95,64.97 25.82,61.84 25.82,58.02 27.44,56.41 27.44,55.26 28.4,54.3 28.4,45.85 25.48,42.93 21.78,42.93 19.19,40.34
  vias: v1(19.31,37.51) v1(19.31,36.85) v1(39.7,93.91) v1(40.03,93.32) v1(40.36,93.91)
L_SPK+_1: length 153.3
  TOP w1.016: v1(41.78,100.38) 41.78,98.54 39.74,96.5 38.52,96.5 37.68,95.67 37.68,92.63
  IN4 w1.016: 81.46,197.38 81.08,197.76 78.88,197.76 77.33,196.21 67.54,196.21 63.3,191.97 62.13,191.97 60.63,190.48 60.63,183.36 60.36,183.09 60.36,181.27 54.48,175.38 44.69,175.38 40.86,171.55 40.86,159.28 40.89,159.25 40.89,159.07 41.21,158.74 41.21,120.85 40.62,120.26 40.62,103.12 41.07,102.67
  BOTTOM w1.016: 81.46,198.52 81.46,200.3 86.06,204.9 93.88,204.9 94.08,204.7 CN63.4
  vias: v1(41.37,101.72) v1(42.03,101.71) v1(81.11,196.52) v1(81.77,196.52)
L_SPK+_2:
  vias: v1(39.7,94.8) v1(40.36,95.5) v1(40.36,94.8)
L_SPK-: length 82.1
  IN4 w1.016: 41.75,93.03 41.47,92.75 35.87,92.75 32.29,96.33 28.12,96.33 25.18,93.39 25.18,89.22 29.72,84.68 29.72,71.6 30.27,71.05 30.27,64.42 27.14,61.3 27.14,58.57 28.76,56.96 28.76,55.81 29.72,54.85 29.72,45.3 26.02,41.61 22.52,41.61 21.52,40.6
  vias: v1(19.97,39.98) v1(20.73,39.92) v1(20.71,39.2) v1(41.02,93.91) v1(42.64,93.91)
L_SPK-_1: length 160.4
  TOP w1.016: 40.46,100.38 40.46,99.08 39.19,97.82 37.97,97.82 36.36,96.21 36.36,92.08 37.51,90.93 40.98,90.93
  IN4 w1.016: 82.78,197.97 81.66,199.08 78.34,199.08 76.79,197.53 66.75,197.53 62.52,193.29 61.58,193.29 59.31,191.02 59.31,183.91 59.04,183.64 59.04,181.82 53.93,176.7 44.15,176.7 39.54,172.09 39.54,158.55 39.89,158.2 39.89,121.4 39.3,120.81 39.3,102.62 39.39,102.53
  BOTTOM w1.016: 82.99,198.52 82.99,199.96 86.48,203.45 CN63.3
  vias: v1(39.91,101.74) v1(40.57,101.73) v1(40.85,91.34) v1(82.58,196.57) v1(83.24,196.57)
L_SPK-_2:
  vias: v1(41.02,94.8) v1(42.64,94.8)
LAD0_R: length 3.2
  BOTTOM w0.114: R673.1 193.83,110.85 192.38,109.4 CN17.58
LAD1: length 2.8
  BOTTOM w0.114: R2662.1 193.57,107.88 v4(193.25,107.56) 193.09,107.4 CN17.66
LAD2: length 2.7
  BOTTOM w0.114: R2663.1 193.46,107.11 193.24,106.9 CN17.68
LAD3: length 2.6
  BOTTOM w0.114: R2664.1 193.1,106.38 193.08,106.4 CN17.70
LAN_DIS#: length 150.3
  TOP w0.114: v1(27.69,165.98) 28.11,166.4 28.91,166.4 29.27,166.03 R67504.2
  IN4 w0.089: v1(43.28,157.87) 43.11,157.87 42.72,157.48 42.72,123.65 43.08,123.29 43.86,123.29 44.51,122.64 44.51,108.64 46.42,106.72 47.09,106.72 48.78,105.04 50.27,105.04 51.44,103.87 54.54,103.87 55.58,102.83 63.37,102.83 65.4,104.86 66.51,104.86 66.84,105.19 75.36,105.19 86,115.83 v1(86.59,115.83)
  BOTTOM w0.079: U1.BU34 102.1,131.57 101.86,131.57 101.66,131.77 101.15,131.77 101.07,131.84 100.52,131.84 100.41,131.91 99.99,131.91 99.81,131.73 99.39,131.73 98.58,130.91 96.33,130.91 95.01,129.59
  BOTTOM w0.114: 95.01,129.59 94.03,129.59 93.5,129.06 93.5,126.99 87.64,121.13 87.64,117.91 87.08,117.35 87.08,116.92 86.59,116.43 v1(86.59,115.83) ; v1(27.69,165.98) 27.21,165.49 27.21,164.89 27.58,164.52 27.58,163.71 28.84,162.44 30.38,162.44 30.71,162.11 31.61,162.11 33.95,159.77 42.57,159.77 43.28,159.06 v1(43.28,157.87)
LAN_JTAG_TCK: length 4.1
  TOP w0.114: U6521.35 16.26,164.21 16.09,164.04 16.09,163.5 15.64,163.05 TP13161.1 15.25,162.26 R67512.2
LAN_JTAG_TDI: length 3.6
  TOP w0.114: v1(15.76,165.66) 15.8,165.66 16.05,165.41 U6521.32
  BOTTOM w0.114: R67509.2 16.3,166.14 TP13158.1 15.12,165.87 15.32,165.66 v1(15.76,165.66)
LAN_JTAG_TDO: length 2.8
  TOP w0.114: U6521.34 16.16,164.61 15.59,164.04 TP13159.1 14.79,163.73 R67510.2
LAN_JTAG_TMS: length 2.3
  TOP w0.114: U6521.33 15.57,165.01 TP13160.1 15.42,164.87 R67511.2
LAN_WAKE#: length 174.8
  TOP w0.114: v2(98.87,131.74) 98.79,131.82 98.17,131.82 95.23,128.88 93.5,128.88 93.15,128.53 91.86,128.53 90.76,127.43 R36.1 88.04,127.43 87.91,127.56 84.51,127.56 84.07,128 79.09,128 78.61,127.52 76.92,127.52 73.01,123.61 73.01,108.47 73.38,108.09 73.38,106.02 72.17,104.81 72.17,100.77 71.36,99.96 71.36,98.5 70.74,97.87 70.74,94.51 v1(70.64,94.41) 70.64,94.21 70.15,93.72 v1(70.15,93.21) ; R67505.2 v1(26.85,161.82)
  IN4 w0.089: v1(26.85,161.82) 26.13,161.1 26.13,156.1 28.45,153.78 28.45,148.65 27.99,148.19 27.99,147.26 27.83,147.09 27.83,143.82 29.11,142.54 29.11,134.6 28.37,133.86 28.37,130.28 29.39,129.26 29.39,120.74 30.47,119.66 30.47,115.54 30.95,115.06 30.95,109.62 30.73,109.4 30.73,104.16 33.81,101.08 34.32,100.57 35.22,100.57 38.18,97.61 42.94,97.61 43.14,97.81 48.62,97.81 51.47,94.95 51.47,93.18 51.69,92.96 68.29,92.96 69.06,93.74 69.63,93.74 v1(70.15,93.21)
  BOTTOM w0.079: U1.BU32 102.89,131.91 102.89,132.2 102.67,132.42 102.05,132.42 101.96,132.51 101.74,132.51 101.61,132.37 101.08,132.37 101.05,132.35 100.54,132.35 100.39,132.28 100,132.28 99.84,132.44 99.4,132.44 98.87,131.91 v2(98.87,131.74)
LAN_XTAL1: length 5.5
  TOP w0.114: Y4.1 31.46,169.46 30.15,169.46 29.9,169.2 29.9,168.67 C638.2 R511.2
LANPWR#: length 215.2
  TOP w0.114: v1(142.73,98.68) 143.55,98.68 144.05,99.18 144.05,99.84 146.91,102.7 147.01,102.7 147.3,102.99 148.01,102.99 148.24,103.22 148.24,103.49 148.58,103.83 TP9045.1 149.3,104.06 150.09,104.06 150.33,103.83 150.33,103.67 150.46,103.54 U37.16 ; v1(33.53,176.38) 32.31,176.38 R67508.1
  IN3 w0.102: v1(114.29,96.14) 115.1,96.95 119.71,96.95 120.8,98.05 122.38,98.05 123.96,99.63 130.54,99.63 131.04,100.13 138.73,100.13 140.18,98.68 v1(142.73,98.68)
  IN4 w0.089: v1(114.29,96.14) 113.1,94.95 98.71,94.95 97.69,95.96 93.1,95.96 92.59,95.46 78.95,95.46 78.17,94.67 75.94,94.67 73.88,92.62 68.75,92.62 68.59,92.77 51.62,92.77 51.28,93.11 51.28,94.87 48.54,97.62 43.21,97.62 43.02,97.42 38.1,97.42 35.14,100.38 34.24,100.38 33.62,101 30.54,104.08 30.54,109.47 30.76,109.7 30.76,114.99 30.28,115.46 30.28,119.58 29.2,120.66 29.2,129.19 28.18,130.2 28.18,133.94 28.92,134.68 28.92,142.46 27.64,143.74 27.64,147.17 27.8,147.34 27.8,148.27 28.26,148.73 28.26,153.7 25.94,156.02 25.94,162.75 26.44,163.25 27.89,163.25 29.27,164.64 29.27,171.12 33.53,175.38 v1(33.53,176.38)
LANWAKEB: length 3.9
  TOP w0.114: R67505.1 R67506.1 25.14,162.84 24.63,163.35 24.63,163.46 v1(24.39,163.7) 24.28,163.7 23.77,164.21 U6521.2
LED0: length 3.6
  TOP w0.114: TP13153.1 16.12,169.37 16.12,168.02 16.33,167.81 U6521.26
LED1/EESK: length 5
  TOP w0.114: TP13154.1 14.37,169.86 15.26,169.86 15.85,169.26 15.85,167.89 16.34,167.41 U6521.27
LED2/EEDO: length 4.1
  TOP w0.114: TP13152.1 16.44,170.35 16.44,169.11 16.89,168.65 U6521.25
LFRAME#_R: length 3
  BOTTOM w0.114: CN17.62 192.8,108.4 193.73,109.33 R675.1
LGATE1_CORE: length 7.2
  TOP w0.114: v3(151.95,160.04) 152,160.09 v1(152,160.85)
  IN4 w0.508: v3(151.95,160.04) 150.71,160.04 149.51,158.84 149.51,157.25 149.58,157.17 v1(149.58,156.38)
  BOTTOM w0.305: v3(151.95,160.04) 151.95,160.04 PU7002.7
LGATE2_CORE: length 7.9
  TOP w0.114: v1(152.57,144.02) 152.58,144.03 v1(152.58,144.73)
  IN4 w0.508: v1(152.57,144.02) 151.79,144.02 150.47,142.7 v3(150.47,140.44)
  BOTTOM w0.254: PU7001.7 152.8,144.26 v1(152.57,144.02)
  BOTTOM w0.508: PQ7001.8 v3(150.47,140.44)
LGATE_GT: length 19.1
  TOP w0.114: v1(157.48,165.55) 156.82,165.55 v1(156.82,165.55)
  IN4 w0.508: v1(156.82,165.55) 155.93,166.44 152,166.44 151.77,166.67 142.62,166.67 v3(141.61,167.69)
  BOTTOM w0.254: PU7003.7 v1(156.82,165.55)
  BOTTOM w0.508: PQ7004.8 142.42,166.88 v3(141.61,167.69)
LGATE_SA: length 4
  TOP w0.254: PU7004.7 163.65,131.36 v1(163.6,131.31)
  BOTTOM w0.508: PQ7003.4 162.16,129.02 162.59,129.44 v1(162.59,130.3) v1(163.6,131.31)
LID#: length 477.4
  TOP w0.114: HE1.1 147.35,213.54 C841.1 147.35,210.18 147.28,210.12 D13091.2 146.62,209.32 v1(146.34,209.04) ; R25315.2 162.04,115.34 162.66,115.96 163.64,115.96 163.98,116.3 163.98,117.94 165.21,119.17 v1(165.77,119.17) ; R67864.1 139.7,208.44 139.7,207.7 v1(139.47,207.47)
  IN1 w0.089: v1(146.34,209.04) 146.14,209.25 143.79,209.25 143.38,208.84 141.93,208.84 141.55,208.45 140.85,208.45 139.87,207.47 v1(139.47,207.47) 137.23,207.47 137.13,207.57 136.42,207.57 135.34,208.65 128.06,208.65 127.79,208.92 124.74,208.92 123.76,209.9 122.42,209.9 119.86,207.33 119.08,207.33 116.82,205.07 116.82,198.73 117.48,198.07 117.48,195.61 116.53,194.65 116.53,192.4 116.01,191.89 116.01,189.77 115.79,189.55 115.51,189.55 114.33,188.37 114.33,187.41 112.59,185.66 107.29,185.66 106.66,186.3 103.44,186.3 102.84,186.9 102.84,188.48 100.91,190.41 100.72,190.41 100.4,190.72 97.33,190.72 96.31,191.75 94.08,191.75 93.45,191.12 87.22,191.12 v1(85.53,192.81)
  IN2 w0.102: v1(71.16,100.81) 72.91,102.56 77.39,102.56 77.61,102.78 80.4,102.78 80.63,103 84.35,103 84.91,102.45 v1(85.37,102.45) 86.3,103.38 87.51,103.38 87.83,103.7 88.64,103.7 88.65,103.7 92.5,103.7 92.79,103.98 95.62,103.98 96.19,103.41 96.59,103.41 97.11,103.93 99.73,103.93 102,106.2 104.71,106.2 106.08,107.57 111.92,107.57 112.48,107.01 117.83,107.01 118,107.19 120.7,107.19 121.22,106.67 127.84,106.67 130,104.51 133.54,104.51 134.41,103.64 143.81,103.64 145.07,102.38 146.14,102.38 146.7,102.94 152.83,102.94 153.13,103.25 159.12,103.25 159.53,103.66 159.53,104.2 161.21,105.87 166.13,105.87 167.33,107.07 169.53,107.07 170.71,108.25 171.82,108.25 175.06,111.49 184.93,111.49 186.34,110.08 186.34,108.84 187.3,107.88 194.15,107.88 194.86,108.6 196.93,108.6 197.33,108.2 202.43,108.2 202.97,108.74 202.97,112.69 202.16,113.5 202.16,115.99 207.81,121.64 207.81,121.84 208.4,122.43 209.11,122.43 v1(209.52,122.02)
  IN3 w0.102: v1(209.52,122.02) 207.11,119.61 192.72,119.61 191.31,118.19 182.04,118.19 181.08,119.15 177.65,119.15 176.18,120.62 176.18,120.85 175.78,121.26 174.96,121.26 174.67,120.97 169.78,120.97 169.49,120.67 168.01,120.67 167.69,121 167.33,121 165.77,119.43 v1(165.77,119.17)
  IN4 w0.089: v1(52.88,100.33) 51.93,100.33 49.62,102.64 48.12,102.64 47.57,103.19 47.57,104.65 46.89,105.33 45.67,105.33 45.21,105.79 45.21,107.13 43.94,108.4 43.94,122.4 43.62,122.71 42.84,122.71 42.14,123.41 42.14,159.13 41.79,159.48 41.79,171.16 45.08,174.45 55.74,174.45 59.09,177.8 59.09,178.05 60.02,178.98 60.27,178.98 61.65,180.36 61.65,180.6 63.18,182.14 63.18,186.67 62.66,187.2 61.94,187.2 61.57,187.57 61.57,190.09 62.52,191.04 83.76,191.04 v1(85.53,192.81)
  BOTTOM w0.114: v1(85.53,192.81) D3.1 86.29,190.9 86.81,190.38 R25370.2 ; CN4.6 84.15,100.35 84.35,100.54 84.96,100.54 85.37,100.95 85.37,101.6 85.37,101.6 v1(85.37,102.45) ; v1(71.16,100.81) 70.93,100.58 58.93,100.58 57.95,99.61 53.61,99.61 v1(52.88,100.33)
LID#_C: length 7.7
  TOP w0.114: U37.118 156.96,111.98 156.4,112.54 156.4,113.57 157.06,114.24 157.53,114.24 157.87,114.58 v1(158.04,114.58) 158.08,114.53 D65.1 159.81,114.53 C6572.1 160.1,114.65 160.71,115.26 R25315.1
LID_OPEN_GMR: length 2.6
  TOP w0.114: R67864.2 138.73,209.85 138.36,210.21 138.36,210.43 v1(138.13,210.66) 137.72,211.07 137.72,211.29 137.89,211.45 U6525.4
LINE1-L: length 6.3
  BOTTOM w0.203: v1(17.28,27.4) 17.43,27.56 17.43,27.94 18.21,28.72 U20.22
  BOTTOM w0.381: C589.1 15.1,24.69 15.68,25.27 15.68,25.44 16.72,26.49 16.72,26.85 v1(17.28,27.4)
LINE1-R: length 5.1
  BOTTOM w0.203: U20.21 18.61,28.61 18.02,28.03 18.02,27.24 17.53,26.74
  BOTTOM w0.381: C594.1 16.57,25.15 17.22,25.81 v1(17.22,26.08) 17.41,26.27 17.41,26.62 17.53,26.74
LINE1-VREFO-L: length 12.9
  IN3 w0.381: v1(14.99,32.46) 14.71,32.46 14.18,31.93 14.18,30.23 14.71,29.7 14.71,27.74 14.97,27.48 14.97,25.95 15.12,25.8 15.12,23.88 v1(15.88,23.12)
  BOTTOM w0.203: v1(14.99,32.46) 15.14,32.61 U20.31 ; v1(15.88,23.12) 16.15,22.84 R476.1
LINE1-VREFO-R: length 13.5
  TOP w0.381: v1(18.01,23.64) 18.38,23.64 v1(18.63,23.39)
  IN3 w0.381: v1(18.63,23.39) 17.66,23.39 16.62,24.43 16.62,27.06 15.85,27.83 15.85,30.58 14.97,31.46 v2(14.97,31.7)
  BOTTOM w0.203: U20.30 15.4,32.21 14.97,31.78 v2(14.97,31.7) ; R477.1 v1(18.63,23.39)
LPC_LAD0: length 149.1
  TOP w0.114: U37.10 152.09,105.94 153.27,104.76 154.63,104.76 155.1,104.29 155.1,103.55 154.5,102.95 154.5,102.49 154.69,102.29 154.91,102.29 156.09,103.48 156.72,103.48 v1(157.15,103.91) ; v1(195.76,110.89) 195.05,110.89 v1(194.98,110.82)
  IN4 w0.089: v2(105.42,128.41) 105.84,128.82 106.44,128.82 106.62,128.65 106.62,128.07 107.4,127.29 107.4,126.61 107.69,126.32 108.29,126.32 108.61,126 108.61,124.44 110.46,122.6 112.09,122.6 112.95,121.74 118.66,121.74 119.19,121.21 119.45,121.21 119.55,121.11 119.55,120.76 119.44,120.65 118.82,120.65 118.74,120.56 118.74,120.3 118.81,120.22 119.56,120.22 119.66,120.13 120.37,120.13 120.49,120.01 120.49,119.8 120.4,119.71 119.57,119.71 119.48,119.62 119.48,119.44 119.6,119.32 120.32,119.32 120.39,119.26 120.39,119.04 120.3,118.95 119.45,118.95 119.37,119.03 119.06,119.03 118.88,118.85 118.88,118.33 118.97,118.24 120.12,118.24 120.31,118.05 120.31,117.86 120.25,117.8 119.75,117.8 119.67,117.71 119.67,117.46 119.75,117.37 121.41,117.37 121.62,117.17 121.62,117.03 121.53,116.94 120.24,116.94 120.15,116.85 120.15,116.65 120.24,116.56 121.73,116.56 121.83,116.46 121.83,116.22 121.71,116.1 120.74,116.1 120.62,115.98 120.62,115.81 120.74,115.68 121.66,115.68 121.74,115.6 121.74,115.37 121.65,115.28 120.54,115.28 120.42,115.16 120.42,112.59 121.8,111.21 121.8,110 123.3,108.49 124.74,108.49 125.22,108.01 128.54,108.01 131.85,104.7 132.24,104.7 133.75,103.19 135.41,103.19 135.51,103.29 137.34,103.29 137.89,102.74 140.96,102.74 141.25,103.04 144.37,103.04 145.02,102.39 147.22,102.39 147.39,102.56 150.97,102.56 151.08,102.67 156.19,102.67 156.26,102.6 156.26,102.37 156.35,102.28 156.53,102.28 156.64,102.39 156.64,103.34 157.15,103.85 v1(157.15,103.91) 157.6,104.35 158,104.35 158.11,104.25 158.71,104.25 158.81,104.35 163.51,104.35 163.9,103.96 163.9,103.43 164.36,102.98 165.83,102.98 166.91,104.05 170.34,104.05 173.38,107.1 173.38,107.88 175.83,110.33 180.38,110.33 180.5,110.21 180.5,108.93 180.66,108.77 180.87,108.77 181.01,108.91 181.01,109.99 181.12,110.1 181.42,110.1 181.52,110 181.52,108.89 181.64,108.77 182.85,108.77 183.79,109.71 183.79,110.63 186.05,112.88 188.95,112.88 191.01,110.82 193.79,110.82 193.92,110.7 193.92,110.12 194.01,110.03 194.33,110.03 194.42,110.12 194.42,110.73 194.52,110.82 v1(194.98,110.82)
  BOTTOM w0.079: U1.CA29 105.18,128.64 v2(105.42,128.41)
  BOTTOM w0.114: R673.2 194.48,110.82 v1(194.98,110.82)
LPC_LAD1: length 145.9
  TOP w0.114: U37.9 152.3,106.34 153.56,105.08 154.76,105.08 155.58,104.25 v1(155.58,103.97) ; v1(195.89,108.53) 195.51,108.53 v1(195.14,108.16)
  IN4 w0.089: v1(195.14,108.16) 195.26,108.16 196.04,108.95 196.04,111.66 195.26,112.45 190.63,112.45 189.31,113.76 185.68,113.76 183.35,111.43 181.33,111.43 181.11,111.21 175.47,111.21 172.51,108.25 172.51,107.47 170.73,105.69 167.68,105.69 167.21,105.22 160.27,105.22 159.69,105.8 158.23,105.8 157.65,105.23 156.85,105.23 v1(155.58,103.97) 155.58,103.71 155.42,103.55 151.92,103.55 151.83,103.63 151.83,103.95 151.75,104.04 151.51,104.04 151.43,103.95 151.43,103.64 151.34,103.55 151.11,103.55 151.05,103.61 151.05,103.96 150.97,104.04 150.77,104.04 150.66,103.93 150.66,103.5 150.59,103.43 150.34,103.43 150.26,103.51 150.26,103.96 150.18,104.04 149.56,104.04 149.18,103.65 147.66,103.65 147.4,103.91 140.89,103.91 140.59,103.62 138.26,103.62 137.71,104.17 135.14,104.17 135.06,104.08 134.09,104.08 132.6,105.57 132.21,105.57 128.9,108.89 125.58,108.89 125.5,108.96 125.5,109.13 125.61,109.24 128.53,109.24 128.62,109.33 128.62,109.46 128.53,109.55 125.31,109.55 125.23,109.63 125.23,109.85 125.31,109.93 127.79,109.93 127.89,110.03 127.89,110.18 127.77,110.3 125.06,110.3 125,110.36 125,110.59 125.09,110.68 127.18,110.68 127.25,110.74 127.25,110.95 127.17,111.03 124.79,111.03 123.61,112.2 123.61,113.48 123.47,113.63 122.73,113.63 122.07,114.29 122.07,114.46 123.23,115.63 123.23,116.79 122.24,117.78 122.24,118.28 121.98,118.54 121.09,118.54 120.97,118.66 120.97,119.47 120.9,119.54 120.9,120.46 119.24,122.12 113.22,122.12 112.39,122.95 110.61,122.95 109,124.56 109,126.39 107,128.39 107,129.08 106.44,129.64 105.85,129.64 105.77,129.72 105.29,129.72 104.94,129.37 104.94,129.34 v2(104.91,129.31)
  BOTTOM w0.079: U1.BY29 105.18,129.57 104.92,129.31 v2(104.91,129.31)
  BOTTOM w0.114: v1(195.14,108.16) 194.73,108.16 R2662.2
LPC_LAD2: length 145.5
  TOP w0.114: v1(156.26,103.96) 156.26,104.02 154.89,105.39 153.94,105.39 152.59,106.74 U37.8
  IN4 w0.089: v1(195.14,107.46) 194.71,107.9 194.71,108.37 194.94,108.6 195.24,108.6 195.75,109.11 195.75,111.54 195.14,112.15 190.51,112.15 189.19,113.47 185.8,113.47 183.47,111.13 181.45,111.13 181.23,110.91 175.59,110.91 172.8,108.13 172.8,107.34 170.86,105.4 167.81,105.4 167.34,104.93 166.76,104.93 165.97,104.14 164.55,104.14 163.76,104.93 159.2,104.93 158.7,105.43 158.27,105.43 157.78,104.94 157.06,104.94 156.26,104.14 v1(156.26,103.96) 155.56,103.25 150.84,103.25 150.73,103.14 147.41,103.14 147.28,103.27 147.28,103.54 147.2,103.62 146.98,103.62 146.86,103.5 146.86,103.06 146.77,102.97 146.49,102.97 146.43,103.03 146.43,103.5 146.31,103.62 141.01,103.62 140.71,103.32 138.14,103.32 137.58,103.88 135.27,103.88 135.18,103.79 133.97,103.79 132.48,105.28 132.09,105.28 128.78,108.59 125.46,108.59 124.98,109.08 123.55,109.08 123.21,109.41 123.21,109.52 123.35,109.66 124.85,109.66 124.93,109.75 124.93,109.92 124.81,110.03 122.59,110.03 122.49,110.14 122.49,110.36 122.57,110.45 124.61,110.45 124.71,110.55 124.71,110.69 124.63,110.77 122.45,110.77 122.38,110.85 122.38,111.04 122.45,111.11 122.82,111.11 122.91,111.2 122.91,111.41 122.82,111.5 122.36,111.5 122.29,111.56 122.29,111.83 122.37,111.91 123.09,111.91 123.18,112 123.18,112.19 123.09,112.27 121.59,112.27 121,112.86 121,113.65 121.18,113.83 121.56,113.83 121.79,113.6 121.79,112.94 122.04,112.69 123.2,112.69 123.32,112.81 123.32,113.21 123.19,113.34 122.61,113.34 121.66,114.29 121.66,114.47 122.94,115.75 122.94,116.3 122.84,116.4 122.51,116.4 122.41,116.5 122.41,117.2 121.95,117.66 121.95,118.16 121.86,118.25 120.97,118.25 120.68,118.54 120.68,120.41 119.16,121.93 113.08,121.93 112.23,122.78 110.53,122.78 108.82,124.49 108.82,126.31 106.81,128.32 106.81,128.9 106.44,129.27 v2(106.2,129.27)
  BOTTOM w0.079: v2(106.2,129.27) 106.21,129.27 106.21,129.38 106.48,129.66 U1.BY27
  BOTTOM w0.114: v1(195.14,107.46) 194.8,107.11 R2663.2
LPC_LAD3: length 147
  TOP w0.114: v1(156.01,105.18) 155.55,105.18 155.02,105.71 154.07,105.71 152.64,107.14 U37.7
  IN4 w0.089: v1(195.83,107.45) 195.83,108.32 196.33,108.83 196.33,111.78 195.38,112.74 191.87,112.74 189.9,114.71 187.08,114.71 186.42,114.05 185.56,114.05 183.23,111.72 181.21,111.72 180.99,111.5 175.35,111.5 170.49,106.64 168.22,106.64 167.09,105.51 160.39,105.51 159.81,106.09 158.1,106.09 157.53,105.52 156.73,105.52 156.38,105.18 v1(156.01,105.18) 155.68,105.18 155.15,104.65 155.15,103.93 155.06,103.84 154.78,103.84 154.72,103.9 154.72,104.53 154.59,104.66 152.19,104.66 152.15,104.62 149.32,104.62 148.94,104.24 147.9,104.24 147.64,104.5 140.65,104.5 140.35,104.2 138.5,104.2 137.95,104.75 137.11,104.75 136.56,105.3 135.94,105.3 135.79,105.15 135.79,104.84 135.7,104.75 135.41,104.75 135.32,104.84 135.32,105.16 135.18,105.3 134.68,105.3 134.28,104.9 134.1,104.9 133.97,105.03 133.97,105.18 134.26,105.48 134.26,105.62 134.15,105.73 134.03,105.73 133.75,105.45 133.56,105.45 133.44,105.56 133.44,105.72 133.75,106.02 133.75,106.14 133.55,106.33 133.43,106.33 133.12,106.01 132.99,106.01 132.86,106.14 132.86,106.26 133.17,106.57 133.17,106.71 133,106.88 132.88,106.88 132.45,106.45 132.16,106.45 131.76,106.85 131.76,106.96 132.06,107.26 132.06,107.4 131.91,107.56 131.76,107.56 131.48,107.28 131.33,107.28 130.14,108.47 130.14,108.55 130.61,109.01 130.61,109.18 130.47,109.32 130.33,109.32 129.91,108.89 129.72,108.89 129.57,109.04 129.57,109.2 130.05,109.68 130.05,109.83 129.9,109.98 129.73,109.98 129.44,109.69 129.33,109.69 129.14,109.88 129.14,110.01 129.43,110.3 129.43,110.46 129.28,110.61 129.15,110.61 128.86,110.32 128.7,110.32 127.41,111.61 127.18,111.61 127.07,111.72 127.07,112.5 126.98,112.59 126.7,112.59 126.59,112.48 126.59,111.71 126.48,111.61 125.07,111.61 124.2,112.48 124.2,114.7 124.42,114.92 125.4,114.92 125.5,115.02 125.5,115.26 125.42,115.34 124.42,115.34 124.28,115.48 124.28,115.66 124.4,115.78 125.08,115.78 125.17,115.87 125.17,116.08 125.08,116.17 124.04,116.17 123.94,116.27 123.94,116.58 124.04,116.69 124.87,116.69 124.97,116.78 124.97,117.01 124.88,117.1 123.75,117.1 123.65,117.2 123.65,117.42 123.75,117.52 123.89,117.52 123.99,117.61 123.99,118.17 123.86,118.29 122.97,118.29 122.83,118.43 122.83,119.4 120.76,121.46 120.61,121.46 119.57,122.51 113.97,122.51 113.67,122.81 113.05,122.81 112.47,123.39 111.96,123.39 111.74,123.61 111.74,125.04 111.62,125.16 111.14,125.16 111.01,125.03 111.01,124.46 110.9,124.35 110.59,124.35 110.51,124.43 110.51,124.72 110.38,124.85 110.04,124.85 109.83,124.64 109.66,124.64 109.42,124.87 109.42,126.75 108.56,127.61 108.56,127.96 108.15,128.37 108.15,130.3 107.89,130.56 106.64,130.56 v2(106.27,130.2)
  BOTTOM w0.089: U1.BV27 106.48,130.51 106.27,130.3 v2(106.27,130.2)
  BOTTOM w0.114: v1(195.83,107.45) 195.83,107.21 194.99,106.38 R2664.2
LPC_LFRAME#: length 147.8
  TOP w0.114: U37.6 152.69,107.54 154.14,106.09 155.76,106.09 157.81,104.04 v1(157.81,103.91)
  IN4 w0.089: v1(194.99,109.59) 191.83,109.59 188.83,112.59 186.17,112.59 184.11,110.54 184.11,109.62 182.97,108.48 180.54,108.48 178.98,110.04 175.95,110.04 173.68,107.76 173.68,106.98 170.46,103.76 167.03,103.76 164.73,101.46 160.54,101.46 160.43,101.58 160.43,101.88 160.56,102.02 161.66,102.02 161.82,102.17 161.82,102.59 161.82,102.59 161.82,102.77 162.01,102.96 163,102.96 163.12,103.07 163.12,103.37 163,103.48 158.84,103.48 158.42,103.91 v1(157.81,103.91) 157.81,103.61 157.71,103.51 157.23,103.51 157.09,103.37 157.09,103.1 157.2,102.99 159.11,102.99 159.21,102.88 159.21,102.1 159.1,101.99 155.8,101.99 155.41,102.38 151.2,102.38 151.09,102.26 147.51,102.26 147.34,102.1 144.89,102.1 144.24,102.75 141.37,102.75 141.08,102.45 137.77,102.45 137.22,103 135.63,103 135.53,102.9 133.63,102.9 132.12,104.41 131.73,104.41 128.42,107.72 125.1,107.72 124.62,108.2 123.15,108.2 121.5,109.84 121.5,111.09 120.16,112.44 119.7,112.44 119.5,112.64 119.5,114.47 119.65,114.63 120.01,114.63 120.1,114.71 120.1,114.92 120.01,115.01 118.84,115.01 118.75,115.1 118.75,115.3 118.84,115.39 119.78,115.39 119.88,115.49 119.88,115.69 119.8,115.77 118.86,115.77 118.75,115.88 118.75,116.1 118.84,116.19 119.86,116.19 119.92,116.25 119.92,116.48 119.83,116.57 118.83,116.57 118.75,116.65 118.75,117.79 118.6,117.94 117.99,117.94 117.9,118.03 117.9,118.25 118,118.36 118.5,118.36 118.59,118.45 118.59,118.67 118.47,118.79 118.01,118.79 117.91,118.89 117.91,119.17 118.01,119.27 118.61,119.27 118.71,119.37 118.71,119.98 118.61,120.08 117.53,120.08 117.37,120.24 117.37,120.84 117.45,120.92 118.7,120.92 118.79,121.01 118.79,121.29 118.72,121.35 112.99,121.35 111.93,122.42 110.39,122.42 108.19,124.62 108.06,124.62 107.76,124.92 107.76,126 107.22,126.54 107.22,127.16 106.21,128.17 v2(106.21,128.45)
  BOTTOM w0.079: v2(106.21,128.45) 105.83,128.83 U1.CA28
  BOTTOM w0.114: R675.2 194.72,109.33 v1(194.99,109.59)
LTE_BODY_SAR_ODL: length 85.3
  TOP w0.114: U37.126 153.76,109.76 154.66,108.86 v1(154.66,108.68)
  IN3 w0.102: v1(154.66,108.68) 156.28,107.06 159.02,107.06 159.97,106.11 167.09,106.11 167.96,106.98 171.4,106.98 175.41,110.99 179.16,110.99 182.45,107.7 190.01,107.7 191.52,106.2 195.19,106.2 195.66,105.72 196.97,105.72 197.94,106.69 199.25,106.69 v1(200.27,107.71)
  BOTTOM w0.114: CN49.14 221.14,121.25 220.4,120.5 218.25,120.5 v1(217.58,119.83) 217.23,119.49 216.73,119.49 213.19,115.95 213.19,111.46 210.52,108.78 210.51,108.78 209.77,108.05 207.5,108.05 206.32,106.88 202.96,106.88 202.13,107.71 v1(200.27,107.71)
LTE_OFF_ODL: length 113.3
  TOP w0.114: v1(147.63,95.98) 148.48,95.13 150.18,95.13 150.6,95.56 150.6,96.67 150.35,96.91 150.35,97.33 150.56,97.54 U37.31
  IN1 w0.089: v1(195.74,99.87) 195.74,100.14 196.81,101.2 197.99,101.2 198.47,100.72 209.02,100.72 211.8,103.5 216.42,103.5 218.59,105.67 221.24,105.67 224.61,109.04 224.61,110.5 227.75,113.64 227.75,122.2 226.94,123 226.48,123 v1(224.69,124.79)
  BOTTOM w0.114: v1(224.69,124.79) 224.69,124.28 223.66,123.25 CN49.10 ; v1(195.74,99.87) 195.2,99.33 195.2,98.38 194.74,97.92 192.88,97.92 192.02,97.06 182.5,97.06 182.14,97.41 179.36,97.41 179,97.05 168.7,97.05 167.94,96.29 164.12,96.29 163.28,95.46 153.5,95.46 152.83,96.13 151.78,96.13 151.1,95.46 148.16,95.46 v1(147.63,95.98)
