# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+A3VPCU: length 4.6
  TOP w0.203: U37.74 168.77,100.74 169.04,101.01 v1(169.37,101.01) 170.17,101.01 C6566.1 170.6,101.11 170.84,100.86 L29.2
+V3A_LX: length 1.2
  BOTTOM w0.114: v1(181.69,134.74) 181.29,134.74 PC6001.2
+V3A_LX_R: length 2.5
  BOTTOM w0.508: PR6001.2 180.71,124.39 180.68,124.36 v1(180.25,124.36) 179.55,125.06 PC6006.1
+V3A_OUT: length 0.9
  BOTTOM w0.203: PR6008.2 193.15,127.23 192.64,127.74 192.64,127.85
  vias: v1(188.06,127.45)
+V5P5A_LX: length 1
  TOP w0.508: PR6019.1 v2(51.16,179.47)
  vias: v1(53.8,180.31)
+V5P5A_LX_R: length 3
  TOP w0.114: PR6019.2 50.18,181.65 v1(50.14,181.68)
  TOP w0.508: PR6019.2 51.43,181.65 52.58,180.5 PC6038.1
+V5P5A_OUT: length 0.9
  BOTTOM w0.203: PR6026.2 44.39,179.1 44.5,179.2
  vias: v1(43.08,185.95)
+VCC_CORE: length 4.5
  BOTTOM w0.152: U1.BB2 122.97,140.98 v2(123.16,140.79) ; v2(121.38,138.73) 121.38,138.45 121.64,138.2 122.17,138.2 122.52,138.54 U1.BF2
  BOTTOM w0.254: U1.AP2 123.57,145.86 v1(123.66,145.77) ; v2(123.32,143.05) 123.19,143.18 122.78,143.18 U1.AV2
  vias: v1(108.53,140.23) v1(108.63,145.37) v1(108.63,144.73) v1(108.63,141.51) v1(108.63,140.87) v1(116.53,143) v1(116.61,144.27) v1(116.56,143.63) v1(132.13,152.7) v1(132.49,152.14) v1(132.92,152.7) v1(133.58,152.7) v1(134.29,152.7) v1(134.39,152.04) v1(134.93,152.45) v1(135.41,151.96) v1(135.4,148.89) v1(135.48,150.01) v1(135.74,151.05) v1(135.87,149.48) v1(136.05,148.83) v1(136.14,148.15) v1(136.71,148.81) v1(136.8,148.15) v1(137.14,142.77) v1(137.32,149.13) v1(137.28,141.97) v1(137.44,143.56) v1(137.46,148.17) v1(137.74,142.45) v1(137.86,148.75) v1(137.93,143.08) v1(138.18,148.15) v1(138.19,141.95) v1(138.29,143.64) v1(138.39,149.15) v1(138.59,143.03) v1(138.84,148.03) v1(138.8,142.4) v1(138.86,148.69) v1(138.87,146.62) v1(138.97,143.63) v1(139.25,143.02) v1(144.05,143.3) v2(106.16,145.7) v2(106.16,144.79) v2(106.16,143.88) v2(106.16,142.96) v2(106.16,142.05) v2(106.16,141.14) v2(106.16,140.23) v2(106.32,139.32) v2(108.03,145.24) v2(108.03,144.33) v2(108.03,142.51) v2(108.01,141.6) v2(108,139.78) v2(108.03,138.86) v2(116.5,139.44) v2(117.16,145.73) v2(117.16,143.88) v2(117.16,142.96) v2(118.36,145.73) v2(118.36,144.81) v2(118.36,142.03) v2(118.54,142.87) v2(118.54,141.2) v2(119.17,144.83) v2(119.83,141.2) v2(119.81,140.22) v2(128.63,153.28) v3(132.04,137.71) v3(132.8,137.71) v3(141.31,157.72) v3(141.31,156.96) v3(141.61,152.35) v3(141.61,151.59) v3(142.05,142.53) v3(142.05,141.77) v3(142.05,141.01) v3(142.05,140.17) v3(142.05,139.41) v3(142.05,138.64) v3(142.05,137.88) v3(142.08,157.72) v3(142.08,156.96) v3(142.37,152.35) v3(142.37,151.59) v3(142.7,150.86) v3(142.7,150.1) v3(142.84,157.72) v3(142.84,156.96) v3(142.8,142.26) v3(142.8,141.49) v3(142.8,140.73) v3(142.8,139.97) v3(143.13,152.35) v3(143.13,151.59) v3(143.43,146.44) v3(143.43,145.68) v3(143.46,150.86) v3(143.6,157.72) v3(143.6,156.96) v3(143.56,141.49) v3(143.56,140.73) v3(143.56,139.97) v3(143.89,152.35) v3(143.89,151.59) v3(144.22,150.86) v3(144.2,146.44) v3(144.2,145.68) v3(144.32,141.49) v3(144.32,140.73) v3(144.32,139.97) v3(144.96,146.44) v3(144.96,145.68) v3(145.08,141.49) v3(145.08,140.73) v3(145.08,139.97)
+VCC_V3A: length 2.5
  BOTTOM w0.114: PC6022.1 173.56,130.66 v1(173.56,131.37)
  BOTTOM w0.203: PU6000.9 174.71,130.43 174.59,130.55 PC6022.1
+VCC_V5P5A: length 3.9
  BOTTOM w0.203: PC6058.1 58.12,179.96 57.76,180.32 v1(57.76,181.53) 57.41,181.89 57.41,182.22 57.22,182.41 PU6003.11
+VCC_XD: length 29.1
  IN1 w0.762: 32.2,65.43 30.7,65.43 27.54,62.27 27.54,57.68 28.41,56.81 28.41,56.17 29.8,54.78 29.8,46.66 32.08,44.38 32.08,42.49
  BOTTOM w0.305: 30.09,64.75 29.76,64.41 U40.5
  vias: v1(33,65.63) v1(33.34,42.12) v1(33.44,42.78) v1(33.57,43.44) v1(33.8,66.35) v1(33.8,65.69) v1(33.8,65.03)
+VCCGT: length 2.6
  BOTTOM w0.127: U1.P2 122.87,157.74 123.2,157.74 123.28,157.66 v2(123.36,157.66)
  BOTTOM w0.254: U1.K2 122.84,160.8 123.32,160.8 123.42,160.9 v2(123.47,160.9)
  BOTTOM w0.305: 117.75,155.45 117.76,155.44 U1.W9
  vias: v1(108.55,158.94) v1(108.71,155.04) v1(108.84,155.67) v1(108.9,156.96) v1(108.86,156.31) v1(108.99,159.43) v1(108.95,158.23) v1(108.95,157.6) v1(110.77,160.08) v1(110.77,159.45) v1(110.77,158.81) v1(112.54,160.06) v1(112.53,159.22) v1(114.41,160.12) v1(114.41,159.49) v1(114.41,158.85) v1(115.53,160.04) v1(115.53,159.41) v1(115.53,158.77) v1(123.24,168.02) v1(123.8,167.08) v1(123.85,167.74) v1(124.49,167.97) v1(124.46,167.24) v1(124.46,166.44) v1(125.12,167.74) v1(125.12,167.08) v1(125.12,166.42) v1(127.72,166.89) v1(127.78,167.7) v1(128.33,166.6) v1(128.45,168.07) v1(128.4,167.28) v1(129.03,166.6) v1(129.49,169.96) v1(129.72,166.59) v1(130.22,169.94) v1(130.61,167.66) v1(130.91,169.92) v1(131.84,164.93) v1(131.84,164.16) v1(131.86,166.35) v1(131.86,165.65) v1(132.27,168.2) v1(132.27,167.51) v1(132.4,169.92) v1(132.51,166.7) v1(132.52,166.02) v1(132.49,165.32) v1(132.53,164.58) v1(132.53,163.9) v1(133.09,169.92) v1(133.24,167.61) v1(133.2,166.75) v1(133.2,166.07) v1(133.18,165.39) v1(133.21,164.65) v1(133.21,163.93) v1(133.47,168.29) v1(133.82,169.95) v1(133.96,167.61) v1(134.13,168.26) v2(110.8,165.41) v2(110.8,164.11) v2(110.8,162.81) v2(110.8,161.51) v2(112.59,165.41) v2(112.59,164.11) v2(112.59,163.46) v2(112.59,162.16) v2(112.59,161.51) v2(114.34,167.28) v2(114.44,166.67) v2(114.47,166.06) v2(114.47,165.41) v2(114.47,164.11) v2(114.47,163.46) v2(114.47,162.16) v2(114.47,161.51) v2(116.33,166.9) v2(116.26,166.16) v2(116.35,165.41) v2(116.35,164.11) v2(116.35,163.46) v2(116.35,162.16) v2(116.35,161.51) v2(117.04,168.32) v2(117.03,167.7) v2(116.99,156.82) v2(117.04,155.84) v2(117.16,159.59) v2(117.16,158.66) v2(117.33,165.42) v2(117.33,164.81) v2(117.33,163.52) v2(117.33,162.84) v2(118.33,156.82) v2(118.36,162.36) v2(118.36,160.51) v2(118.36,159.59) v2(118.36,158.66) v2(118.36,157.74) v2(119.38,163.28) v2(119.38,162.36) v2(119.38,160.51) v2(120.03,162.36)
+VCCGT_+VCORE: length 4.4
  BOTTOM w0.152: U1.AK2 122.81,148.3 123.37,147.75 v2(123.37,147.52) ; v2(123.67,150.53) 123.45,150.74 U1.AF2
  BOTTOM w0.203: v2(123.34,155.37) 122.8,155.37 U1.V2 ; U1.AB2 123.36,153.18 v2(123.5,153.04)
  vias: v1(108.66,149.96) v1(108.66,149.3) v1(116.43,154.72) v1(116.43,154.09) v1(116.42,152.99) v1(116.43,151.33) v1(116.36,148.74) v1(116.48,147.82) v1(116.89,148.38) v1(121.16,147.26) v2(108.05,149.8) v2(117.04,154.1) v2(117.02,153.05) v2(117.08,151.24) v2(118.31,153.12) v2(118.33,152.2) v2(118.33,151.27) v2(118.33,150.35) v2(118.36,148.51) v2(118.51,149.34) v2(118.47,147.52)
+VCCIO: length 114.3
  TOP w0.203: C80.2 112.42,134.39 v2(112.88,133.93) ; v2(106.27,136.6) 106.68,136.19 106.68,135.57 106.35,135.24 106.1,135.24 105.87,135.01 105.87,134.13 R72.2
  IN1 w0.381: v1(131.66,159.33) 131.66,159 131.19,158.54 131.19,156.56 130.79,156.16 130.79,154.22 131.19,153.82 131.19,150.29 129.09,148.19 129.09,145.88 128.18,144.97 125.98,144.97 v2(125.32,145.63)
  IN2 w0.381: v1(163.55,118.82) 163.55,119.04 162.17,120.42 160.33,120.42 159.26,121.49 156.85,121.49 155.91,122.44 155.91,123.09 155.35,123.65 150.84,123.65 147.7,126.79 147.7,127.39 146.21,128.87 140.76,128.87 139.56,130.07 137.34,130.07 136.67,129.4 135.79,129.4
  IN4 w0.203: v1(140.11,159.12) 140.41,159.42 148.62,159.42 150.17,160.97 151.57,160.97 152.16,161.56 152.16,162.38 152.83,163.06 156.53,163.06 157.36,162.22 157.36,159.51 157.86,159.01 159.47,159.01 160.66,157.82 160.66,151.39 161.31,150.74 163.52,150.74 v1(164.77,149.49)
  BOTTOM w0.203: v1(131.66,159.33) 132.25,159.92 132.25,160.63 133.02,161.4 138.22,161.4 138.53,161.09 138.53,159.56 138.97,159.12 v1(140.11,159.12) ; PR7011.2 v1(164.77,149.49)
  BOTTOM w0.254: v2(113.64,134.64) 113.64,133.99 U1.BP16 ; R23.2 131.45,158.09 131.66,158.29 v1(131.66,159.33) ; PR22.2 162.97,118.71 163.59,118.09 PC756.1 163.84,118.52 v1(163.55,118.82) ; U1.BP18 112.71,133.9 112.8,133.9 112.83,133.93 v2(112.88,133.93)
  BOTTOM w0.381: R2.1 v2(125.32,145.63)
  BOTTOM w0.508: v1(128.91,140.77) 128.35,140.21 R69.1
  vias: v1(130.64,126.52) v1(130.69,125.85) v1(131.34,126.33) v1(131.34,125.67) v1(131.34,125.01) v1(132,126.33) v1(132,125.67) v1(132,125.01) v1(132.67,125.85) v2(106.12,148.4) v2(106.17,147.51) v2(106.16,146.61) v2(106.18,137.6) v2(108.03,147.98) v2(108.01,147.07)
+VCCLDOSRAM_1P24: length 2.9
  BOTTOM w0.254: U1.BY24 108.4,129.73 v2(108.73,129.41) 109.05,129.73 U1.BY23 ; U1.CA23 109.05,129.08 v2(108.73,128.76) 108.4,129.08 U1.CA24
  BOTTOM w0.508: v1(108.19,116.28) R211.2
  vias: v2(108.91,119.25)
+VCCPLL: length 1.5
  BOTTOM w0.254: U1.BR11 117.05,132.98 v2(117.27,132.76) 117.1,132.76 116.67,132.33 U1.BT11
  vias: v1(133.32,129.94)
+VCCPLL_OC: length 13.2
  TOP w0.508: 102.13,136.44 101.95,136.26 98.27,136.26 97.25,137.28 96.52,137.28 96.5,137.3 92.16,137.3 v1(91.2,138.26)
  BOTTOM w0.305: v2(106.12,135.73) 106.3,135.56 106.3,135.4 U1.BL27 106.64,135.22 106.94,134.91 U1.BM26
+VCCRTC: length 24.4
  IN3 w0.508: 102.37,127.95 101.41,127.95 100.6,127.14 100.6,126.01 99.26,124.67 97.14,124.67 96.17,123.71 96.17,122.32 95.29,121.44 95.29,119.5 89.69,113.89 v1(89.69,111.1)
  BOTTOM w0.254: v2(108.73,133.31) 109.05,132.98 U1.BR23
  vias: v1(90.25,111.45)
+VCCSA:
  vias: v1(131.84,136.48) v1(135.29,136.34) v1(135.98,136.37) v1(139.88,136.04) v2(108.13,136.14) v2(108.15,137.08) v2(108.74,137.08) v2(108.66,136.44) v2(108.66,135.81) v2(116.41,137.41) v2(116.36,136.37) v2(116.99,137.41) v2(117.04,134.69) v2(118.53,136.38) v3(143.21,130.7) v3(143.97,130.7) v3(144.77,130.7) v3(145.54,130.7) v3(146.3,130.7) v3(149.32,130.68) v3(149.83,130.11) v3(150.33,129.49) v3(150.69,130.6) v3(151.01,129.91) v3(151.01,129.14) v3(151.25,131.92) v3(151.25,131.16) v3(152.02,131.92) v3(152.02,131.16) v3(152.78,131.92) v3(152.78,131.16)
+VCCST: length 115
  TOP w0.203: R14.1 132.28,157.22 v1(132.61,156.89) 132.61,156.63 R22.2 ; v1(131.58,160.06) 131.58,160.68 131.59,160.69 R11.1 131.59,161.6 130.84,162.35 129.98,162.35 R15.1 ; R19.1 127.11,158.97 v2(126.9,159.18) ; v1(129.97,163.5) 129.54,163.06 R12.1
  TOP w0.381: Q85.3 108.25,107.35 R822.2 110.51,106.97 v1(111.33,106.15)
  IN2 w0.254: v1(131.58,160.06) 131.58,161.23 130.81,162 130.81,162.66 v1(129.97,163.5) 128.21,161.73 128.21,160.95 126.9,159.65 v2(126.9,159.18) 128.12,157.96 129.44,157.96 v1(129.8,158.31)
  IN2 w0.508: v1(111.33,106.15) 111.55,105.94 111.55,105.18 112.37,104.36 117.19,104.36 118.59,105.76 119.96,105.76 v1(121.16,104.56)
  IN3 w0.381: v1(126.69,152.9) 126.95,152.9 127.71,152.14 127.71,151.49 128.5,150.7 128.5,142.84 129.77,141.57 129.77,139.55 v1(131.19,138.13) 131.19,136.42 131.26,136.35 131.26,134.82 133.42,132.66 v1(133.42,132.66)
  IN3 w0.508: v1(133.42,132.66) 133.42,131.4 133.56,131.26 133.56,130.63 132.9,129.96 132.9,127.71 132.63,127.45 132.63,123.72 131.72,122.81 131.72,119.77 130.42,118.48 130.42,116.05 129.38,115.01 129.38,113.43 129.89,112.93 130.99,112.93 131.63,112.28 131.63,111.76 129.96,110.09 126.78,110.09 121.25,104.56 v1(121.16,104.56)
  IN4 w0.381: v1(126.69,152.9) 126.69,157.1 126.33,157.47 126.33,158.89 126.62,159.18 v2(126.9,159.18)
  IN4 w0.508: v1(132.61,156.89) 132.61,159.48 132.03,160.06 v1(131.58,160.06)
  BOTTOM w0.178: v2(123.53,133.71) 123.47,133.66 U1.BP2
  BOTTOM w0.203: v1(126.69,152.9) 126.69,153.48 126.46,153.72 R10.1 ; R13.1 v2(126.9,159.18)
  BOTTOM w0.254: v2(116.29,133.98) 116.63,133.63 U1.BP11 ; R67.1 129.45,157.96 v1(129.8,158.31) ; v1(132.61,156.89) 132.61,156.45 132.31,156.15 R63.2 R65.1
  BOTTOM w0.305: v1(131.19,138.13) 131.19,138.4 130.67,138.91 R2229.2
  vias: v1(129.57,132.69)
+VCCSTG: length 5.6
  BOTTOM w0.203: U1.BG3 U1.BG2 U1.BG1 123.21,138.22 123.68,138.22
  BOTTOM w0.508: 127.01,138.27 125.03,138.27 124.98,138.22 123.68,138.22
  vias: v1(126.72,139.87)
+VDD_IO: length 14.6
  TOP w0.381: v1(59.31,98.07) 58.93,97.69 58.55,97.69 57.44,96.59 R67562.1
  IN4 w0.508: v1(59.31,98.07) 59.31,97.68 59.75,97.24 67.13,97.24 67.67,97.78 v1(67.67,98.45)
  BOTTOM w0.305: v1(59.31,98.07) 59.31,98.25 60.2,99.14 CN58.15
  vias: v1(67.02,98.57) v1(68.56,97.51)
+VDD_SIM: length 8.2
  TOP w0.114: v1(62.61,98.07) v1(61.84,98.84) 58.31,98.84 57.06,97.59 R67562.2
  BOTTOM w0.114: CN58.10 62.7,98.16 v1(62.61,98.07)
+VDDD_SUPPLY: length 30.6
  IN1 w0.508: v1(25.77,55.01) 25.76,55 24.14,55 22.82,53.68 v1(17.04,53.68)
  IN3 w0.381: v1(25.4,45.64) 25.33,45.57 22.29,45.57 21.9,45.96 18.34,45.96 v1(17.58,45.21)
  BOTTOM w0.254: v1(25.4,45.64) 25.52,45.64 R67478.2 ; R25580.1 17.51,54.15 v1(17.04,53.68) 17.33,53.39 R135.1
  BOTTOM w0.508: v1(17.04,53.68) 15.12,51.76 15.12,47.85 15.8,47.17 17.07,47.17 ; v1(25.77,55.01) 27.11,55.01 R197.2
+VDDQ: length 86.5
  TOP w0.508: v1(47.26,172.49) 46.51,172.49 v1(46.46,172.44) ; R67575.2 44.12,125.42 R67574.2 43.93,124.46 43.5,124.03 v1(43.28,124.03)
  IN2 w0.508: v1(72.17,179.8) 72.05,179.68 69.34,179.68 68.26,178.6 68.26,176.95 67.74,176.43 66.14,176.43 v1(65.33,177.24)
  IN4 w0.508: v1(47.26,172.49) 45.91,172.49 44.14,170.72 44.14,124.38 43.79,124.03 v1(43.28,124.03)
  BOTTOM w0.508: v1(72.17,179.8) 72.32,179.8 72.55,180.04 PR5014.2 ; v1(47.26,172.49) 47.26,174.77 47.92,175.44 64.63,175.44 65.33,176.14 v1(65.33,177.24)
+VDDQ_BOOT1: length 2
  TOP w0.508: 73.72,183.52 v1(73.69,183.49) ; 73.72,183.52 PR5004.1 ; 73.72,183.52 73.87,183.66 PC5011.1
+VDDQ_P: length 13.7
  TOP w0.203: PR5008.1 85.99,180.21 v3(86.54,180.21)
  TOP w0.508: v1(76.24,178.24) 75.94,178.54 PR5005.1
  IN2 w0.508: v3(86.54,180.21) 77.2,180.21 76.07,179.08 76.07,178.42 v1(76.24,178.24)
  vias: v1(89.21,179.6) v3(86.54,180.97) v3(87.3,180.97) v3(87.3,180.21) v3(88.07,180.97) v3(88.07,180.21) v3(88.83,180.97) v3(88.83,180.21) v3(89.59,180.97) v3(89.59,180.21)
+VDDQ_SR: length 2.6
  TOP w0.114: PC5018.1 76.62,186.98 v1(76.48,187.12)
  TOP w0.508: PR5007.2 76.58,186.09 PC5018.1
+VDDQ_VTT: length 89.9
  BOTTOM w1.524: 55.38,101.65 67.06,101.65 69.46,104.05 69.46,106.89 71.63,109.06 71.63,166.37 69.48,168.53 69.48,177.12
  vias: v1(45.93,104.67) v1(46.59,104.68) v1(54.47,105.03) v1(55.26,105.37) v1(55.93,105.81)
+VIN: length 21.3
  TOP w0.508: v1(142.24,133.87) 142.34,133.97 146.67,133.97 146.97,133.66 149.22,133.66 149.89,132.99 153.1,132.99 ; PR9102.1 153.4,168.25 152.96,168.68 149.79,168.68 149.03,167.92
  BOTTOM w0.508: v1(142.24,133.87) 141.94,133.56 141.94,133.13 140.24,131.43 PR79.1
  vias: v1(78.54,201.44) v1(79.3,201.44) v1(107.56,190.11) v1(107.78,189.48) v1(108.42,189.29) v1(108.7,189.89) v1(109.13,189.29) v1(109.41,189.89) v1(149.41,142.44) v1(150.8,122.51) v1(151.39,122.09) v1(151.6,122.73) v1(155.17,135.91) v1(155.83,135.91) v1(156.49,135.91) v1(157.15,135.91) v3(53.65,186.84) v3(53.65,186.08) v3(54.41,186.84) v3(54.41,186.08) v3(55.25,186.81) v3(55.25,186.03) v3(96.37,206.22) v3(96.37,205.46) v3(97.13,206.22) v3(97.13,205.46) v3(97.89,206.22) v3(97.89,205.46) v3(98.66,206.22) v3(98.66,205.46) v3(145.93,162.16) v3(146.69,162.16) v3(147.47,162.17) v3(148.23,162.17) v3(149.43,162.11) v3(150,122.18) v3(150.19,162.11) v3(151.59,120.76) v3(151.8,121.5) v3(152.09,122.21) v3(152.86,122.34) v3(158.09,156.79) v3(158.36,154.41) v3(158.39,153.64) v3(158.37,152.88) v3(158.37,152.12) v3(158.85,156.81) v3(165.08,150.77) v3(165.15,151.53) v3(165.92,151.53) v3(166.68,151.53) v3(171.35,127.91) v3(171.35,127.15) v3(171.35,126.39) v3(172.11,127.91) v3(172.11,127.15) v3(172.11,126.39) v3(172.82,127.46) v3(172.87,126.09) v3(173.18,126.79)
+VIN_BLIGHT:
  vias: v1(76.76,192.3)
AVDD2: length 9
  BOTTOM w0.203: U20.40 18.61,36.14 18.32,36.44 18.32,37.45 17.95,37.81 17.77,37.81
  BOTTOM w0.508: L28.2 12.83,35.65 14.06,36.87 C845.1 14.06,37.37 14.5,37.81 15.7,37.81 v1(15.7,37.82) 15.7,37.81 17.77,37.81
DVDD_IO: length 11.7
  BOTTOM w0.203: U20.9 23.63,31.41 24.13,30.91 24.82,30.91 v1(25.17,30.55) 25.4,30.55 25.76,30.91 26.63,30.91 26.64,30.91 27.52,30.91 27.53,30.91 27.72,30.91 C585.1 28.29,30.38 28.75,29.92 28.75,28.82 C584.1 29.29,28.77 30.1,28.77 30.34,28.53 R460.2 30.61,28.9 31.31,29.6 R462.1
GND: length 1736.6
  TOP w0.079: U6516.C3 154.86,214.4 v1(156.16,214.4)
  TOP w0.114: R183.1 129.27,114.11 129.27,114.96 126.6,117.62 v1(126.6,117.83) 126.6,118.26 125.31,119.56 124.48,119.56 124.15,119.89 124.15,120.33 v2(123.92,120.57) 123.41,120.06 123.09,120.06 122.14,121.01 122.14,122 122.37,122.23 R148.1 ; C255.2 47.17,103.08 ; C6626.2 v2(102.61,110.5) ; C204.1 124.54,121.72 124.54,121.1 125.07,120.57 125.75,120.57 126.39,119.93 126.39,119.4 127.72,118.07 v1(127.72,117.69) 127.72,117.34 129.08,115.98 129.71,115.98 130.61,115.08 130.61,114.22 v2(130.3,113.91)
  TOP w0.152: U37.91 v1(168.18,107.54)
  TOP w0.178: v1(17.78,75.33) 17.27,74.82 17.27,74.56 17.39,74.43 17.39,73.28 C20065.1 ; v1(28.5,122.79) 28.67,122.95 28.67,123.27 28.53,123.41 U30.43 ; v1(24.32,121.7) 24.32,121.73 24.62,122.04 U30.35 ; U30.26 20.53,124.21 v1(20.43,124.1) ; U30.38 25.82,122.04 25.54,121.76 v1(25.54,121.56)
  TOP w0.203: v1(123.55,117.87) 123.12,117.87 123.09,117.9 C224.1 ; PR7034.2 v1(157.07,147.87) ; v1(163.52,134.91) 163.11,135.32 PR7038.2 ; v2(119.84,142.13) 119.84,141.98 119.31,141.45 C36.1 ; PC7029.1 171.3,145.91 v2(171.07,145.67) ; v1(150.04,109.01) 150.04,109.22 150.36,109.54 U37.1 ; C6.2 107.69,133.21 107.75,133.27 v2(107.75,133.31) ; R147.2 115.52,122.88 v2(115.52,124.02) ; v2(103.56,137.49) 103.08,137.97 C95.1 ; U37.27 v1(152.64,99.14) ; v2(125.96,116.05) 125.96,116.2 125.76,116.4 C227.1 125.25,117.01 124.84,117.42 C6613.1 ; v2(121.39,143.33) 121.09,143.63 C37.1 ; R183.1 130.17,113.79 v2(130.3,113.91) ; v2(128.58,159.21) 128.93,159.21 R24.1 ; v2(114.07,120.46) 114.07,120.43 114.44,120.06 C237.2 ; v2(118.36,143.88) 118.37,143.89 C17.1 ; v2(102.74,133.85) 103.18,133.42 R16.2 ; v2(115.09,119.76) 115.09,119.86 114.81,120.14 114.81,120.54 R125.1 ; PC7006.2 v2(170.33,139.97) ; v2(116.67,120.63) 116.88,120.85 R25433.2 ; C18.1 118.14,139.85 v2(118.52,140.22) ; v2(123.35,122.77) 123.81,123.24 C219.1 ; v1(147.7,98.22) 147.96,98.48 C6577.2 C6578.2 ; C24.1 107.55,141.17 v2(108.03,140.69) 107.38,140.03 C47.2 ; U37.104 162.56,109.75 162.06,109.24 v1(162.06,108.43) ; v1(168.69,136.19) 169.04,136.53 PR7040.2 ; v2(102.98,152.13) 102.9,152.21 C76.1 ; C87.1 101.99,142.26 v2(101.89,142.17) ; R74.2 105.38,134.5 v2(105.38,134.77) ; v1(168.48,98.68) 168.48,98.47 168.88,98.07 PC20.1 ; R17.1 130.43,155.02 130.57,155.16 R25.1 131.19,155.49 v1(131.61,155.49) ; R138.2 122.5,125.54 v2(122.5,124.94) ; U67.24 27.35,151.28 v1(27.15,151.08) ; PR7041.1 v1(166.06,134.51) ; R25316.2 164.8,113.84 R25303.2 165.56,113.84 v1(165.73,113.67) ; U37.49 159.36,96.55 v1(159.21,96.69) ; R25527.2 v1(32.08,157.59) ; R44.1 106.59,131.62 v2(106.22,131.99) ; C16.1 119.7,142.9 v2(119.81,143.01) ; C222.1 125.88,122.55 v2(125.88,122.91) ; v2(123.37,122.15) 122.79,122.15 R148.1 ; v2(117.94,120.45) 118.24,120.16 R25481.2 ; C25.1 120.7,144.63 v2(120.75,144.67) ; C78.1 108.44,148.48 v2(108.03,148.89)
  TOP w0.254: v1(63.48,145.38) 64.1,144.76 C20127.2 ; C5.2 90.12,108.19 v1(90.12,108.86) ; C124.2 43.5,141.91 v1(43.34,141.91) ; v1(13.77,129.16) 13.94,128.99 14.63,128.99 D13087.1 ; C232.1 125.7,128.46 v2(125.86,128.3) ; v1(139.96,211.7) 139.71,211.95 U6525.2 ; D13086.1 14.27,120.03 v1(14.39,119.92) ; C20107.2 58.67,139.24 v1(58.8,139.11) ; v1(146.5,210) 146.5,210.19 C841.2 ; R25568.1 24.97,67.97 v1(25.03,67.91) ; v1(170.56,97.59) 170.49,97.66 R25311.2 ; PR8044.2 22.33,115.11 v1(21.9,114.68) ; v1(33.67,116.18) 33.96,116.18 34.59,115.55 PR8057.2 ; C272.2 58.53,141.9 58.53,142.77 v1(58.6,142.83) ; v1(12.58,66.83) RV3.3 10.36,66.83 v1(10.2,67) ; v2(133.26,188.64) 133.26,188.08 C449.1 ; v1(189.69,114.2) 189.69,114.48 189.05,115.13 U35.3 ; v1(170.56,96.36) 170.56,96.21 170.3,95.95 C6570.2 ; v2(100.18,109.97) 100.18,109.75 100.45,109.48 R146.1 ; C20124.2 50.43,135.93 v1(50.47,135.89) ; R88.1 92.85,110.58 92.45,110.19 C236.1 ; v1(13.32,131.52) D13089.1 ; v1(58.77,131.09) 58.65,131.21 C20126.2 ; C2335.1 90.63,105.33 v1(90.17,104.87) ; U42.13 v1(229.42,112.49) ; v1(62.4,158.7) 62.41,158.7 63.05,158.7 C88.1 ; v2(92.54,154.97) 92.54,155.09 92.11,155.52 C131.1 ; C1190.2 v1(148.36,105.18) ; C84.1 132.26,127.46 v2(132.26,128.04) 132.4,128.04 C85.1 ; PR8042.2 25.96,113.73 v1(25.96,113.19) ; R67555.2 58.34,92.1 v1(58.66,91.78) ; v1(54.69,146.15) 54.77,146.07 54.77,145.58 54.86,145.49 C20103.2 ; v1(79.91,121.94) 80.28,121.94 C246.1 ; C842.2 150.97,212.95 v1(151.48,213.46) ; R137.2 121.47,124.11 v2(121.43,124.08) 121.39,124.04 120.87,124.04 C6612.1 ; R122.1 89.76,117.2 89.29,116.72 v1(89.29,116.43) ; v1(66.17,155.81) 66.13,155.77 C133.1 ; D13085.1 13.76,121.92 v1(13.57,122.11) ; C2374.2 v1(147.91,101.57) ; C127.2 61.96,125.05 v1(61.95,125.04) ; v1(96.8,192.75) 96.8,192.79 96.95,192.94 97.59,192.94 PC9029.2 ; R499.1 v1(234.12,114.27) ; C20123.2 66.98,128.95 v1(66.9,129.03) ; U33.16 85.94,100.85 85.7,101.09 85.19,101.09 85.15,101.05 v1(84.48,101.05) ; v2(104.46,199.43) 104.17,199.43 PC9000.2 ; C96344.2 194.12,122.99 v1(193.75,123.36) ; v1(14.03,125.59) 14.09,125.54 D13083.1 ; v1(50.55,142.15) 50.55,142.74 C277.2 ; C132.1 91.76,148.45 92.25,147.96 v2(92.25,147.76) ; v1(15.61,74.01) 15.61,73.23 C20062.2 ; PR8059.2 27.43,108.33 v1(27.64,108.54) ; R25320.2 155.94,113.62 v1(155.94,114.4) ; U23.17 21.42,138.98 21.29,138.85 20.59,138.85 20.25,139.19 19.55,139.19 19.09,139.65 v1(19.09,139.75) ; v2(91.39,152.08) 91.35,152.11 C130.1 ; v1(31.4,118.36) 31.27,118.23 PR8043.2 ; U6515.4 143.3,213.32 143.94,212.67 144.12,212.67 v1(144.74,212.05) ; v1(45.98,145.52) 45.9,145.43 C249.1 ; v1(78.47,101.43) 78.75,101.43 J9007.2 ; U36.3 186.51,115.16 187.14,114.53 v1(187.14,114.2) ; v1(154.58,113.79) 154.52,113.79 C6574.2 ; PC581.2 38.38,138.67 v1(38.11,138.4) ; v1(129.6,98.02) 129.6,97.97 129.06,97.42 C697.2 ; R1235.1 v1(225.43,114.8) ; v1(55.29,159.85) 55.75,159.38 C20104.2 ; C20118.2 55.17,152.56 v1(55.29,152.45) ; C6610.1 149.47,103.28 v1(149.81,103.63) ; v1(57.93,136.17) 57.66,135.9 C20129.2 ; C129.2 65.23,150.78 v1(66.19,150.78) ; R497.1 v1(234.12,115.08) ; v1(87.2,107) C2337.2 86.41,106.44 86.2,106.24 U2015.3 ; C279.2 43.6,149.07 v1(43.34,149.32) ; v1(55.29,161.88) 55.32,161.91 C75.1 ; v1(27.15,151.08) 26.98,150.91 C20022.1 ; U42.3 229.42,118.54 v1(229.62,118.74) ; v1(146,103.18) 146.37,103.54 C6571.2 146.37,103.85 145.61,104.6 C6562.1 ; R1234.1 v1(234.12,116.35) ; v1(67.53,136.42) 67.53,135.71 C128.2 ; C91.1 47.35,150.64 v1(47.35,151.1) ; R414.1 26.03,100.44 v1(26.22,100.63) ; PC9026.2 PC9023.2 ; v1(66.18,161.25) 65.72,161.71 C20121.2 ; v1(66.93,120.95) 66.93,121.06 66.56,121.43 C20110.2 ; v1(67.54,91.74) 68.89,93.09 R67569.2 ; v2(123.37,122.15) 123.95,122.15 C204.1 ; PC6056.2 35.37,160.05 35.01,160.41 ; 35.01,160.41 v1(35.01,161.49) ; 35.01,160.41 34.64,160.03 PC6057.2 ; EC13.2 186.99,108.98 187.28,109.27 v1(187.47,109.27) ; v1(86.9,108.73) 86.9,108.43 C2336.2 ; U42.18 v1(232.85,115.72) ; v1(43.3,145.48) 43.36,145.42 C270.2 ; v1(77.3,95.84) 76.81,95.34 C212.2 ; v1(169.07,112.51) 168.4,112.51 C6580.1 ; R25566.1 17.83,76.58 v1(18.14,76.88) ; v1(114.91,187.07) 114.6,187.38 R394.2 ; R890.2 148.5,95.78 v1(148.29,95.98) ; PC8011.2 33,113.36 v1(32.98,113.38) ; C443.1 134.17,189.86 v2(133.88,189.57) ; v1(63.64,103.66) 64.01,103.66 C20106.1 C20109.1 v1(65.63,103.92) ; v2(130.94,186.07) 131.44,186.56 C455.1 ; PR8056.2 v1(23.86,111.78) ; R504.1 v1(225.43,115.74) ; C20125.2 63.58,136.83 v1(63.55,136.8) ; v1(82.38,98.22) 82.38,97.69 C741.2 C744.2 ; v2(131.85,188.26) 131.85,188.47 C380.1 ; C262.2 46.72,169.25 v1(47.09,169.62) ; v1(66.11,110.28) 66.11,110.85 C20113.2 ; R506.1 v1(225.43,117.67) ; U6515.8 142.8,217 v1(143.01,217.21) ; C1189.2 149.48,106.78 149.87,107.17 v1(149.87,107.77) ; v1(82.11,105.69) 82.54,105.69 C1211.2 ; v1(209.38,97.94) 209.02,97.58 C6615.1 ; v1(48.71,145) 48.98,145.27 C90.1 ; v1(54.63,126.73) 54.35,127 C256.2 ; v1(43.24,143.45) 43.32,143.37 C263.2 ; U14.14 21.21,96.72 21.97,97.48 v1(22.51,97.48) ; v1(20.73,107.36) 20.63,107.26 U6531.3 17.83,107.26 17.61,107.48 v1(17.28,107.48) ; PR8040.1 22.79,117.46 v1(22.68,117.35) 22.88,117.15 PC8005.2 ; PR8008.2 54.33,196.98 54.93,197.59 v1(54.98,197.59) ; R25563.1 v1(13.79,71.06) ; v1(14.22,127.83) 14.29,127.75 D13088.1 ; v1(152.36,111) 151.85,111 C6563.2 ; v1(55.31,169.32) 55.19,169.2 C20116.2 ; C613.2 14.43,129.8 14.35,129.73 D13090.1 13.3,129.73 v1(13.08,129.51) ; v1(170.93,148.21) 170.82,148.1 PC7001.2 ; C6575.2 v1(160.12,113.08) ; PR8064.2 v1(19.36,110.23) ; C6614.1 118.09,116.61 v2(118.08,116.61) ; C6573.2 152.19,112.59 v1(152.35,112.75) ; v1(142.21,217.21) 142.3,217.12 U6515.9 ; v1(43.35,138.76) 43.56,138.97 C252.2 ; C274.2 46.53,159.2 v1(47.04,159.71) ; R1236.1 v1(225.43,116.68) ; C698.2 128.42,98.46 v1(128.01,98.04) 127.86,98.19 127.86,98.36 C699.2 ; EC11.2 27.33,67.78 v1(27.49,67.63) ; v1(80.99,103.6) 80.96,103.57 C1217.2 80.32,104.07 Q6520.1 ; D13084.1 14.63,124.4 v1(14.2,124.4) ; R25564.1 v1(20.12,76.86) ; v1(62.21,140.61) 62.25,140.65 62.25,141.41 C20122.2 ; D13100.3 v1(19.41,103.7) ; PC5.2 v1(68.91,203.2)
  TOP w0.305: v1(84.66,130.54) 85.17,131.06 86.44,131.06 86.72,131.34 C213.1 ; C696.2 133.31,97.71 v1(133.07,97.95) ; v1(16.61,91.52) 16.7,91.62 U6530.3 18.85,91.62 v1(19.05,91.41) 19.43,91.79 C521.2 ; C96333.1 120.17,122.32 v2(120.4,122.55) ; C153.1 130.2,164.55 129.65,164.01 v1(129.39,164.01) ; PC8002.2 14.87,196.62 v1(15.29,196.62) ; C559.1 70.55,194.06 v1(69.66,194.06) ; R25270.2 67.88,190.36 68.41,189.84 v1(68.41,189.58) ; v2(137.6,198.53) 136.72,198.53 C366.2 ; D13089.1 14.92,131.52 C614.2 ; v2(131.02,196.65) 131.48,197.11 C428.1 ; R229.2 45.16,105.31 46.26,105.31 46.59,105.65 v1(46.59,105.93) ; R56.1 84.77,101.34 v1(84.48,101.05) ; v2(122.61,198.52) 123.33,199.24 C429.1 ; C351.1 129.25,194.93 v2(128.97,194.65) ; v1(15.28,197.31) 14.66,197.93 PC8001.2 ; v1(19.1,93.54) 19.67,92.98 C522.2
  TOP w0.356: v2(128.97,196.6) 128.27,197.3 C402.2 127.82,197.75 127.54,198.03 C395.2 ; C353.1 134.58,191.9 v2(134.31,191.64) ; v2(152.12,194.84) 151.7,194.42 C475.2 ; C495.1 156.27,197.89 156.73,197.89 v2(156.9,198.06) ; C483.1 153.52,175.75 v2(153.69,175.58) ; v2(131.85,193.67) 132.11,193.93 C418.1 132.49,193.96 C374.1 ; C408.1 127.53,195.28 v2(127.91,195.66) ; v2(134.31,193.65) 134.03,193.93 C357.1 ; C373.1 127.5,191.38 v2(127.89,191.77) ; v2(160.9,179.62) 161.48,179.62 C501.2 ; v2(126.72,190.65) 126.99,190.38 C406.1 ; C460.1 125.93,191.74 v2(125.93,191.03) ; v1(161.7,191) Q20.1 ; C409.1 126.91,194.35 v2(126.91,194.55) ; C459.1 125.85,192.88 v1(125.85,193.38) ; C411.1 130.51,193.93 v2(130.12,193.54) 129.72,193.93 C430.1 ; C369.1 131.48,190.44 v2(131.06,190.85) ; v2(134.98,193.7) 135.41,193.27 C444.1 ; v2(129.06,190.71) 129.57,191.22 C365.1 ; C496.1 156.79,176.53 v2(156.9,176.42) ; C410.1 133.38,197.03 v2(132.89,196.54) ; C493.1 159.1,206.62 v2(158.5,206.02) ; C407.1 128.54,190.17 v2(128.07,189.7) ; C352.1 133.75,194.93 134.29,195.47 v2(134.29,195.63) ; v2(165.7,183.62) 165.76,183.56 C491.1 ; C412.1 132.11,191.38 v2(131.85,191.64) ; C439.1 135.38,194.2 v2(134.9,194.69) 135.38,195.17 C448.1 ; C367.1 133.55,191.38 v2(133.01,190.84) ; v2(133.88,196.72) 134.01,196.72 134.37,196.36 C445.1 ; v2(131.27,194.66) 131,194.93 C424.1 ; v2(159.3,205.22) 159.93,204.59 C481.1 ; v2(132.01,189.37) 132.48,189.83 C372.1 ; v2(164.9,175.62) 165.06,175.78 C478.1 ; v2(156.9,202.03) 157.26,202.03 C480.1 ; v2(160.9,198.88) 160.42,198.88 C482.1 ; C421.1 130.5,191.38 v2(130.12,191.76)
  TOP w0.381: R761.1 31.08,130.58 v1(30.7,130.2) 30.31,129.81 C808.1 ; v1(46,127.86) 45.91,127.77 C265.2 ; v2(119.58,166.29) 119.35,166.06 PC7087.1 ; PQ9050.1 37.45,120.89 v1(36.48,119.91) ; v2(125.63,189.73) 125.46,189.73 125.01,189.28 C398.2 ; v2(116.56,124.03) 116.95,124.03 C2.1 117.16,123.74 117.94,122.96 C1.1 ; v1(22.51,97.48) 22.82,97.17 R415.1 ; v1(78.92,100.45) 78.87,100.5 C1214.2 ; v2(132.01,189.37) 132.4,188.98 C450.1 ; C477.1 153.69,194.84 v2(153.7,194.82) ; v1(33.8,126.22) 33.24,126.77 R755.1 ; C218.1 84.28,130.93 v1(84.66,130.54) ; Q22.1 75.75,101.92 v1(75.75,100.88) ; v1(55.38,193.11) 56.05,192.44 PR8029.2 ; C267.2 46.03,115.51 v1(45.91,115.39) ; C20000.2 26.41,166.68 v1(27.01,167.28) ; v2(102.01,134.76) 102.3,135.05 R30.2 ; C241.1 112.83,118.79 v2(113.31,118.79) ; Q6509.1 140.23,98.55 v1(140.23,99.23) ; C83.1 107.27,146.16 108.01,146.16 v2(108.02,146.15) 108.62,146.15 C82.1 ; v2(157.7,206.02) 157.7,205.31 R317.2 ; C399.2 145.09,208.56 v1(145.19,208.66) ; v1(46.61,125.78) 46.34,126.05 R243.2 ; v1(137.2,213.2) 137.43,213.43 C20137.2 ; C6568.1 167.06,96.19 v1(166.68,95.81) ; PC8006.2 17.83,117.23 v1(18.34,117.73) ; v1(18.46,17.88) 18.87,18.28 R470.1 ; v2(101.9,139.63) 102.13,139.86 C77.1 ; PR8030.1 83.07,190.7 82.69,190.32 v1(82.62,190.32) ; v1(91.95,111.58) 92.31,111.58 92.85,111.04 R88.1 ; v2(119.54,168.1) 119.44,168.2 C140.1 ; R25378.1 108.14,114.26 v1(107.1,113.22) ; PC9056.2 96.89,186.9 96.31,187.48 v1(95.85,187.48) ; C508.2 22.81,100.75 v1(22.84,100.72) ; PQ19.1 19.08,144.97 v1(18.27,144.15) ; R124.1 86.56,121.3 v1(85.85,121.3) ; v2(156.9,179.62) 157.09,179.81 C479.1 ; R589.2 17.59,17.09 v1(17.95,17.45) ; v1(46,131.54) 45.84,131.38 C254.2 ; C453.1 135.27,187.84 134.73,188.38 134.73,188.62 C447.1 134.51,188.94 v2(133.88,189.57) ; C913.1 20.1,130.96 v1(19.77,131.29) ; v1(54.13,121.73) 54.85,121.01 R25614.1 ; R25534.2 34.47,145.43 v1(34.11,145.07) ; C20059.2 v1(13.81,64.71) ; v1(142.06,211.91) 141.69,211.54 C20136.2 ; v1(169.99,104.76) 169.99,104.48 169.66,104.15 C1208.1 ; R244.1 45.93,119.13 v1(45.93,118.32) ; v1(36.48,152.65) 36.09,152.26 C20020.1 ; R398.1 123.82,187.54 123.52,187.25 v2(123.52,186.06) ; C20120.2 55.76,114.49 v1(55.28,114.01) ; C454.1 136.78,191.91 v2(137.6,192.73) ; C471.2 167.11,191.49 v1(167.3,191.3) ; v1(34.16,144.11) 34.66,144.11 PC571.2 ; v2(155.31,206) 155.99,206 C492.1 ; U6509.12 v1(218.9,98.83) ; PQ8015.1 30.56,118.36 v1(31.4,118.36) ; R25379.1 109.59,111.9 v1(109.6,111.89) 109.18,111.89 R825.1 ; C20003.1 v1(14.38,160.17) ; D13095.2 10.35,13.79 v1(9.83,13.79) ; C371.2 125.76,188.68 v2(125.76,189.1) ; v2(124.23,195.22) 124.72,195.71 C432.1 ; v1(140.02,210.69) 140.18,210.53 R25624.1 ; v2(154.52,179.64) 154.47,179.69 C502.2 ; v1(84.37,188.09) 84.37,187.89 83.8,187.32 PR8023.1 ; C533.2 v1(20.74,108.51) ; v1(43.24,134.64) 43.59,135 EC5.1 ; C354.2 143.72,209.66 v1(144.12,210.07) ; v1(22.97,90.63) 22.87,90.74 22.33,90.74 C518.1 ; PQ8005.1 38.1,98.82 v1(38.3,99.01) 38.3,99.22 38.49,99.42 PR8017.1 ; C157.1 117.72,166.44 v2(117.33,166.06) ; C498.1 164.72,202.14 164.1,202.76 v2(164.1,202.82) ; v1(14.79,162) 14.58,162 13.9,161.31 C20006.1 ; PR8000.1 30.22,102.37 v1(30.22,102.05) ; PC9060.2 90.32,183.16 90.02,183.46 v1(90.02,183.93) 90.25,184.17 PC9059.2 ; PQ8005.4 35.67,100.28 v1(36.14,100.75) 36.61,101.22 PR8009.2 ; v2(129.18,197.76) 129.47,198.05 C419.2 ; C425.1 125.25,196.9 v1(125.25,196.39) 125.68,196.39 125.85,196.22 C415.1 ; C740.2 91.2,103.34 v1(90.88,103.02) ; C231.1 128.13,126.3 v1(128.22,126.39) 128.22,126.43 128.73,126.95 PC236.1 ; v1(35.86,144.96) 36,144.83 PC572.2 ; v1(114.82,181.52) 114.22,181.52 C376.2 ; v1(89.29,116.43) 89.27,116.41 R25431.2 ; PC8007.2 25.21,119.1 v1(25.51,119.4) ; C526.1 24.86,106.6 v1(25.28,106.6) ; PC8009.2 v1(32.67,109.76) 32.64,109.73 PR8055.2 ; C523.1 24.6,105.04 23.96,104.4 v1(23.57,104.4) ; R157.1 86.34,123.37 v1(86.66,123.05) 87.15,123.05 R90.1 ; R46.2 82.73,126.04 v1(82.74,126.05) C8.2 ; v2(107.75,133.31) 107.95,133.51 107.95,133.79 R29.1 108.14,134.46 R28.2 ; R84.1 87.68,130.2 87.67,130.19 v1(87.12,130.19) 86.75,130.19 R25501.2 86.02,130 85.89,129.88 85.7,129.88 C96350.2 ; v1(35.87,97.08) 35.73,96.94 PR8016.2 ; PC9027.2 101.85,191.72 101.34,191.22 v1(101.13,191.22) ; Q16.1 110.7,188.35 v1(110.24,187.88) 110.19,187.84 110.19,187.58 109.87,187.26 Q14.1 ; C20008.1 14.33,159.03 v1(14.46,158.9) ; R158.1 119.42,120.99 v2(119.86,120.54) ; v1(171.81,102.64) 172.17,102.28 L11.2 ; v2(122.61,195.22) 122.61,195.3 124.23,196.92 C431.1 ; R409.1 v1(79.18,105.64) ; C271.2 C269.2 v1(52.02,102.72) ; v1(200.65,128.38) 200.28,128.02 PC6026.2 ; R25403.2 v2(103.54,112.9) ; v1(138.88,156.78) 139.07,156.96 PR7045.2 ; v1(43.35,107.39) 43.53,107.21 R228.2 ; v1(156.95,217.05) 157.55,217.05 R25648.2 ; v1(142.8,133.3) 142.97,133.13 PR7061.2 ; C506.2 v1(157.75,193.16) R25282.1 ; R59.1 87.29,113.8 v1(86.92,114.17) ; PR8028.2 50.31,192.41 v1(50.02,192.71) ; v1(24.45,74.32) 24.39,74.26 23.8,74.26 R2660.2 ; C458.1 124.99,190.7 v2(125.32,191.03) ; C1210.2 170.82,102.99 v1(171.1,103.28) ; v1(87.63,108.76) 88.21,108.19 U2014.3 ; C485.2 165.46,201.15 v1(165.46,201.59) ; PR567.1 v1(37.13,144.83) ; v1(22,21.2) 21.56,20.76 R465.2 ; v1(16.62,88.45) D13099.3 ; C164.1 117.96,147.05 v2(118.36,146.65) ; R25600.2 59.27,103.53 v1(59.43,103.69) ; C631.2 v1(27.05,168.06) ; v2(117.09,150.32) 117.47,149.94 C163.1 ; v1(152.71,209.36) 151.83,209.36 D13092.1 ; v1(43.3,133.88) 43.41,133.88 43.75,134.22 C268.2 ; v1(119.7,147.58) 119.69,147.59 C162.1 ; C260.2 54.94,109.99 v1(54.93,109.98) ; R230.2 v1(46.24,129.87) ; v2(135.07,197.6) 134.57,198.11 C362.2 ; C20063.2 13.74,66.81 v1(13.24,66.81) ; R25298.1 144.89,96.34 145.32,95.91 v1(145.32,95.51) ; C81.1 106.65,149.29 v2(106.17,149.29) ; PC9064.2 90.66,185.13 v1(90.03,185.13) ; v1(46.94,129.36) 46.94,129.29 C264.2 ; v1(26.78,120.06) 27.31,119.53 C880.2 ; C3.1 v1(76.7,128.75) ; EC1.1 82.1,127.01 v1(82.75,127.01) 83.33,127.01 R45.2 ; C240.1 C239.1 89.03,109.94 88.78,110.19 v1(88.78,110.52) ; v1(58.6,194.95) 58.55,195 PR8027.2 ; PR8039.2 17.63,118.99 R779.1 ; v1(132.37,97.95) 132.37,98.38 132.82,98.83 C695.2 ; R25375.1 79.91,121.35 v1(79.91,121.94) ; v2(92.59,139.94) 92.59,139.74 92.19,139.34 91.69,139.34 C117.2 ; v2(113.73,115.91) 113.48,115.67 C243.1 ; v2(121.38,126.31) 121.32,126.37 R136.2 ; C494.1 156.9,181.22 v2(156.9,181.22) ; v1(125.85,193.38) 126.14,193.67 C368.1 ; C484.2 164.16,198.89 v2(164.1,198.82) ; v1(54.3,118.52) 54.31,118.53 EC6.1 ; C513.1 22.25,89.3 21.96,89.01 v1(21.63,89.01) ; R25386.1 v1(88.83,115.19) 88.83,115.18 R209.2 ; PR211.1 163.46,120.52 162.62,119.69 v1(161.87,119.69) ; R770.1 v1(32.25,128.42) ; v1(87.68,111.66) 87.29,112.04 R25394.1 ; C532.2 v1(20.73,107.36) ; R757.1 22.28,119.42 v1(22.41,119.42) 22.78,119.79 R844.1 ; C2321.1 85.01,110.15 v2(85.44,110.58) ; C20010.1 35.52,148.09 34.9,147.47 v1(34.73,147.47) 34.5,147.7 C20023.1 ; C20140.1 154.37,209.38 v1(154.7,209.38) 154.95,209.38 C20141.2 ; R677.2 v1(189.69,114.2) ; v1(129.39,164.01) 129.07,163.69 PR7052.2 ; ESD4.3 v1(9.6,159.53)
  TOP w0.406: C216.1 79.45,134.03 v1(79.17,133.75) ; v1(83.29,133.75) 83.52,133.98 84.57,133.98 85.06,134.47 C217.1 C214.1
  TOP w0.457: C161.2 121.04,164.59 v2(120.26,164.59) ; C441.1 165.7,194.82 v2(165.7,194.82) ; C500.2 163.23,206.1 v2(163.3,206.02) ; v2(162.5,194.82) 162.5,194.82 C442.1
  TOP w0.508: C1691.2 v1(28.82,146.26) ; v1(29.11,172.63) 29.39,172.92 C20131.1 ; PC6007.1 175.91,129.89 PR6007.2 175.91,130.53 v1(176.01,130.63) 176.16,130.78 PC6023.2 ; C20041.2 224.5,98.07 v1(224.89,97.68) ; v1(26.62,104.41) 26.44,104.24 PR8031.2 PR8022.2 ; v1(31.34,129.88) 31.63,130.17 C912.1 ; R4009.2 26.49,171.74 v1(27.24,170.99) ; v1(115.58,190.03) 115.07,190.55 C394.2 C401.2 ; U19.2 76.52,194.97 v1(76.85,194.64) ; PC5009.2 73.12,186.17 72.55,186.17 v1(72.44,186.28) 72.09,186.64 C550.2 ; D33.1 195.47,98.02 v1(194.29,96.84) ; v1(133.54,128.6) 132.9,128.6 C57.2 ; R845.1 29.93,119.36 v1(29.74,119.56) 29.73,119.55 R773.2 ; C20043.2 v1(209.38,97.94) ; v1(136.89,217.21) 136.89,216.54 C20134.2 ; v1(3.01,13.92) 3.01,14.65 D10.2 ; EC16.1 208.5,99.47 v1(208.17,99.79) ; C456.2 115.72,192.99 v1(116.12,192.99) ; C1690.2 v1(28.87,144.32) ; C461.2 C457.1 v1(115.76,196.3) ; R759.1 v1(19.27,119.64) ; v1(159.25,209.82) 158.95,209.82 PR9105.2 ; HE1.3 148.86,211.16 v1(149.09,210.93) ; PC8008.1 35.35,113.04 34.9,112.59 PU8001.2 34.9,111.4 35.44,110.86 v1(35.67,110.86) ; D13096.2 12.08,70.62 v1(11.83,70.87) ; R765.1 v1(32.02,120.66) ; R4008.2 12.59,167.24 v1(13.18,167.83) 13.27,167.92 C642.2 ; CN62.4 33.8,41.38 v1(33.42,41.38) ; C645.2 39.04,178.07 v1(38.87,177.89) ; PQ14.1 131.18,115.02 v1(131.83,114.37) ; v1(73.97,181.15) 74.49,180.62 PC5012.2 ; v1(29.21,171.91) 28.8,171.91 28.49,171.6 C639.1 ; v1(161.64,167.41) 161.64,167.41 PQ9085.1 ; C641.2 18.91,172.71 v1(19.23,172.39) ; v1(92.64,195.08) 93.47,194.25 PC9004.2 94.45,194.28 95.94,194.28 PC9023.2 ; C392.2 v1(164.26,207.98) ; Q6508.2 14.98,135.13 v1(14.73,134.88) ; R678.2 185.47,120.42 v1(185.23,120.65) ; v1(16.64,159.23) 16.18,159.69 C96305.2 ; v1(24.89,64.49) 24.24,64.49 C20064.2 ; v1(14.38,160.17) 14.61,160.17 14.87,159.91 C96304.2 ; CN62.7 34.24,49.68 33.57,49.01 v1(33.52,49.01) ; C20051.2 v1(214.17,102.89) ; v1(8.08,11.81) 7.76,12.13 R67362.2 ; v1(140.41,217.2) 139.92,217.2 C20133.2 ; Y4.4 30.75,168.21 v1(29.92,167.37) ; R676.2 v1(188.01,120.29) ; v1(37.59,177.88) 37.01,178.46 C96313.2 ; HOLE23.1 10.14,2.5 ; HOLE23.1 7.7,4.88 ; HOLE23.1 5.15,2.5 ; v1(225.37,95.68) 225.88,95.68 226.42,95.14 C20053.2 ; PQ9083.1 v1(160.96,209.17) ; C20135.2 v1(134.2,213.13) ; R588.2 23.33,24.59 v1(23.76,24.16) ; v1(206.19,99.79) 205.79,99.4 EC17.2 ; v1(13.7,13.11) 13.21,13.6 C588.2 ; C96301.2 v1(23.52,174.23) ; C6616.1 66.17,185.64 v1(66.17,185.11) 66.96,185.11 67.49,185.65 C20002.1 ; v1(141.74,128.23) 141.21,128.23 v1(141.04,128.41) 140.4,129.05 PC83.1 ; PC8010.2 30.03,111.29 29.96,111.36 v1(28.78,111.36) ; v1(157.33,168.55) 156.83,169.06 PQ9084.1 ; PR8039.2 v1(16.75,118.98) ; v1(23.38,22.84) 22.42,22.84 C586.2 ; C619.2 24.59,136.49 v1(25.09,135.99) 25.58,136.48 C1692.2 ; R507.2 v1(23.71,147.43) ; PC9054.2 90.7,180.16 v1(91.29,179.56) ; PR9101.2 160.06,166.71 159.79,166.44 PQ9086.1 159.23,166.6 v1(158.73,167.1) ; R749.2 v1(19.53,146.7) ; PC6042.2 31.8,161.25 v1(31.4,161.65) ; v1(157.7,140.31) 157.7,139.47 PC7000.1 ; C20048.2 v1(220,103.28) ; C20001.1 65.46,185.37 v1(65.33,185.24) ; C96303.1 23.52,171.71 v1(23.67,171.56) ; C20046.2 C20047.1 v1(209.4,98.96) ; v1(17.22,100.85) 17.22,100.91 17.66,101.35 R416.2 ; C735.1 v1(212.05,101.11) ; C20039.2 v1(224.79,92.99) ; PR9098.2 v1(170.84,153.75) ; R763.1 31.3,133.24 v1(31.8,132.74) R832.1 ; C282.2 v1(13.03,62.64) ; PR230.2 56.26,205.42 v1(55.52,205.42) ; C20022.1 25.99,150.28 C20021.1 v1(25.08,150.31) ; C20040.2 v1(209.22,95.71) ; PC234.2 142.73,128.71 v1(142.73,128.2) ; PR9104.2 155.28,171.08 v2(155.28,171.89) ; C675.1 12.22,69.29 v1(12.57,69.29) ; CN62.12 12.8,56.62 v1(12.31,56.14) ; C20011.1 28.94,147.71 28.8,147.86 v1(28.54,147.86) ; Y4.2 v1(33.79,170.67) ; v1(93.67,94.59) 93.22,95.04 C743.1 ; R510.1 v1(23.39,161.81) ; C900.1 v1(13.04,148.17) ; PC6037.2 33.07,166.89 v1(33.57,167.38) 34.09,166.86 PC6053.2 ; v1(102.09,106.68) 101.09,107.68 PQ12.1 ; v1(26.83,170.41) 26.52,170.72 R67477.1 ; v1(26.67,146.97) 26.02,146.97 C628.1 ; R25556.1 v1(209.25,94.73) ; C20045.1 C20044.2 v1(224.09,101.77) ; PQ8019.1 20.52,110.05 v1(21.14,110.68) ; v1(32.48,167.25) 32.02,166.8 31.41,166.8 R67513.1 ; R25562.1 24.57,65.5 v1(24.92,65.15) ; R67476.2 v1(31.82,165.37) ; v1(26.33,70.09) 26.9,70.09 27.49,69.5 EC10.2 ; v1(34.29,131.84) 33.84,131.39 C881.1 ; PC6051.2 v1(35.11,167.33) ; v1(20.57,117.88) 20.75,117.7 PU8000.2 ; v1(21.09,172.39) 20.99,172.5 C633.2 ; R748.2 v1(24.72,147.44) ; v1(148.96,210.25) 148.96,209.8 D13091.1 ; C20042.2 v1(225.05,99.08) ; C1693.2 v1(26.56,135.82) ; PR9030.1 v2(93.35,196.95) 93.93,197.53 PC9025.2 ; C632.2 v1(26.79,169.71) ; C1687.2 v1(28.83,145.28) ; C20132.1 v1(26.33,172.62) ; C20049.1 v1(222.46,103.28) ; PC6052.2 v1(36.12,167.32) ; v1(67.48,131.39) 67.48,131.82 67.07,132.23 C20128.2 ; v1(215.09,101.01) C20050.1 ; v1(12.35,64.73) 12.33,64.75 C676.1 ; R679.1 v1(187.14,114.2) ; C638.1 v1(27.78,168.04)
  IN1 w0.102: 29.01,59.31 28.59,58.88 28.59,57.9 v1(29.8,56.69) 30.36,56.12 30.36,47.95 30.75,47.56 32.78,47.56 v1(33.25,47.09) 33.56,47.09 33.96,47.49 33.96,48.64 33.59,49.01 v1(33.52,49.01) 33.46,49.07 32.52,49.07 32.11,49.48 32.11,52.68 30.92,53.87 30.92,58.27 29.86,59.34
  IN4 w0.089: 132.51,109.59 132.51,108.88 135.03,106.37 137.01,106.37 137.55,105.82 139.55,105.82 v1(139.79,105.57) 139.81,105.55 147.9,105.55 148.13,105.77 154.72,105.77 155.7,106.75 163.37,106.75 163.57,106.96 167.44,106.96 168.02,107.54 v1(168.18,107.54) v1(168.84,107.54) 169.93,107.54 174.69,112.3 177.94,112.3 179.24,113.61 183.99,113.61 185.87,115.49 190.42,115.49 192,113.91 195.46,113.91 v1(195.93,113.43) 196.51,113.43 196.84,113.1 196.84,108.94 196.13,108.22 196.13,107.83 v1(196.59,107.37) 197.46,108.24 197.46,113.86 197.03,114.3 192.16,114.3 190.58,115.88 185.71,115.88 184.05,114.22 v1(182.66,114.22) 179.3,114.22 177.78,112.69 173.99,112.69 v1(173.41,112.12) 173.07,111.78 173.07,111.38 172.2,110.51 v1(171.85,110.51) 171.85,110.16 169.99,108.3 167.9,108.3 167.19,107.59 163.39,107.59 163.05,107.24 155.13,107.24 v1(154.95,107.05) 154.08,106.18 147.96,106.18 147.74,105.96 140.62,105.96 v1(140.36,106.21) 137.72,106.21 137.16,106.76 135.19,106.76 133.12,108.83 133.12,109.81 132.23,110.7 v1(132.23,112.54) 132.23,113.98 v1(131.83,114.37) 131.27,114.94 129.86,114.94 129.59,114.68 129.59,114.27 129.96,113.91 v2(130.3,113.91) 130.72,114.33 131.01,114.33 131.47,113.87 131.47,110.63 132.51,109.59 ; 103.73,133.34 103.89,133.5 104.52,133.5 104.71,133.69 104.71,134.18 104.22,134.67 103.15,134.67 102.74,134.26 v2(102.74,133.85) 102.54,133.65 101.77,133.65 100.46,132.35 100.46,127.98 99.64,127.17 v2(99.64,127.05) 99.64,126.65 100.02,126.28 100.02,124.22 99.36,123.57 v2(99.05,123.57) 98.46,122.97 v2(98.46,120.94) 98.46,120.68 99.25,119.9 99.94,119.9 101.02,120.98 101.02,123.21 102.03,124.22 v2(102.03,124.59) 102,124.59 101.84,124.75 v2(101.84,127.17) 101.78,127.23 101.78,129.69 v2(101.85,129.77) 101.85,131.76 v2(102.05,131.95) 103.43,133.34 103.73,133.34
  BOTTOM w0.079: v2(123.55,124.38) 124.14,123.78 124.14,122.2 124.49,121.85
  BOTTOM w0.102: v2(117.94,120.45) 117.86,120.54 117.86,121.52 ; 101.15,119.93 100.69,120.39 U1.CR36 ; U1.BT36 99.6,132.09 v2(99.59,132.08) ; 123.55,118.41 123.55,118.47 123.72,118.65 123.72,119.73 124.03,120.04 124.03,120.46 v2(123.92,120.57) 123.92,120.59 123.27,121.24 123.27,122.07 123.29,122.07 v2(123.37,122.15) ; v2(98.46,120.94) 98.86,120.54 98.86,119.93
  BOTTOM w0.114: 98.86,119.93 98.86,119.18 100.39,117.65 v2(100.67,117.65) ; 124.49,121.85 125.35,120.99 125.35,119.86 125.82,119.38 125.82,116.19 v2(125.96,116.05) ; v2(127.12,113.78) 127.12,113.29 126.97,113.15 126.97,112.57 126.89,112.49 125.74,112.49 125.44,112.19 v2(125.02,112.19) 124.61,112.19 124.27,112.53 C205.1 ; C206.1 101.53,117.09 101.53,116.01 101.78,115.76 101.78,114.76 101.95,114.59 105.55,114.59 105.79,114.83 105.79,116.83 105.55,117.07 C209.1 ; 101.15,119.93 101.6,119.48 102.42,119.48 102.71,119.2 103.48,119.2 103.91,118.77 v2(105.1,118.77) ; 126.37,121.48 126.37,121.39 126.67,121.08 126.67,120.6 126.48,120.41 126.48,118.12 126.6,118 v1(126.6,117.83) 126.78,117.83 127.38,117.23 127.38,117.04 ; 123.55,118.41 v1(123.55,117.87) 123.55,117.58 123.83,117.3 123.83,115.89 v2(123.9,115.82)
  BOTTOM w0.127: v2(99.59,162.57) 99.86,162.3 100.65,162.3 U1.G36 U1.G35 ; U1.CN9 U1.CP9 117.86,121.52
  BOTTOM w0.152: U1.CP11 116.59,120.79 116.67,120.72 v2(116.67,120.63) ; PC6228.2 129.77,113.1 130.3,113.63 v2(130.3,113.91) ; U1.CP15 114.07,120.46 v2(114.07,120.46) ; v2(107.22,120.2) 107.22,120.3 106.51,121.02 U1.CP27 ; U1.BK2 U1.BK3 121.76,135.98 121.39,135.91 121.06,135.91 U1.BK4 ; v2(97.82,157.95) 97.82,158.15 98.37,158.71 99.68,158.71 99.87,158.52 U1.P36 ; v2(99.85,156.13) 99.98,156.01 U1.V36 ; U1.CB2 U1.CB3 ; U1.CF2 U1.CF3 121.41,126.33 v2(121.38,126.31) 121.36,126.33 U1.CF4 ; U1.BP4 v2(121.36,133.66) U1.BP3
  BOTTOM w0.178: U1.AK36 99.23,148.45 v2(99.09,148.32) ; U1.J36 99.67,161.04 v2(99.63,161.08) ; U1.AB36 99.12,153.49 98.85,153.76 v2(98.72,153.76) ; U1.BF36 99.74,138.39 v2(99.63,138.5) ; U1.B27 v2(106.5,166.25) ; U1.AV36 100.55,143.41 98.76,143.41 v2(98.61,143.26) ; U1.BB36 99.36,140.9 v2(99.21,140.76) ; v2(141.5,193.54) 141.5,193.45 141.33,193.27 140.54,193.27 U8.P26 ; v2(99.43,150.93) 99.47,150.97 U1.AF36 ; v2(108.9,166.35) 108.99,166.27 109.02,166.24 U1.B23 ; v2(103.84,166.39) 103.98,166.25 103.98,166.04 103.99,166.03 103.99,165.42 U1.B31 ; U1.AP36 99.94,145.94 99.63,145.62 98.98,145.62 v2(98.86,145.51)
  BOTTOM w0.203: 126.37,121.48 126.37,121.63 125.88,122.12 v2(125.88,122.91) ; v1(102.74,166.21) 102.77,166.18 102.87,166.18 U1.A32 ; v2(122.5,124.94) 122.5,124.91 122.21,124.62 U1.CJ2 U1.CJ3 ; C6622.2 127.95,117.4 127.72,117.64 v1(127.72,117.69) ; v2(133.49,185.24) 133.08,185.65 U8.E17 ; C242.2 96.09,105.16 v1(95.71,104.78) ; CN11.17 v1(232.64,104.21) ; v2(102.03,124.59) 102,124.59 101.96,124.55 101.31,124.55 U1.CJ35 U1.CJ36 ; v2(108.99,160.04) 108.96,160.07 108.83,160.07 U1.K24 ; v2(99.05,123.57) 99.14,123.57 99.62,124.05 U1.CK37 ; U1.CM4 121.05,123.37 120.88,123.54 U1.CK4 121.26,123.9 v2(121.43,124.08) 120.95,124.55 U1.CJ4 ; v2(171.07,145.67) 170.73,146.01 PC7003.1 ; U1.CM5 120.33,122.61 v2(120.4,122.55) 120.4,122.1 U1.CN5 ; U1.AB4 120.88,153 120.56,152.68 120.19,152.68 U1.AC5 ; v1(63.48,113.75) 63.61,113.75 63.93,114.07 JDIM02.223 ; v2(169.67,137.33) 169.43,137.33 PC7007.2 168.96,137.8 PC7009.2 ; U1.L35 U1.L36 100.58,159.85 99.12,159.85 v2(99.01,159.96) ; v1(159.76,146.35) 159.53,146.35 PC7018.2 ; v1(73.97,181.15) 73.91,181.2 PU5000.3 ; PC7005.2 167.72,145.88 167.69,145.9 v2(167.68,145.9) ; v2(101.85,129.77) 101.66,129.58 U1.BY35 U1.BY36 ; v1(168.69,136.19) 168.69,135.48 168.05,134.84 PC7012.2 ; v2(118.08,116.61) C7.2 ; CN11.20 v1(234.14,104.21) ; U1.CE35 U1.CE36 100.49,127.23 99.77,127.23 99.67,127.12 99.67,127.07 v2(99.64,127.05) ; CN11.14 v1(231.14,104.21) ; v2(57.46,183.75) PU6003.8 ; PU6000.8 175.86,129.98 176.01,130.12 v1(176.01,130.63)
  BOTTOM w0.254: v2(113.31,118.79) 113.27,118.75 R121.2 ; v2(123.52,186.06) 123.16,185.7 U8.E5 ; U1.B5 120.26,164.95 v2(120.26,164.59) 120.27,164.58 120.74,164.58 U1.C4 ; v1(160.47,117.63) 160.67,117.63 PR205.1 ; v2(102.03,124.59) 102.51,124.59 U1.CJ33 102.51,124.93 102.69,125.12 102.69,125.39 102.96,125.66 v2(102.96,125.67) 102.8,125.67 102.67,125.8 U1.CG33 ; v1(142.73,128.2) 142.93,128.2 143.19,127.93 PU16.19 ; U1.B15 114.37,164.76 v2(114.47,164.76) ; CN33.4 v1(129.6,98.02) ; R34.1 127.15,144.9 126.32,144.07 C6619.2 125.38,144.07 v2(125.33,144.02) ; U1.BY28 105.83,129.72 105.52,129.42 105.52,129.31 v2(105.5,129.29) ; v2(122.61,187.78) 122.61,187.78 U8.H5 ; U1.C21 110.7,164.67 v2(110.8,164.76) 110.27,165.28 U1.B21 ; v1(67.81,99.28) 67.32,99.28 67.2,99.4 CN58.1 ; U8.B5 123.1,183.22 v2(123.1,182.29) ; CN17.63 v1(185.06,108.15) ; C6618.1 129.04,159.38 128.87,159.21 v2(128.58,159.21) ; PU9004.19 164.28,156.93 v3(163.92,157.29) ; U1.V4 v2(121.38,155.62) U1.V3 ; U1.AC10 117.3,152.49 v2(117.05,152.23) ; 44.63,164.32 v1(43.33,164.32) ; v1(12.58,66.83) 12.57,66.82 RV2.3 10.33,66.82 10.2,66.96 v1(10.2,67) ; U1.D6 119.68,163.63 v2(120.03,163.28) 120.33,163.59 U1.D5 ; CN49.24 v1(222.9,116.25) ; U1.AN8 118.22,146.51 v2(118.36,146.65) 118.41,146.65 U1.AN7 ; 44.63,168.32 43.68,168.32 v1(43.34,167.97) ; Q6521.1 86.32,189.87 86.02,190.17 v1(86.02,190.48) ; v2(116.35,164.76) 116.25,164.76 U1.B12 ; U1.AB4 v2(121.38,153.18) U1.AB3 ; CN49.21 v1(222.9,117.75) ; U1.CP19 111.86,121.12 111.86,120.63 v2(112.02,120.47) ; CN48.12 v1(206.45,114.14) ; U1.BM36 100.52,134.75 100.02,134.75 99.95,134.82 v2(99.92,134.82) ; U8.B11 128.16,183.13 v2(128.16,182.72) ; U1.BU20 110.75,131.68 110.43,132 v2(110.38,132) ; U1.D1 123.33,164.17 123.36,164.19 v2(123.36,164.19) ; U1.AF4 v2(121.38,150.74) U1.AF3 ; R67593.2 11.9,45.97 v1(11.98,46.05) ; v2(119.38,158.66) 118.92,158.2 U1.P7 ; v2(135.38,181.99) 135.48,182.08 U8.B20 ; 44.63,126.82 43.46,126.82 v1(43.3,126.67) ; U1.CN29 105.3,122.23 105.3,123 U1.CM29 105.25,123.28 105.28,123.32 v2(105.28,123.67) 105.28,123.78 105.78,124.28 U1.CJ28 ; U8.B17 133.12,183.13 v2(133.12,182.62) ; v2(111.25,120.45) 111.02,120.45 110.56,120.92 110.56,121.26 U1.CP21 U1.CN21 U1.CM21 ; v1(229.62,118.74) 229.34,118.46 CN55.14 ; C116.2 126.44,139.13 126.03,139.54 v2(125.9,139.54) ; U1.BT33 102.37,131.95 v2(102.05,131.95) 101.91,132.09 U1.BT35 ; 114.16,130.38 114.16,129.77 U1.BY15 114.19,129.73 v2(114.52,129.41) 114.45,129.41 U1.CA15 113.73,128.69 113.73,128.23 U1.CC16 ; 114.16,130.38 114.54,130.76 114.54,131.95 v2(114.48,132) ; 114.16,130.38 U1.BW15 ; v1(43.3,119.19) 43.43,119.32 JDIM1.202 ; v1(58.6,194.95) 58.28,194.95 57.15,193.82 CN29.3 ; C805.1 196.7,122.52 196,123.21 v1(195.66,123.21) 195.38,122.93 C801.2 ; v1(226.49,122.18) 226.97,122.65 227.61,122.65 227.8,122.46 CN55.6 ; U1.AW1 123.01,142.62 123.65,142.62 123.93,142.9 v2(123.93,143.06) ; v2(117.33,162.13) 117.56,162.36 U1.G9 ; U1.T7 118.87,157.27 v2(119.33,156.82) 118.87,156.36 U1.U7 ; v2(117.24,130.12) 116.86,129.73 U1.BY11 U1.CA11 U1.CB11 U1.CC11 U1.CD11 116.61,127.1 116.61,126.67 v2(116.52,126.59) ; v2(117.24,130.12) 117.1,130.26 117.1,130.57 U1.BV11 U1.BU11 ; v2(117.24,130.12) 116.91,130.12 U1.BW11 ; v1(110.88,110.93) 111.03,110.78 U6504.3 ; R116.1 95.05,123.9 v1(95.35,123.6) 95.38,123.64 C96340.1 ; C20089.1 v1(16.03,45.23) ; C2616.1 13.03,69.75 v1(12.57,69.29) ; v2(119.94,150.38) 120.17,150.15 U1.AG5 ; U8.E2 120.57,185.64 119,185.64 v2(118.97,185.67) ; CN29.12 61.65,194.44 v1(61.46,194.63) 62.42,194.63 63.15,193.9 CN29.15 ; U1.BU23 109.08,131.61 108.83,131.36 v2(108.73,131.36) 108.57,131.36 U1.BU24 U1.BU25 U1.BT25 107.26,132.48 107.26,132.84 U1.BR25 107.42,132.98 107.75,133.31 v2(107.75,133.31) 107.42,133.63 U1.BP25 ; U8.L25 139.2,191.09 138.44,191.09 U8.L23 v2(137.6,190.25) ; v2(115.09,119.76) 115.26,119.93 115.26,121.45 U1.CP13 U1.CN13 ; v2(114.47,162.81) 114.37,162.81 U1.F15 ; U1.F12 116.25,162.81 v2(116.35,162.81) ; v2(125.14,201.1) 125.56,200.68 U8.AC8 ; C6609.2 113.61,108.64 v1(113.34,108.91) 113.15,108.72 R25358.1 ; C804.2 v1(192.53,124.05) ; U1.BA10 117.16,141.71 v2(117.16,142.03) ; Q34.1 22.27,86.74 v1(22.5,86.51) ; U1.CF19 111.59,126.31 U1.CD20 ; CN17.19 v1(182.68,119.15) ; U1.BD6 119.23,140.02 v2(119.23,140.22) ; U1.CB20 110.8,128.43 v2(111.13,128.11) 111.46,128.43 U1.CB19 111.76,128.43 v2(112.08,128.11) 112.41,128.43 U1.CB18 ; 102.93,127.48 U1.CE33 102.4,127.17 v2(101.84,127.17) 101.76,127.09 101.33,127.09 U1.CE35 ; 102.93,127.48 102.51,127.89 U1.CB33 ; 102.93,127.48 103.35,127.48 103.8,127.93 U1.CC31 ; U1.CJ14 115.21,124.02 v2(115.52,124.02) 115.33,123.84 U1.CM13 ; U1.P4 v2(121.38,158.07) U1.P3 ; CN52.9 v1(206.35,102.22) ; v1(64.65,192.02) CN29.18 ; 44.63,156.82 43.51,156.82 43.3,157.03 v1(43.3,157.19) ; U1.AJ7 118.97,148.86 118.97,148.15 U1.AL7 119.33,147.58 v1(119.7,147.58) ; v2(117.16,154.97) 117.3,155.11 U1.W10 ; v2(118.49,137.4) 118.49,137.33 U1.BJ7 ; v2(118.36,163.31) 118.35,163.31 ; 118.35,163.31 118.33,163.31 118.31,163.28 U1.E9 ; 118.35,163.31 118.35,163.3 118.35,163.29 118.36,163.28 118.36,163.28 118.55,163.47 U1.D8 ; v1(163.52,134.91) 163.25,135.18 PC7027.1 ; CN29.21 66.15,192.11 v1(65.95,191.91) ; U1.K9 117.72,160.51 v2(117.33,160.9) 117.76,161.33 U1.H9 ; 44.63,149.32 v1(43.34,149.32) ; CN10.B1 7.07,69.37 7.34,69.37 CN10.A12 8.05,69.37 8.13,69.3 8.13,69.25 8.72,69.25 v1(9.63,70.15) ; U8.L5 123.44,190.25 v2(123.46,190.25) ; 120.54,136.6 120.54,137.28 v2(120.45,137.38) 120.91,137.85 U1.BG4 ; CN29.9 60.15,194 v1(60.26,194.1) ; CN16.33 25.86,80.36 v1(25.86,79.19) ; PU7001.6 154.34,143.76 PU7001.9 154.59,144.85 v1(154.41,145.02) 153.98,145.46 PC7063.1 ; v1(9.07,63.66) 8.86,63.87 CN10.A1 7.08,63.87 CN10.B12 ; PC37.1 161.94,124.89 162.33,124.5 v1(162.33,124.41) ; v2(102.91,122.61) 102.72,122.79 U1.CM33 ; v1(120.36,147.58) 120.36,147.31 U1.AM5 ; U8.B1 v2(119.04,183.25) ; CN52.16 v1(202.85,102.24) ; U1.CE7 118.75,126.79 118.56,126.98 v2(118.56,127.18) 118.56,127.41 U1.CC7 118.77,127.81 118.77,128.54 U1.CB7 ; v2(119.81,143.01) 119.81,143.03 119.52,143.32 U1.AV6 ; v3(106.6,201.2) 106.6,201.68 PR9274.2 ; C749.1 108.46,107.1 108.25,106.89 v1(107.19,106.89) ; v2(141.63,182.49) 141.63,182.84 U8.B27 ; U1.AU10 117.16,144.48 v2(117.16,144.81) ; v2(130.94,186.07) U8.E14 ; U1.BP15 114.09,133.63 113.77,133.31 ; CN17.39 182.73,114.15 v1(182.66,114.22) ; U1.C9 117.85,164.66 117.36,164.16 v2(117.33,164.16) 117.57,163.93 U1.D9 ; U1.N6 119.52,159.42 119.38,159.56 v2(119.38,159.59) 119.38,159.66 119.52,159.8 U1.L6 119.57,160.05 v2(120.03,160.51) ; CN4.1 86.65,99.15 87.05,98.75 v1(87.05,98.07) ; U1.CJ23 108.46,124.36 108.1,124 108.1,123.59 v2(108.2,123.49) U1.CM25 U1.CN25 ; U1.C25 U1.B25 ; U1.J12 116.25,160.86 v2(116.35,160.86) ; v2(120.22,187.73) 120.62,188.13 U8.H2 ; v2(114.48,132) 114.48,132.01 114.15,132.33 U1.BT15 ; v2(114.48,132) 114.82,132.33 U1.BT14 ; v2(114.47,160.86) 114.37,160.86 U1.J15 ; 44.63,153.82 v1(43.26,153.82) ; U8.U23 138.08,195.63 138.47,196.01 v2(138.47,196.01) ; PC7102.1 155.42,164.12 154.79,164.75 v1(154.79,164.79) 154.78,164.8 PU7003.9 155.03,166.05 PU7003.6 ; U1.BP33 102.51,133.62 v2(102.74,133.85) 102.75,133.84 102.78,133.84 U1.BP32 ; CN29.6 58.65,194.13 v1(58.55,194.23) ; U1.B29 U1.C29 ; U1.B7 119.12,165.9 119.5,166.29 v2(119.58,166.29) ; v2(119.86,120.54) 119.86,121.03 U1.CR6 ; U8.E8 125.9,185.31 125.95,185.31 125.96,185.29 v2(125.96,185.27) ; U1.F18 112.49,162.81 v2(112.59,162.81) ; U1.AK4 121.05,148.13 v2(121.39,148.13) 121.71,148.13 U1.AK3 ; C463.2 128.26,177.84 128.26,174.18 128.06,173.97 123.63,173.97 123.33,174.26 123.33,175.16 123.89,175.71 v1(123.89,177.38) 124.05,177.38 124.2,177.53 124.92,177.53 125.24,177.85 C464.2 ; v2(120.03,160.51) 119.56,160.97 U1.J6 ; v2(120.03,160.51) 120.17,160.65 U1.J5 ; v1(20.19,79.2) 19.85,79.54 CN16.57 ; v1(151.48,213.46) 151.48,213.95 R25650.2 ; CN48.16 v1(204.45,112.47) ; CN16.39 24.35,81.56 23.43,82.47 v1(23.43,82.9) ; CN48.19 v1(202.95,114.17) ; C20085.1 R205.2 v1(27.4,50.98) ; PR6014.1 175.16,134.47 v1(174.55,135.08) ; U9.3 105.42,185.84 105.05,186.21 PC9072.2 ; CN16.45 22.85,79.51 v1(23.22,79.14) ; U1.BV3 v2(121.36,131.22) U1.BV4 120.88,131.39 120.47,131.8 120.47,132.04 U1.BT5 120.17,132.37 v2(120.49,132.69) ; v1(16,46.19) 16.19,46 C20090.1 ; v2(119.84,142.13) 119.84,141.89 U1.BA6 ; v1(222.9,115.54) 222.9,115.11 222.54,114.75 CN49.27 ; U1.BT16 113.45,132.33 v2(113.77,132.01) 113.45,131.68 U1.BU16 ; 44.63,152.32 v1(43.33,152.32) ; v1(204.68,114.32) 204.95,114.05 CN48.15 ; v2(112.12,133.98) 111.77,133.63 U1.BP19 U1.BR19 ; 113.77,133.31 113.61,133.31 U1.BR16 ; 113.77,133.31 v2(113.77,133.31) ; CN55.9 227.85,120.96 227.61,120.72 v1(227.35,120.72) ; RV1.3 v1(9.41,61.52) ; v1(137.95,181.73) 138.13,181.92 138.13,183.08 U8.B23 ; v1(43.3,154.82) 44.63,154.82 ; CN14.5 74.95,100.48 75.36,100.88 v1(75.75,100.88) ; v2(108.03,140.69) 108.03,140.69 U1.BC25 ; v2(117.33,166.06) 117.36,166.06 117.85,165.56 U1.B9 ; v1(119.27,110.48) 118.92,110.13 C190.2 C189.1 ; v2(116.56,124.03) 116.89,124.36 U1.CJ11 ; v2(111.33,124.18) 111.51,124.36 U1.CJ19 ; v2(115.46,128.11) 115.29,128.11 U1.CC14 U1.CD14 114.96,126.89 115.44,126.42 v2(115.46,126.42) 115.35,126.31 U1.CF14 ; v2(120.01,182.12) 120.38,182.12 120.62,182.36 U8.A2 ; v1(43.28,155.52) 43.59,155.82 44.63,155.82 ; v1(25.03,27.97) 25.55,28.49 R734.1 ; v1(108.51,138.35) 108.45,138.35 108.06,137.95 U1.BG25 ; v2(123.37,162.95) U1.F2 122.46,162.86 121.97,162.86 U1.F3 121.79,162.85 U1.F4 ; U1.BY5 120.88,128.86 U1.CB4 v2(121.38,128.78) U1.CB3 ; C206.1 100.99,117.33 v2(100.67,117.65) ; v1(15.56,35.8) 15.78,35.8 16.13,36.14 R469.2 ; U1.CN9 U1.CM9 118.82,124.02 U1.CK7 ; v2(106.96,163.36) 106.87,163.46 U1.E27 ; v2(142.34,198.37) 142.34,198.22 142.03,197.92 140.61,197.92 U8.Y26 ; U1.AV8 118.22,143.74 v2(118.36,143.88) ; v2(116.52,126.59) 116.35,126.59 U1.CD12 ; v2(116.52,126.59) 116.8,126.31 U1.CF11 ; U1.AE7 U1.AF7 118.88,150.81 119.29,150.4 119.3,150.4 v2(119.31,150.38) ; U1.CN17 U1.CM17 113.19,123.43 113.2,123.43 v2(113.22,123.46) ; U1.BV33 102.51,130.5 v2(102.81,130.2) 102.51,129.9 U1.BY33 ; v2(116.42,138.43) 117,138.43 117.16,138.59 117.16,138.66 U1.BE10 ; PC6055.1 58.61,180.94 59.05,180.5 59.05,180.49 59.4,180.14 PC6058.2 59.62,179.96 v2(60.05,179.52) ; U1.BD7 118.87,139.85 118.52,140.2 v2(118.52,140.22) 118.51,140.23 118.47,140.23 118.22,140.48 U1.BC8 ; U6523.8 3.61,49.43 3.44,49.27 3.44,48.68 v1(3.86,48.26) ; v1(14.03,125.59) 14.03,125.89 D13082.1 ; U1.AM10 117.3,147.44 v2(117.16,147.58) ; U1.B18 112.49,164.76 v2(112.59,164.76) ; U1.BU7 U1.BW7 119.21,130.15 v2(119.21,130.14) ; v1(182.5,109.17) 182.98,109.65 CN17.57 ; U8.H23 v2(138.42,187.79) ; v2(128.22,180.13) 128.02,180.13 127.36,179.47 v1(127.36,179.22) ; v1(59.97,98.07) 59.97,98.2 60.7,98.94 CN58.14 ; U1.BW24 108.24,130.33 108.52,130.06 v2(108.73,130.06) ; U1.BY18 112.41,129.73 v2(112.08,129.41) 111.76,129.73 U1.BY19 ; CN16.27 27.35,79.4 26.25,78.31 v1(25.87,78.31) ; U1.BR22 110.05,132.98 v2(110.38,133.31) ; C96269.2 93.82,187.54 94.62,188.34 94.68,188.34 94.69,188.35 PQ9009.1 ; U1.AN25 v2(108.02,146.15) ; CN17.13 v1(185.23,120.65) ; U8.AC26 140.65,200.83 141.7,200.83 v2(141.89,201.01) ; CN17.33 183.04,115.65 182.71,115.98 v1(182.71,116.39) ; v2(103.85,123.14) 103.85,123.13 104.02,122.96 U1.CM31 ; U6517.5 194.28,123.89 v1(193.75,123.36) 194.19,122.93 C800.2 ; v2(116.97,157.81) 116.97,157.87 U1.P10 ; CN58.7 64.2,98.62 64.59,98.23 v1(64.59,98.07) ; CN49.18 v1(222.9,119.25) ; CN17.45 182.82,112.65 v1(182.69,112.53) ; v1(58.09,183.34) 59.12,183.34 59.47,182.99 PR6031.1 ; U1.AB7 118.64,153.81 118.64,154.28 U1.Y7 118.82,154.51 v2(118.36,154.97) 118.82,155.43 U1.W7 ; CN17.7 v1(182.64,122.15) ; v2(112.59,160.86) 112.49,160.86 U1.J18 ; CN17.75 v1(185.09,105.15) ; v2(108.01,143.42) U1.AV25 ; U1.BE8 118.22,138.75 118.51,138.45 v2(118.51,138.39) ; 44.63,171.32 JDIM1.2 ; v2(103.41,130.2) 103.42,130.2 U1.BV31 ; R25578.2 v1(26.8,47.35) ; U1.CH31 103.77,125.19 103.57,124.99 v2(103.57,124.69) ; 44.63,166.32 v1(43.33,166.32) ; CN53.9 218.4,99.65 218.54,99.5 v1(218.93,99.5) ; v1(206.95,112.47) CN48.11 ; v2(105.62,125.67) 105.83,125.89 U1.CF28 ; v2(118.52,126.41) 118.52,126.22 U1.CG7 ; v2(115.47,134.64) 115.8,134.31 U1.BP12 ; U1.BT28 105.86,132.48 106.17,132.17 106.17,132.14 106.22,132.09 v2(106.22,131.99) ; v1(17.18,84.35) 17.25,84.42 17.25,85.55 R654.1 ; 44.63,162.82 v1(43.33,162.82) ; U1.K4 121.06,160.51 v2(121.31,160.75) 121.56,160.51 U1.K3 ; 44.63,159.82 43.32,159.82 v1(43.28,159.87) ; 44.63,150.32 v1(43.33,150.32) ; 44.63,160.82 v1(43.32,160.82) ; v2(105.58,127.43) 105.58,127.46 105.61,127.49 105.61,127.71 U1.CC28 ; C20091.1 v1(26.47,54.35) ; v1(21.77,79.03) 21.35,79.45 CN16.51 ; v2(128.41,185.28) U8.E11 ; CN17.18 v1(190.12,119.4) ; v2(117.09,150.32) 117.3,150.11 U1.AG10 ; CN53.1 v1(226.4,99.63) ; v2(139.23,186.15) 139.23,186.09 U8.E25 ; v2(108.21,135.31) 108.14,135.23 108.04,135.23 108.03,135.22 U1.BL25
  BOTTOM w0.305: PU7002.9 153.78,159.54 PU7002.6 ; v2(119.63,200.91) 120.31,200.91 U8.AC2 ; v2(161.7,172.42) 161.71,172.42 VRAM1.E1 ; U8.AF17 132.99,203.05 132.59,202.65 132.58,202.65 v2(132.58,202.65) ; U8.B8 125.45,183.14 125.45,181.71 v2(125.55,181.61) ; U8.L2 120.65,190.67 121.06,190.26 v2(121.06,190.25) ; v2(127.66,188.46) 127.52,188.6 U8.K11 v2(128.07,189.7) U8.L12 129.06,190.69 v2(129.06,190.71) 129.08,190.71 U8.M13 129.52,191.22 130.04,191.74 130.07,191.74 130.09,191.76 v2(130.12,191.76) 130.14,191.76 U8.N14 130.55,192.15 131.06,192.65 v2(131.09,192.65) 131.09,192.72 U8.P15 131.52,193.15 131.85,193.48 v2(131.85,193.67) 132.04,193.67 132.52,194.15 U8.R16 133.02,194.65 133.52,195.15 U8.T17 ; v2(141.63,182.49) 140.87,182.49 140.82,182.45 U8.A26 ; U1.BY22 110.25,129.41 v2(110.39,129.41) 110.06,129.08 U1.CA22 ; v2(119.99,195.32) 120.31,195.32 U8.U2 ; VRAM2.U1 165.3,206.89 v2(165.2,206.99) ; U8.R18 134.31,193.94 v2(134.31,193.65) 134.14,193.65 133.94,193.45 133.82,193.45 U8.P17 v2(133.08,192.71) U8.N16 132.52,192.02 132.14,191.64 v2(131.85,191.64) 131.85,191.4 131.6,191.15 U8.M15 131.49,191.15 131.19,190.85 v2(131.06,190.85) 131.04,190.83 131.04,190.7 130.52,190.18 U8.L14 130.49,190.15 v2(130.07,189.73) 129.52,189.18 U8.K13 ; U8.AD12 129.27,201.84 v2(129.29,201.84) ; v2(130.14,182.88) 130.51,183.25 U8.B14 ; v2(130.05,200.22) 130.46,199.81 U8.AB14 ; U8.AB11 v2(128.46,200.23) ; U8.N10 126.52,192.4 v2(126.8,192.68) 127.05,192.68 U8.P11 127.52,193.2 v2(127.89,193.57) 127.94,193.57 U8.R12 128.97,194.6 v2(128.97,194.65) 129.02,194.65 U8.T13 129.52,195.22 130.02,195.72 130.02,195.72 130.02,195.72 130.45,196.15 U8.U14 v2(131.02,196.65) U8.V15 ; v2(125.47,203.85) 125.47,203.67 125.42,203.62 125.42,203.19 U8.AF8 ; v2(135.9,201.85) 135.88,201.85 U8.AE20 ; U8.AB7 124.83,199.81 v2(125.15,200.12) 125.56,200.54 U8.AC8 ; v2(123.43,193.56) U8.P5 ; R25380.1 111.3,111.58 110.88,111.16 v1(110.88,110.93) ; U8.K15 131.71,189.34 131.99,189.34 v2(132.01,189.37) 132.01,189.54 132.52,190.05 U8.L16 132.52,190.15 132.98,190.61 132.98,190.81 v2(133.01,190.84) 133.21,190.84 133.52,191.15 U8.M17 134.01,191.64 v2(134.31,191.64) 134.52,191.84 U8.N18 ; v2(122.67,201) U8.AC5 ; U8.AD13 129.7,201.45 v2(130.1,201.05) ; v2(164.1,174.02) 164.09,174.02 VRAM1.C3 ; v2(139.22,200.2) 138.82,199.8 U8.AB24 ; U8.AF14 130.9,202.67 v2(130.9,202.65) ; U8.AF5 123.07,203.33 122.91,203.49 122.91,204.39 v1(122.81,204.49) ; v2(138.36,203.44) U8.AF23 ; v2(133.26,188.64) 133.26,188.89 U8.K17 133.88,189.51 v2(133.88,189.57) 133.93,189.57 134.5,190.15 U8.L18 ; U8.AC22 v2(136.75,201.02) ; CN17.69 v1(185.06,106.65) ; U11.3 127.32,211.65 v1(127.8,212.13) ; U8.AA7 124.36,198.59 v2(124.36,198.5) ; U8.AD18 133.82,201.45 v2(133.42,201.05) ; v2(132.58,201.85) 132.6,201.85 U8.AE17 ; v2(140.83,204.28) 140.42,203.87 U8.AG26 ; U8.Y2 119.67,198.11 119.1,197.54 v2(118.97,197.54) ; v2(123.29,123.57) 123.16,123.57 U1.CK1 ; U8.AD16 v2(131.76,201.05) ; U8.AD19 134.66,201.45 v2(135.06,201.05) ; v2(119.01,202.77) 119.27,202.77 119.55,203.05 U8.AF1 ; U1.CC20 111.09,127.46 v2(111.13,127.46) 110.81,127.13 U1.CD20 ; U8.R10 126.52,194.16 v2(126.91,194.55) 127.51,195.15 U8.T11 127.52,195.27 v2(127.91,195.66) 128.39,196.15 U8.U12 v2(128.97,196.6) U8.V13 ; U8.AE14 130.9,201.87 v2(130.9,201.85) ; U8.U10 126.99,196.62 v2(126.99,196.65) 127.02,196.65 U8.V11 ; U8.AF20 v2(135.88,202.65) ; CN48.8 208.45,114.03 v1(209.05,114.63) ; v2(122.61,195.22) 123.01,195.63 U8.U5 ; v2(140.05,188.62) 140.05,188.62 U8.H25 ; v2(133.36,200.19) 133.36,200.16 U8.AB17 ; U8.AD15 v2(131.77,201.86) ; U8.U26 140.4,195.63 140.02,195.25 v2(140.02,195.23) ; v1(120.01,193.15) U8.P2 ; v1(95.6,109.47) 95.6,109.38 96.12,108.86 C247.1 ; v2(128.45,203.44) 128.43,203.44 U8.AF11 ; v1(123.89,177.38) 123.89,177.82 R331.2 ; v2(128.44,202.64) 128.43,202.64 U8.AE11 ; v2(164.1,179.62) 164.5,180.02 VRAM1.B10 ; v2(122.61,198.52) U8.Y5 ; U8.AD22 v2(136.72,201.85) U8.AD21 ; v2(164.1,202.82) 164.1,202.82 VRAM2.T5 ; U8.AB20 v2(135.06,200.23) ; U8.U18 134.52,195.86 v2(134.29,195.63) ; v1(27.47,31.68) 27.47,31.65 27.42,31.65 27.18,31.42 C215.1 ; v1(185.64,109.98) 185.22,110.4 185.22,110.76 184.82,111.15 CN17.51 ; v2(120.21,204.26) U8.AG2 ; v1(66.42,189.62) 66.42,189.32 66.86,188.88 R442.2 ; R67592.2 v1(7.67,44.67) ; U8.P23 v2(137.6,192.73) ; U8.Y23 v2(137.6,198.53) ; U8.V17 132.96,196.59 132.94,196.59 v2(132.89,196.54) 132.87,196.52 132.87,196.49 U8.U16 132.08,195.7 v2(131.85,195.7) 131.85,195.48 U8.T15 131.52,195.15 131.27,194.89 v2(131.27,194.66) 131.04,194.66 130.52,194.15 U8.R14 130.12,193.74 v2(130.12,193.54) 129.89,193.54 129.52,193.17 U8.P13 129.52,193.15 v2(129.02,192.65) 129.02,192.65 U8.N12 128.3,192.15 127.91,191.77 v2(127.89,191.77) 127.89,191.61 127.52,191.24 U8.M11 127.3,191.15 126.87,190.72 126.85,190.72 126.8,190.67 126.77,190.67 126.75,190.65 v2(126.72,190.65) 126.72,190.57 126.52,190.37 U8.L10 126.1,190.15 v2(125.88,190.37)
  BOTTOM w0.33: v2(152.88,174.8) VRAM1.U3 ; v2(163.3,194.82) 163.7,195.22 VRAM2.R14 ; VRAM2.C12 154.08,196.82 v2(153.7,197.2) 153.71,197.2 154.1,197.59 VRAM2.C11 ; VRAM1.A1 165.3,172.82 v2(164.9,172.42) ; VRAM1.T5 153.3,175.97 v2(153.69,175.58) ; v2(155.31,206) VRAM2.E1 ; VRAM2.K14 159.35,195.57 v2(159.3,195.57) 159.7,195.97 VRAM2.K13 ; VRAM1.A3 165.31,174.42 v2(165.7,174.02) ; v2(165.7,203.62) 165.31,204.02 VRAM2.U3 ; v2(155.3,204.38) 155.35,204.38 155.7,204.03 VRAM2.E3 ; VRAM1.G5 160.5,176.02 v2(160.9,176.42) 161.3,176.02 VRAM1.F5 ; VRAM2.J1 158.9,205.63 v2(158.5,206.02) ; VRAM2.L10 160.5,198.42 160.9,198.82 ; VRAM1.C11 163.7,180.82 v2(163.3,181.22) ; v2(160.1,182.82) 159.7,182.42 VRAM1.H13 ; VRAM2.N14 162.11,195.22 v2(162.5,194.82) ; v2(162.5,174.02) 162.11,174.42 VRAM1.E3 ; VRAM2.J10 158.9,198.43 158.5,198.82 v2(158.5,198.88) ; v2(164.1,197.22) 163.71,197.62 VRAM2.R11 ; VRAM2.U12 165.7,197.22 v2(165.7,197.22) ; v2(163.3,172.42) 163.7,172.82 VRAM1.C1 ; v2(155.31,183.6) VRAM1.N14 ; VRAM1.M5 156.5,176.02 v2(156.9,176.42) 157.3,176.03 VRAM1.L5 ; VRAM2.N1 162.1,205.62 161.75,205.97 v2(161.7,205.97) ; VRAM2.K1 159.31,205.22 v2(159.3,205.22) 159.3,205.22 VRAM2.K2 ; VRAM2.T10 164.5,198.43 v2(164.1,198.82) ; VRAM2.P10 162.9,198.42 v2(163.3,198.82) ; v2(165.7,183.62) 165.3,183.22 VRAM1.A14 ; VRAM2.A14 152.5,195.22 v2(152.12,194.84) ; v2(151.92,181.48) 152.06,181.62 VRAM1.U12 ; VRAM2.C1 154.47,205.24 v2(154.5,205.24) ; VRAM1.R11 154.1,180.82 v2(154.5,181.22) 154.11,181.62 VRAM1.R12 ; v2(160.1,183.62) 159.7,183.22 VRAM1.H14 ; VRAM1.R4 154.1,175.18 v2(154.49,174.79) 154.13,174.42 VRAM1.R3 ; v2(153.7,172.42) 154.1,172.82 VRAM1.R1 ; VRAM1.H2 159.7,173.62 v2(159.3,173.22) ; VRAM2.R12 164.09,196.42 v2(164.1,196.42) ; v2(155.7,194.68) VRAM2.E14 ; v2(152.91,179.61) 153.3,180 VRAM1.T10 ; v2(153.7,204.38) 153.74,204.38 VRAM2.C3 ; VRAM1.K1 158.1,172.83 v2(157.7,173.22) 158.1,173.62 VRAM1.K2 ; VRAM1.H1 159.7,172.82 v2(159.3,172.42) 158.91,172.82 VRAM1.J1 ; v2(163.32,202.85) 163.69,203.22 163.7,203.22 VRAM2.R4 ; v2(156.1,174.82) 155.7,174.42 VRAM1.N3 ; v2(163.3,206.02) 163.7,205.62 VRAM2.R1 ; VRAM1.U14 152.22,183.22 v2(151.99,182.99) ; VRAM2.B5 153.3,202.42 153.69,202.81 v2(153.7,202.81) 153.7,202.82 VRAM2.C4 ; VRAM2.F5 156.51,202.42 156.9,202.03 v2(156.9,202.03) 156.91,202.03 157.3,202.42 VRAM2.G5 ; v2(156.9,198.06) 156.55,198.42 VRAM2.F10 ; v2(153.7,183.62) 154.1,183.23 VRAM1.R14 ; VRAM1.B5 164.51,176.02 v2(164.9,175.62) ; VRAM2.D10 154.9,198.43 154.5,198.82 v2(154.5,198.88) ; v2(163.3,183.62) 163.7,183.22 VRAM1.C14 ; v2(157.7,183.62) 158.1,183.23 VRAM1.K14 ; v2(164.08,204.4) VRAM2.R3 ; VRAM1.E12 162.1,181.62 v2(161.7,181.22) ; v2(157.7,206.02) 158.1,205.63 VRAM2.H1 ; VRAM2.C14 154.1,195.22 v2(153.7,194.82) ; v2(163.3,182.02) 163.7,181.62 VRAM1.C12 ; v2(156.75,198.88) 156.84,198.88 VRAM2.G10 ; VRAM1.U1 v2(152.09,172.41) ; v2(154.52,179.64) VRAM1.P10 ; VRAM1.M10 156.51,180.02 v2(156.9,179.62) 157.3,180.02 VRAM1.L10 ; VRAM2.M10 161.3,198.42 160.9,198.82 ; VRAM1.G10 160.51,180.02 v2(160.9,179.62) 161.3,180.02 VRAM1.F10 ; v2(157.7,182.82) 158.1,182.43 VRAM1.K13 ; VRAM2.H13 157.7,195.62 v2(157.7,195.57) 158.06,195.22 VRAM2.H14 ; VRAM2.L5 160.51,202.42 v2(160.9,202.02) 161.3,202.42 VRAM2.M5 ; VRAM2.U14 165.31,195.22 v2(165.7,194.82) ; v2(152.11,204.38) 152.14,204.38 VRAM2.A3 ; v2(161.7,183.62) 162.1,183.22 VRAM1.E14 ; v2(160.9,198.88) 160.9,198.82 ; v2(162.5,196.39) 162.5,196.42 VRAM2.N12 ; VRAM1.D10 162.9,180.02 v2(162.5,180.42) ; VRAM1.A12 165.31,181.62 v2(165.7,181.22) ; v2(155.3,182.02) 155.7,181.63 VRAM1.N12 ; VRAM2.A12 152.15,197.17 v2(152.15,197.2) ; VRAM1.N1 155.7,172.31 v2(155.28,171.89) ; VRAM2.A1 v2(152.06,206.06)
  BOTTOM w0.356: v2(164.1,174.82) 163.71,175.22 VRAM1.C4 ; v1(158.38,188.11) 158.38,187.56 R405.1 ; VRAM2.B10 153.33,198.42 153.69,198.06 v2(153.7,198.06) ; v1(146.12,189.48) 146.12,189 145.59,188.46 R315.1 ; U8.E22 137.17,185.65 v2(137.56,185.26) ; VRAM2.H2 VRAM2.H1
  BOTTOM w0.381: C1044.2 16.18,155.96 v1(16.64,155.51) ; Q6565.1 28.33,53.11 v1(27.36,53.11) ; C583.1 29.15,35.84 v1(29.69,36.38) ; C1646.2 24.2,60.47 v1(24.2,59.98) ; v1(104.12,188.64) 104.45,188.64 PQ9010.1 ; Q81.1 15.12,156.52 v1(15.12,157.08) ; v1(30.46,34.8) 30.46,34.46 29.81,33.8 R25495.1 ; v2(116.99,136.39) 117.3,136.08 U1.BK10 ; v1(20.43,62.61) 20.43,62.34 20.84,61.93 C1649.1 ; U8.E20 135.48,185.61 v2(135.88,185.21) ; R355.1 R357.1 115.44,181.52 v1(114.82,181.52) ; C205.1 124.27,115.42 123.9,115.79 v2(123.9,115.82) ; v2(108.33,119.15) 108.33,118.73 108.19,118.58 C228.1 ; C464.2 125.24,179.18 v1(125.6,179.55) ; PC229.2 v1(7,37.06) ; R479.2 32.44,30.71 v1(32.88,31.15) 33.46,30.57 C595.2 ; R467.1 11.43,34.49 v1(11.43,35.09) 10.6,35.09 C596.2 ; C20142.2 157.92,212.52 v1(157.92,212.07) ; R73.1 R25387.1 95.86,120.93 v2(96.32,121.38) ; C96346.2 160.14,113.1 v1(160.12,113.08) ; v2(97.57,128.15) 97.49,128.23 97.49,128.79 96.93,129.34 C96341.1 ; Y2.2 126.65,114.25 v2(127.12,113.78) ; Q6521.4 84.84,188.57 v1(84.37,188.09) ; v1(80.45,188.18) 80.53,188.25 80.53,189.13 Q6522.1 ; R356.1 115.42,186.56 v1(114.91,187.07) 115.42,187.57 R313.2 ; 145.76,192.99 146.01,192.75 C446.1 ; 145.76,192.99 v1(145.76,193) ; 145.76,192.99 145.52,192.75 C451.1 ; Q6570.1 30.47,56.69 v1(29.8,56.69) ; v2(98.46,120.94) 98.46,120.63 97.67,119.84 R25393.1 ; v2(104.46,199.43) 104.45,199.44 PC9012.2 ; R351.1 R350.1 131.35,179.44 130.96,179.83 130.33,179.83 v2(129.06,181.1) ; C463.2 127.8,178.55 127.36,178.99 v1(127.36,179.22) ; v2(110.86,119.27) 110.74,119.16 110.74,118.18 C220.1 110.76,117.79 110.74,117.77 110.74,117.47 C221.1 ; PR9031.1 116.1,190.7 115.58,190.18 v1(115.58,190.03) ; C2542.1 128.44,138.93 v1(128.9,139.39) ; PC6231.2 11.45,36.62 v1(11.24,36.82) ; v1(154.7,209.38) 154.08,210 R25647.2 ; v1(115.9,208.18) 116.62,208.18 C364.2 ; PC9071.2 102.73,186.34 v1(101.92,185.53) ; R25392.1 92.87,120.21 v2(93.22,120.57) 93.48,120.83 R25391.1 ; v1(150.36,211.31) 150.86,211.82 R25640.2 ; C209.1 105.55,118.07 105.16,118.46 105.16,118.72 v2(105.1,118.77) ; v1(123.55,117.87) 122.9,117.87 C230.1 ; PU3003.2 5.74,34.64 v1(5.63,34.54) ; v2(156.1,197.2) 155.72,196.82 VRAM2.E12 ; v1(14.77,40.3) 14.96,40.49 15.72,40.49 C567.2 ; R354.1 116.74,184.4 116.76,184.37 v2(118.97,184.37) ; v1(160.12,133.59) 160.28,133.59 160.67,133.97 160.67,134.13 PR7033.2 ; C736.2 219.39,121.54 219.03,121.91 v1(219.03,122.09) ; v1(54.98,197.59) 54.45,197.06 CN29.41 ; C20139.2 156.37,209.82 C20138.2 157.02,209.82 v1(157.61,209.23) ; PQ7.1 134.02,128.6 v1(133.54,128.6) ; v1(56.82,187.65) 56.45,187.28 PC6039.1 ; v1(12.17,158.9) 12.12,158.85 C20005.1 11.4,158.85 C890.1 ; R25369.2 82.62,190.24 v1(82.62,190.32) ; v1(114.93,185.52) 114.99,185.52 115.01,185.54 R353.1 ; v1(90.02,100.79) 90.58,100.79 90.67,100.7 EC8.2 ; v1(118.37,103.2) 117.96,103.6 C191.2 ; EC7.1 92.94,101.17 v1(92.94,101.97) ; C691.1 15.08,63.3 v1(15.62,63.3) ; PC9073.2 99.08,183.32 v1(98.99,183.41) ; C585.2 28.25,29.54 v1(27.74,29.04) 27.4,29.38 C844.1 ; D16.2 15.36,62.26 v1(15.65,62.54) ; VRAM1.J10 158.9,180.08 v2(159.28,180.46) ; C575.2 17.63,39.53 17.11,39.53 v1(17.09,39.55) ; v1(27.45,99.38) 27.45,98.37 C512.2 ; v1(19.1,93.54) 18.98,93.67 U15.2 ; R352.1 128.79,179.46 128.5,179.75 128.5,179.85 v2(128.22,180.13) ; C587.1 C578.2 29.26,31.65 v1(29.69,31.22) ; R752.1 22.23,62.61 v1(21.18,62.61) ; v1(17.11,40.41) 17.14,40.44 C574.2 ; v1(196.59,107.37) 196.85,107.11 EC12.2 ; v1(27.43,28.36) 28.1,28.36 C584.2 ; v1(171.99,136.1) 171.84,136.25 PC7023.2 ; R332.2 123.8,177.38 v1(123.89,177.38) ; R358.1 115.41,183.56 114.87,183.56 v1(114.71,183.72) ; v1(11.19,156.92) 11.26,156.99 C20009.2 ; v1(33.25,47.09) 33.21,47.13 C1648.2 ; C433.1 109.08,182.81 v1(109.08,182.26) ; v1(119.08,209.51) 118.94,209.37 R311.2 ; v1(153.56,216.47) 153.71,216.62 R25644.2 ; C70.1 127.36,152.11 v2(127.16,151.91) ; v2(125.02,112.19) 125.02,113.1 Y2.4 ; v1(68.41,189.58) 68.41,189.26 C558.2 ; PC6013.2 v1(182.88,134.06) ; v1(22.88,60.19) 22.64,60.43 C1645.2 ; C548.2 52.2,191.9 v1(52.2,191.44) 52.2,190.77 52.58,190.39 C547.2 ; C248.1 v1(119.84,101.44) ; PC35.2 PC36.1 159.38,124.73 v1(159.66,124.44) ; v2(162.5,204.42) 162.1,204.02 VRAM2.N3 ; PC9072.2 104.83,186.86 v1(104.89,186.91) ; R1.1 119.95,114.85 v2(119.95,114.23) ; v1(107.64,180.74) 107.64,180.34 R306.1 ; R25385.1 109.65,111 v1(109.65,110.65) 109.08,111.21 C750.1 ; R25642.2 v1(152.12,215.86) ; v1(221.01,122.09) 221.01,122.27 220.95,122.34 220.95,122.34 220.6,122.69 220.59,122.69 220.53,122.75 C737.1
  BOTTOM w0.508: v1(101.89,184.22) 102.23,184.57 PU9003.2 ; CN14.10 73.02,96.95 73.31,96.66 73.5,96.66 v1(73.7,96.47) ; v1(131.83,114.37) 132.59,114.37 132.99,113.98 PU3002.2 ; v1(95.85,187.48) 95.85,187.66 96.26,188.07 PQ9009.1 ; SW5.3 v1(233.96,111.5) ; v1(5.5,36.26) 4.98,36.79 PR283.2 ; v1(224.79,132.81) 224.41,132.43 CN13.6 ; CN49.32 225.25,111.43 v1(226.27,110.41) ; CN55.17 v1(232.59,126.61) ; PJ1.10 97.31,97.92 v1(97.64,98.25) ; v1(6.05,41.42) 6.49,41.85 Q6562.1 ; v1(6.93,31.1) 7.68,31.1 C597.1 ; Q31.1 213.02,118.9 v1(213.69,119.58) ; PC242.2 3.8,32.42 4.27,31.94 4.72,31.94 v1(4.92,31.74) ; v1(43.24,178.01) 43.39,178.16 PC6046.2 ; CN1.2 3.78,10.21 4.27,10.7 v1(4.27,11.31) ; HOLE23.1 4.97,2.5 ; HOLE23.1 7.7,5.13 ; HOLE23.1 10.27,2.5 ; Y3.2 v1(127.27,177.66) ; C692.1 11.1,72.17 D17.2 9.59,72.17 v1(9.2,71.78) ; v1(89.72,199.21) 90.52,198.4 CN63.5 ; v1(14.79,162) 14.79,162.2 14.52,162.46 C96311.1 ; PU3002.4 131.41,112.54 v1(132.23,112.54) ; v1(76.23,105.46) 73.79,105.46 JDIM02.262 ; v1(133.07,97.95) 133.97,97.05 CN33.9 ; v1(200.7,99.3) 201.2,98.8 CN52.18 ; PC756.2 164.78,118.09 v1(165.22,118.52) 165.1,118.64 PC18.1 ; v1(159.63,211.11) 159.01,211.11 C487.2 ; v1(83.96,196.65) C601.2 v1(83.96,198.24) ; CN29.42 77.35,195.14 v1(76.85,194.64) ; CN49.31 v1(225.25,130.32) ; v1(168.48,98.68) 168.36,98.8 CN18.30 ; v1(200.6,108.86) 199.75,109.71 CN48.24 ; v1(108.32,104.75) 108.32,105.23 PC11.2 ; v1(34.14,60.87) 33.9,61.11 C1644.2 ; C20087.1 v1(22.71,56.08) ; PC6028.2 206.17,127.71 v1(205.87,128.01) 205.51,128.37 PC6029.2 ; C504.2 160.93,169.16 v1(161.09,169.32) ; PR9077.2 103.2,191.93 v1(102.77,191.5) ; C383.1 145.19,208.41 v1(145.19,208.66) ; CN55.18 232.75,115.81 v1(232.85,115.72) ; v1(8.77,42.3) 8.61,42.13 R67852.1 ; C499.1 v1(153.94,169.41) ; C473.2 162.66,167.41 v1(161.64,167.41) ; v1(69.77,178.96) 69.77,180.21 PC5021.1 70.15,180.59 PC5001.1 ; v1(18.46,17.88) 18.87,18.28 R470.1 ; v1(33.8,63.42) 33.8,64.07 C1651.2 ; CN63.6 91.92,206.98 v1(93.99,206.98) ; PC10.2 110.7,105.52 v1(110.7,104.75) ; PC6230.2 v1(6.43,40.63) ; PC5010.1 PC5008.2 72.7,186.03 v1(72.44,186.28) ; PC6.1 155.54,114.8 v1(155.94,114.4) ; v1(212.75,108.78) 213.65,109.68 CN48.23 ; JDIM1.261 36.73,172.76 v1(35.28,174.21) ; FAN3.6 173.57,122.53 v1(173.28,122.81) ; v1(184.82,102.44) 184.65,102.61 CN17.77 ; v1(64.64,186.3) 63.65,186.3 SW4.1 ; v1(98.99,183.41) 98.99,184.06 PR9082.1 ; CN52.17 v1(212,96.96) ; v1(222.46,103.28) 222.47,103.3 CN11.21 ; v1(80.39,196.09) v1(80.39,196.75) 80.39,196.75 80.39,196.76 80.44,196.8 C602.2 ; v1(157.33,168.55) 157.64,168.86 C497.1 ; CN18.29 198.02,100.32 v1(197.59,100.75) ; CN33.10 124.36,97.96 v1(124.99,97.96) ; C96312.1 14.31,166.17 v1(14.07,166.4) ; C1647.2 26.33,57.04 v1(26.24,56.95) v1(25.59,56.3) ; v1(84.91,196.65) C604.2 v1(84.91,198.24) ; PC7050.2 157.7,139.78 v1(157.7,140.31) ; v1(118.74,97.99) 118.44,97.7 117.63,97.7 117.41,97.92 PJ1.9 ; Y3.4 v1(123.93,174.94) ; PU7001.9 154.59,143.02 154.38,142.82 v1(154.38,142.54) ; C20088.2 v1(16.14,43.45) ; R406.1 157,192.26 v1(157,193.16) ; CN53.12 v1(215.25,96.77) ; CN19.30 138.42,106.6 139.45,105.57 v1(139.79,105.57) ; v1(222.86,136.93) CN13.1 ; C528.1 220.92,104.14 v1(221.17,103.89) ; v1(137.26,132.53) 137.26,132.51 137.24,132.49 137.24,132.31 137.59,131.96 PR80.2 ; R463.1 v1(13.62,40) ; v1(126.88,206.83) 126.88,207.3 126.38,207.8 C452.1 R325.1 ; FAN3.4 180.45,119.92 v1(179.65,120.72) ; v1(58.02,177.57) 57.59,177.57 56.77,178.38 PC6054.2 ; PD4.2 113.91,107.08 113.59,106.77 v1(113.59,106.35) 114.15,106.35 114.44,106.06 PD3.2 ; v1(154.03,158.78) PU7002.9 ; v1(165.48,120.93) 165.48,120.57 PR23.2 ; PC4.1 159.78,115.4 v1(159.29,115.89) ; C20083.2 v1(16.82,49.52) ; C96326.1 v1(8.94,44.63) ; v1(88.45,198.24) C603.2 v1(88.45,196.65) ; PQ9011.1 v1(101.13,191.22) ; SW4.2 63.45,178.51 v1(63.68,178.28) ; C734.1 v1(212.23,124.32) ; v1(93.59,107.41) 93.59,107.6 94.03,108.04 U3.2 ; CN19.2 166.9,110.66 166.58,110.98 v1(166.58,111.22) ; CN11.23 223.41,107.3 222.3,106.19 v1(222.3,105.38) ; PC6229.1 v1(6.09,39.94) ; v1(229.42,110.67) 229.9,111.15 SW5.4 ; PC16.2 153.32,121.79 v1(153.25,121.72) ; U25.25 v1(40.13,184.81) ; v1(33.42,41.38) 33.2,41.16 C96319.2 C96320.2 ; v1(68.86,98.76) 68.86,96.86 CN58.16 ; PR3021.2 v1(135.47,116.33) ; C20086.1 v1(24.06,55.97) ; C527.1 v1(216.54,104.67) ; v1(173.41,112.12) 174.37,113.08 FAN3.5 ; D13094.2 6.27,30.4 v1(5.78,30.89) ; U18.2 v1(217.35,107.24) ; JDIM1.262 v1(36.73,108.15) ; C1643.2 v1(34.14,60.11)
  vias: v1(1.26,55.4) v1(1.26,54.13) v1(1.26,52.86) v1(1.26,51.59) v1(1.26,50.32) v1(1.26,49.05) v1(1.26,47.78) v1(1.26,46.51) v1(1.26,45.24) v1(1.26,43.97) v1(1.26,35.68) v1(1.26,34.41) v1(1.26,33.14) v1(1.26,31.87) v1(1.34,30.57) v1(1.26,13.38) v1(1.26,12.11) v1(1.26,10.84) v1(1.26,9.57) v1(1.26,8.3) v1(1.85,3.36) v1(2.18,56.28) v1(2.21,36.34) v1(2.26,41.75) v1(2.26,40.48) v1(2.26,39.21) v1(2.26,37.94) v1(2.53,30.51) v1(2.76,116.14) v1(2.76,114.87) v1(3.45,56.28) v1(3.57,138.75) v1(3.64,61.04) v1(3.8,30.48) v1(4.11,98.84) v1(4.36,147.36) v1(4.36,146.09) v1(4.36,144.82) v1(4.36,143.55) v1(4.36,142.28) v1(4.36,141.01) v1(4.36,139.74) v1(4.57,56.88) v1(4.71,59.4) v1(4.78,193.19) v1(4.76,58.13) v1(4.85,203.37) v1(4.91,194.59) v1(4.93,148.5) v1(4.89,47.29) v1(5.08,99.66) v1(5.55,46.35) v1(5.55,47.04) v1(5.66,203.31) v1(5.86,193.86) v1(5.86,164.57) v1(5.9,163.42) v1(5.9,150.59) v1(5.95,71.52) v1(5.86,62.74) v1(6.05,70.68) v1(6.18,194.59) v1(6.25,55.47) v1(6.44,135.94) v1(6.35,99.66) v1(6.53,203.35) v1(6.53,119.02) v1(6.57,114.78) v1(6.95,97.19) v1(7.13,193.86) v1(7.41,194.89) v1(7.52,203.02) v1(7.55,59.76) v1(7.56,96.68) v1(7.7,136.11) v1(7.77,118.78) v1(7.84,114.78) v1(8.06,192.99) v1(8.08,60.09) v1(8.59,146.35) v1(8.59,9.45) v1(8.65,194.6) v1(8.8,156.26) v1(8.77,97.06) v1(9,118.45) v1(9,115.3) v1(9.48,155.19) v1(9.51,153.48) v1(9.45,68.19) v1(9.53,64.87) v1(9.66,195.36) v1(10.02,97.28) v1(10.06,121.81) v1(10.08,118.52) v1(10.08,99.06) v1(10.27,115.38) v1(10.8,6.82) v1(10.88,10.63) v1(10.88,9.36) v1(10.88,8.09) v1(11,53.58) v1(10.99,52.79) v1(11.34,98.94) v1(11.29,97.34) v1(11.51,115.64) v1(11.57,12.1) v1(11.81,146.48) v1(11.85,53.64) v1(11.87,52.85) v1(11.89,52.1) v1(11.89,51.41) v1(11.87,50.71) v1(12.24,155.49) v1(12.2,154.48) v1(12.3,174.39) v1(12.32,55.47) v1(12.43,13.04) v1(12.49,97.76) v1(12.5,78.64) v1(12.63,192.54) v1(12.57,98.6) v1(12.66,177.73) v1(12.71,175.23) v1(12.68,77.97) v1(12.77,115.77) v1(12.84,80.61) v1(13.03,79.04) v1(13.17,190.92) v1(13.21,78.38) v1(13.44,165) v1(13.45,96.92) v1(13.52,172.87) v1(13.51,102.03) v1(13.47,99.49) v1(13.83,115.42) v1(14.28,98.57) v1(14.28,97.81) v1(14.51,152.13) v1(14.94,60.65) v1(14.98,134.17) v1(14.97,13.11) v1(15.14,84.35) v1(15.16,155.48) v1(15.4,97.84) v1(15.55,128.29) v1(15.62,58.94) v1(16.24,13.11) v1(16.64,70.07) v1(16.64,68.99) v1(16.64,67.91) v1(16.78,137.51) v1(16.78,136.85) v1(17.04,129.2) v1(17.04,128.03) v1(17.04,127.29) v1(17.02,126.12) v1(17.03,125.44) v1(17.04,124.25) v1(17.12,169.57) v1(17.06,123.57) v1(17.22,194.79) v1(17.24,194.07) v1(17.16,142.05) v1(17.26,105.36) v1(17.47,152) v1(17.52,121.75) v1(17.51,13.11) v1(17.6,140.03) v1(17.66,70.07) v1(17.66,68.99) v1(17.66,67.91) v1(17.8,174.26) v1(17.77,83.19) v1(17.93,62.53) v1(17.99,65.21) v1(17.98,33.73) v1(17.99,32.41) v1(18.01,31.01) v1(18.11,175.79) v1(18.06,167.94) v1(18.06,166.98) v1(18.06,166.01) v1(18.06,165.05) v1(18.06,164.08) v1(18.19,174.87) v1(18.24,158.68) v1(18.23,56.46) v1(18.37,96.39) v1(18.41,14.01) v1(18.49,97.51) v1(18.61,155.63) v1(18.57,109.62) v1(18.67,70.07) v1(18.67,68.99) v1(18.67,67.91) v1(18.69,62.53) v1(18.77,176.41) v1(18.8,86.24) v1(18.9,174.86) v1(18.88,56.4) v1(19.03,167.94) v1(19.03,166.98) v1(19.03,166.01) v1(19.03,165.05) v1(19.03,164.08) v1(18.98,96.92) v1(19.07,142.45) v1(19.07,141.76) v1(19.09,140.51) v1(19.1,67.23) v1(19.21,97.56) v1(19.33,109.54) v1(19.34,108.86) v1(19.31,14.91) v1(19.36,153.42) v1(19.43,96.42) v1(19.54,176.4) v1(19.6,159.87) v1(19.61,32.41) v1(19.61,30.95) v1(19.69,70.07) v1(19.69,68.99) v1(19.69,67.91) v1(19.65,33.75) v1(19.77,51.3) v1(19.77,49.98) v1(19.77,48.66) v1(19.77,47.34) v1(20.05,194.49) v1(19.99,167.94) v1(19.99,166.98) v1(19.99,166.01) v1(19.99,165.05) v1(19.99,164.08) v1(20.21,160.23) v1(20.2,15.8) v1(20.31,154.21) v1(20.37,56.36) v1(20.54,86.73) v1(20.49,84.66) v1(20.53,74.65) v1(20.55,89.4) v1(20.71,134.43) v1(20.7,70.07) v1(20.7,68.99) v1(20.7,67.91) v1(20.8,194.5) v1(20.88,152.96) v1(20.96,167.94) v1(20.96,166.98) v1(20.96,166.01) v1(20.96,165.05) v1(20.96,164.08) v1(21.1,51.3) v1(21.1,49.98) v1(21.1,48.66) v1(21.1,47.34) v1(21.1,16.7) v1(21.24,76.02) v1(21.18,56.31) v1(21.28,33.75) v1(21.26,32.42) v1(21.26,30.97) v1(21.44,104.35) v1(21.54,156.21) v1(21.54,64.94) v1(21.58,132.36) v1(21.92,167.94) v1(21.92,166.98) v1(21.92,166.01) v1(21.92,165.05) v1(21.92,164.08) v1(21.86,56.26) v1(21.95,17.48) v1(22.3,75.99) v1(22.42,51.3) v1(22.42,49.98) v1(22.42,48.66) v1(22.42,47.34) v1(22.48,134.45) v1(22.85,18.38) v1(22.9,197.22) v1(22.86,152.62) v1(23.14,84.91) v1(23.22,151.09) v1(23.2,39.63) v1(23.74,51.3) v1(23.74,49.98) v1(23.74,48.66) v1(23.74,47.34) v1(23.75,19.27) v1(23.88,157.05) v1(23.89,156.39) v1(23.93,39.64) v1(23.98,132.21) v1(24.13,95.53) v1(24.17,197.22) v1(24.32,70.07) v1(24.41,94.51) v1(24.58,157.07) v1(24.56,156.4) v1(24.62,95.98) v1(24.64,20.17) v1(24.67,154.12) v1(24.98,77.51) v1(25.02,76.82) v1(25.04,75.53) v1(25.44,197.22) v1(25.54,21.07) v1(25.6,85.34) v1(25.88,152.32) v1(26.11,151.39) v1(26.15,143.98) v1(26.31,105.76) v1(26.41,132.19) v1(26.44,21.97) v1(26.54,152.98) v1(26.49,84.04) v1(26.49,63.84) v1(26.71,197.22) v1(26.8,163.9) v1(27.27,142.37) v1(27.26,36.75) v1(27.34,22.87) v1(27.69,165.27) v1(27.95,37.57) v1(27.98,197.22) v1(28.24,23.76) v1(28.53,195.63) v1(28.54,61.14) v1(28.54,60.48) v1(28.49,38.01) v1(28.82,132.27) v1(29.11,38.33) v1(29.2,61.8) v1(29.2,61.14) v1(29.2,60.48) v1(29.25,197.22) v1(29.41,153.44) v1(29.44,151.79) v1(29.56,99.46) v1(29.86,61.8) v1(29.86,61.14) v1(29.86,60.48) v1(30.28,152.68) v1(30.52,197.22) v1(30.75,83.28) v1(31.13,153.39) v1(31.12,151.75) v1(31.34,163.85) v1(31.32,163.14) v1(31.55,99.34) v1(31.79,197.22) v1(31.91,195.6) v1(32.99,135.13) v1(32.99,134.47) v1(33.02,67.81) v1(33.06,197.22) v1(33.42,76.3) v1(33.42,75.57) v1(33.48,55.13) v1(33.69,195.6) v1(33.69,76.99) v1(33.81,69.01) v1(33.81,68.34) v1(33.81,67.68) v1(33.81,67.02) v1(34.16,163.34) v1(34.17,25.09) v1(34.33,197.22) v1(34.46,194.91) v1(34.53,85.33) v1(34.6,190.63) v1(34.59,83.2) v1(35.22,25.8) v1(35.34,68.98) v1(35.34,67.71) v1(35.34,66.44) v1(35.34,65.17) v1(35.34,63.9) v1(35.34,62.63) v1(35.34,61.36) v1(35.34,60.09) v1(35.34,58.82) v1(35.34,57.55) v1(35.34,48.66) v1(35.34,46.12) v1(35.34,43.58) v1(35.34,41.04) v1(35.34,38.5) v1(35.34,35.96) v1(35.34,33.42) v1(35.34,32.15) v1(35.34,30.88) v1(35.34,29.61) v1(35.34,28.34) v1(35.34,27.07) v1(35.6,197.25) v1(35.76,194.5) v1(35.78,163.34) v1(35.81,70.16) v1(35.86,140.74) v1(35.9,97.76) v1(36.33,190.81) v1(36.49,151.79) v1(36.54,149.67) v1(36.61,140.75) v1(36.71,71.08) v1(36.84,86.29) v1(36.84,85.02) v1(36.84,83.75) v1(36.84,82.48) v1(36.84,81.21) v1(36.84,79.94) v1(36.84,78.67) v1(36.84,77.4) v1(36.84,76.13) v1(36.84,74.86) v1(36.84,73.59) v1(36.84,72.32) v1(36.99,190.79) v1(37.03,156.49) v1(36.99,155.3) v1(37.12,154.17) v1(37.36,190.21) v1(37.66,190.8) v1(38.49,163.8) v1(38.49,163.14) v1(38.49,162.48) v1(38.71,134.86) v1(38.69,134.16) v1(38.68,124.68) v1(38.92,122.51) v1(39.83,89.13) v1(41.1,89.13) v1(42.37,89.13) v1(43.33,124.81) v1(43.28,113.79) v1(43.62,187.65) v1(43.64,89.13) v1(43.79,98.29) v1(44.43,187.37) v1(44.94,98.4) v1(44.91,89.13) v1(45.31,202.04) v1(45.64,188.04) v1(45.6,98.4) v1(45.7,102.7) v1(45.91,167.33) v1(45.93,159.81) v1(45.95,147.32) v1(45.93,121.88) v1(45.91,116.32) v1(45.93,107.78) v1(46.01,171.35) v1(45.98,169.39) v1(45.97,165.57) v1(45.99,162.91) v1(45.95,161.84) v1(45.95,154.84) v1(46,151.15) v1(46,148.07) v1(45.95,146.4) v1(45.95,123.7) v1(45.99,113.37) v1(45.97,112.35) v1(45.99,111.32) v1(45.95,108.84) v1(46.16,110.05) v1(46.18,89.13) v1(46.31,170.3) v1(46.26,98.4) v1(46.35,188.04) v1(46.46,140.9) v1(46.5,137.61) v1(46.5,120.73) v1(46.64,163.17) v1(46.63,141.94) v1(46.57,136.35) v1(46.76,102.67) v1(46.92,133.53) v1(46.95,123.32) v1(46.92,98.4) v1(46.97,107.12) v1(47.09,188.04) v1(47.12,153.62) v1(47.06,152.13) v1(47.09,131.21) v1(47.25,167.35) v1(47.2,161.84) v1(47.22,156.42) v1(47.25,121.89) v1(47.25,107.78) v1(47.29,165.56) v1(47.34,157.89) v1(47.3,154.86) v1(47.3,125.09) v1(47.25,118.32) v1(47.25,116.44) v1(47.32,113.37) v1(47.31,111.34) v1(47.45,89.13) v1(47.85,202.04) v1(47.8,142.89) v1(47.81,106.75) v1(47.92,137.68) v1(47.92,136.37) v1(47.86,119.35) v1(47.97,169.22) v1(48.15,126.18) v1(48.25,115.15) v1(48.5,116.72) v1(48.72,127.96) v1(48.72,89.13) v1(48.77,163.85) v1(48.77,110.11) v1(48.87,140.07) v1(49,170.1) v1(49.12,202.04) v1(49.1,107.08) v1(49.23,142.13) v1(49.33,131.09) v1(49.28,130.02) v1(49.36,154.23) v1(49.41,138.77) v1(49.38,124.84) v1(49.63,133.02) v1(49.74,159.84) v1(49.74,118.98) v1(49.84,161.41) v1(49.9,165.04) v1(49.86,144.37) v1(49.92,121.73) v1(49.98,157.78) v1(50.02,150.8) v1(49.96,116.68) v1(49.99,89.13) v1(50.1,167.27) v1(50.15,156.18) v1(50.23,113.07) v1(50.23,110.88) v1(50.23,107.93) v1(50.32,170.35) v1(50.39,202.04) v1(50.45,152.15) v1(50.45,140.05) v1(50.5,132.36) v1(50.6,128.17) v1(50.73,154.17) v1(50.7,129.92) v1(50.74,126.23) v1(50.77,169.25) v1(50.75,164.09) v1(50.8,135.32) v1(50.84,115.1) v1(51.13,159.84) v1(51.11,152.13) v1(51.25,145.34) v1(51.34,150.86) v1(51.26,128.17) v1(51.26,89.13) v1(51.42,167.27) v1(51.43,165.06) v1(51.41,164.12) v1(51.46,161.03) v1(51.52,156.38) v1(51.55,149.56) v1(51.55,148.56) v1(51.53,123.77) v1(51.54,121.55) v1(51.52,118.88) v1(51.47,116.69) v1(51.55,113.06) v1(51.55,110.87) v1(51.55,107.88) v1(51.66,202.04) v1(52.13,134.42) v1(52.53,89.13) v1(52.82,134.46) v1(53.34,183.13) v1(53.32,108.38) v1(53.5,134.46) v1(53.82,202.98) v1(53.8,89.13) v1(53.86,206.79) v1(53.86,205.52) v1(53.86,204.25) v1(54.23,106.07) v1(54.44,115.22) v1(54.5,117.69) v1(54.49,112.15) v1(54.58,170.49) v1(54.63,167.22) v1(54.63,165.18) v1(54.63,161.88) v1(54.63,159.85) v1(54.63,156.93) v1(54.63,154.76) v1(54.58,150.67) v1(54.63,149.69) v1(54.6,123.44) v1(54.62,113.99) v1(54.58,108.69) v1(54.57,97.98) v1(54.66,125.43) v1(54.89,206.85) v1(55.14,147.48) v1(55.07,89.13) v1(55.17,171.51) v1(55.24,170.49) v1(55.24,150.66) v1(55.16,117.67) v1(55.15,112.15) v1(55.24,108.68) v1(55.23,97.98) v1(55.34,167.21) v1(55.29,165.18) v1(55.29,156.95) v1(55.29,154.76) v1(55.29,149.69) v1(55.29,126.72) v1(55.26,123.46) v1(55.25,118.51) v1(55.69,103.29) v1(55.84,187.89) v1(56.1,103.82) v1(56.16,206.85) v1(56.34,89.13) v1(56.53,103.29) v1(56.93,103.82) v1(57.43,206.85) v1(57.39,171.86) v1(57.61,89.13) v1(57.91,164.09) v1(57.91,162.11) v1(57.93,159.85) v1(57.93,158.5) v1(57.93,156.91) v1(57.93,152.43) v1(57.93,151.13) v1(57.92,129.74) v1(57.93,126.82) v1(57.91,121.81) v1(57.91,117.96) v1(57.97,169.58) v1(58.04,124.97) v1(58.06,120.2) v1(58.12,113.74) v1(58.1,108.64) v1(58.22,123.47) v1(58.58,168.37) v1(58.59,158.49) v1(58.62,115.37) v1(58.61,111.62) v1(58.7,206.85) v1(58.68,172.06) v1(58.71,147.14) v1(58.79,165.75) v1(58.81,154.44) v1(58.77,105.84) v1(58.88,89.13) v1(59.22,161.87) v1(59.25,159.85) v1(59.25,156.93) v1(59.25,151.13) v1(59.23,121.82) v1(59.23,117.96) v1(59.26,126.84) v1(59.36,124.99) v1(59.44,113.74) v1(59.62,143.93) v1(59.81,158.63) v1(59.89,129.7) v1(59.97,206.85) v1(60.03,147.12) v1(60.11,165.77) v1(60.14,137.12) v1(60.25,178.37) v1(60.22,107.96) v1(60.15,89.13) v1(60.52,152.43) v1(60.54,133.82) v1(60.67,120.2) v1(60.76,113.75) v1(61.03,143.93) v1(61.14,206.9) v1(61.09,136.24) v1(61.22,111.47) v1(61.21,105.88) v1(61.44,168.58) v1(61.44,165.8) v1(61.35,147.13) v1(61.42,89.13) v1(61.53,154.38) v1(61.58,109.82) v1(61.57,108.18) v1(61.66,162.67) v1(61.68,115.36) v1(61.8,160.1) v1(61.92,156.55) v1(61.94,133.84) v1(61.88,129.67) v1(61.93,117.96) v1(62.03,185.49) v1(61.98,182.58) v1(62.02,139.11) v1(62.15,132.5) v1(62.12,123.48) v1(62.19,151.17) v1(62.2,126.91) v1(62.19,121.21) v1(62.41,206.9) v1(62.41,189.43) v1(62.49,187.68) v1(62.47,131.11) v1(62.54,111.47) v1(62.53,105.89) v1(62.69,89.13) v1(62.77,172.21) v1(62.92,147.47) v1(62.89,109.69) v1(62.99,162.66) v1(63,115.37) v1(63.12,160.07) v1(63.24,129.66) v1(63.25,117.94) v1(63.44,123.48) v1(63.52,156.55) v1(63.46,154.28) v1(63.51,151.19) v1(63.52,126.89) v1(63.54,121.23) v1(63.68,206.9) v1(63.96,89.13) v1(64.21,172.31) v1(64.42,189.69) v1(64.95,206.9) v1(65.23,89.13) v1(66.13,105.26) v1(66.22,206.9) v1(66.21,117.94) v1(66.5,89.13) v1(66.73,147.41) v1(66.78,149.14) v1(67.49,206.9) v1(67.77,89.13) v1(68,192.07) v1(68.76,206.9) v1(69.04,89.13) v1(69.57,188.47) v1(70.03,206.9) v1(70.2,188.7) v1(70.31,89.13) v1(71.45,206.93) v1(71.58,89.13) v1(71.69,175.68) v1(72.35,175.63) v1(72.72,206.93) v1(72.85,89.13) v1(73.99,206.93) v1(74.12,89.13) v1(74.89,189.51) v1(75.26,206.93) v1(75.31,188.99) v1(75.39,89.13) v1(75.74,189.61) v1(75.98,189) v1(76.53,206.93) v1(76.66,89.13) v1(76.78,178.87) v1(77.47,178.87) v1(77.8,206.93) v1(77.93,89.13) v1(79.07,206.93) v1(79.12,92.26) v1(79.06,90.99) v1(79.06,89.72) v1(80.06,96.8) v1(80.14,93.05) v1(80.82,96.8) v1(81.41,93.06) v1(81.51,141.91) v1(81.99,142.36) v1(82.38,141.8) v1(82.46,142.82) v1(82.68,93.06) v1(83.95,93.06) v1(84.24,190.48) v1(85.22,93.06) v1(85.47,184.78) v1(85.84,183.98) v1(86.32,98.07) v1(86.27,96.85) v1(86.44,191.49) v1(86.49,93.06) v1(86.75,184.7) v1(86.69,183.05) v1(87,96.85) v1(87.33,191.84) v1(87.66,194.15) v1(87.66,193.49) v1(87.81,98.07) v1(87.76,96.85) v1(87.76,93.06) v1(87.86,195.37) v1(88.37,194.15) v1(88.37,193.49) v1(88.7,167.34) v1(89.03,93.06) v1(89.36,167.34) v1(89.72,164.84) v1(90.02,167.34) v1(90.3,93.06) v1(91.57,93.06) v1(91.88,178.02) v1(92.46,177.66) v1(92.61,98.25) v1(92.84,93.06) v1(92.99,178.06) v1(93.25,141.72) v1(93.27,98.25) v1(93.9,184.79) v1(94.05,184.13) v1(94.11,182.45) v1(94.11,93.06) v1(94.62,162.18) v1(94.78,160.6) v1(95.2,163.72) v1(95.26,206.98) v1(95.38,93.06) v1(95.82,132.52) v1(95.94,162.19) v1(96.1,160.59) v1(96.5,159.2) v1(96.65,93.06) v1(97.26,162.18) v1(97.42,160.6) v1(97.95,182.65) v1(97.92,93.06) v1(98.14,182.02) v1(98.98,165.79) v1(99.09,181.94) v1(99.19,207.89) v1(99.19,93.06) v1(99.64,165.79) v1(99.83,204.64) v1(100.09,208.81) v1(100.5,195.89) v1(100.46,93.06) v1(101.01,209.71) v1(101.09,173.4) v1(101.54,196.91) v1(101.49,195.99) v1(101.49,194.77) v1(101.55,173.88) v1(101.71,174.52) v1(101.73,93.06) v1(101.89,210.61) v1(102.04,173.43) v1(102.53,196.02) v1(102.75,106.72) v1(102.78,211.48) v1(103,93.06) v1(103.43,172.18) v1(103.49,115.82) v1(103.46,106.75) v1(103.68,212.41) v1(104.15,115.82) v1(104.19,153.26) v1(104.27,93.06) v1(104.58,213.28) v1(105.48,214.2) v1(105.54,93.06) v1(105.96,174.7) v1(106.05,188.08) v1(106.38,215.1) v1(106.72,188.09) v1(106.81,93.06) v1(107.05,174.66) v1(106.96,160.12) v1(107.28,216) v1(108.13,194.97) v1(108.13,194.08) v1(108.08,93.06) v1(108.17,216.9) v1(108.61,144.09) v1(108.64,143.45) v1(108.64,142.82) v1(108.61,142.18) v1(108.61,139.59) v1(108.74,138.96) v1(108.84,194.97) v1(108.84,194.08) v1(109.07,217.79) v1(109.35,93.06) v1(109.53,194.97) v1(109.53,194.08) v1(109.97,218.69) v1(110.29,194.97) v1(110.29,194.08) v1(110.42,193.32) v1(110.62,93.06) v1(110.95,194.97) v1(110.95,194.08) v1(111.24,218.74) v1(111.62,101.13) v1(111.62,100.47) v1(111.89,93.06) v1(112.28,101.13) v1(112.28,100.47) v1(112.51,218.74) v1(112.6,104.31) v1(112.94,101.13) v1(112.94,100.47) v1(113.06,170.58) v1(113.06,169.92) v1(113.06,169.26) v1(113.06,168.6) v1(113.16,93.06) v1(113.6,101.13) v1(113.6,100.47) v1(113.78,218.74) v1(114,217.67) v1(114.38,136.34) v1(114.43,93.06) v1(115.05,218.74) v1(115.17,207.02) v1(115.62,169.95) v1(115.67,170.61) v1(115.67,169.29) v1(115.67,168.63) v1(115.7,93.06) v1(115.85,207.03) v1(116.32,218.74) v1(116.46,150.07) v1(116.58,150.7) v1(116.67,147.04) v1(116.97,93.06) v1(117.3,172) v1(117.59,218.74) v1(118.24,93.06) v1(118.92,172) v1(119.13,173.83) v1(119.51,93.06) v1(120.78,93.06) v1(121.82,210.84) v1(121.89,208.09) v1(121.96,93.53) v1(122.93,94.34) v1(123.27,208.02) v1(123.92,210.51) v1(124.18,172.23) v1(124.2,94.36) v1(124.95,172.23) v1(124.92,104.8) v1(125.47,94.36) v1(125.58,104.8) v1(126.22,172.23) v1(126.24,104.8) v1(126.74,94.36) v1(126.86,116.02) v1(126.98,172.23) v1(127.54,161.83) v1(127.53,161.15) v1(127.46,131.26) v1(127.91,172.23) v1(128.01,94.36) v1(128.12,131.28) v1(128.67,172.23) v1(128.71,148.26) v1(129.16,214.39) v1(129.16,213.73) v1(129.28,94.36) v1(129.4,123.82) v1(129.5,217.2) v1(129.87,212.81) v1(130.16,217.2) v1(130.29,218.74) v1(130.55,94.36) v1(130.82,217.2) v1(131.48,217.2) v1(131.56,218.74) v1(131.82,94.36) v1(131.93,135.45) v1(132.16,217.22) v1(132.33,134.66) v1(132.7,211.63) v1(132.83,218.74) v1(132.8,208.25) v1(132.85,209.4) v1(133,140.55) v1(133.09,94.36) v1(133.2,134.74) v1(133.36,211.63) v1(133.44,119.66) v1(133.51,209.4) v1(133.46,208.25) v1(133.56,156.14) v1(133.56,118.11) v1(133.66,140.71) v1(133.84,117.98) v1(133.93,119.13) v1(134.02,211.63) v1(134.02,134.56) v1(134.1,218.74) v1(134.09,162.15) v1(134.11,119.77) v1(134.22,156.14) v1(134.3,140.95) v1(134.41,118.63) v1(134.36,94.36) v1(134.88,156.14) v1(134.91,141.28) v1(134.87,118.15) v1(135.3,140.74) v1(135.32,134.65) v1(135.37,218.74) v1(135.36,139.77) v1(135.54,156.14) v1(135.46,141.7) v1(135.6,133.99) v1(135.63,94.22) v1(135.77,174.69) v1(135.85,141.17) v1(135.98,142.24) v1(136.02,134.62) v1(136.35,140.73) v1(136.31,93.15) v1(136.43,174.69) v1(136.37,142.82) v1(136.51,141.37) v1(136.64,218.74) v1(136.61,142.07) v1(136.68,143.41) v1(136.89,209.41) v1(136.9,208.24) v1(137.55,209.41) v1(137.56,208.24) v1(137.58,93.06) v1(137.7,110.71) v1(137.91,218.74) v1(138.1,111.23) v1(138.52,110.71) v1(138.85,93.06) v1(138.88,156.12) v1(139.06,132.72) v1(139.06,132.06) v1(139.18,218.74) v1(139.68,156.21) v1(140.12,93.06) v1(140.34,121.15) v1(140.45,218.74) v1(140.53,208.87) v1(141.19,208.87) v1(141.3,150.64) v1(141.39,93.06) v1(141.72,218.74) v1(141.66,161.72) v1(141.66,161.06) v1(141.66,160.4) v1(141.84,135.19) v1(141.89,134.49) v1(141.96,150.64) v1(141.96,149.98) v1(142.32,161.67) v1(142.32,161.01) v1(142.32,160.35) v1(142.26,145.16) v1(142.4,148.38) v1(142.71,146.64) v1(142.66,145.96) v1(142.66,93.06) v1(142.92,145.16) v1(142.99,218.74) v1(143,207.77) v1(142.98,162.33) v1(142.98,161.67) v1(142.98,161.01) v1(142.98,160.35) v1(143.26,211.42) v1(143.64,162.33) v1(143.64,161.67) v1(143.64,161.01) v1(143.64,160.35) v1(143.93,93.06) v1(144.26,218.74) v1(144.3,162.33) v1(144.3,161.67) v1(144.3,161.01) v1(144.3,160.35) v1(144.3,159.61) v1(144.96,162.33) v1(144.96,161.67) v1(144.96,161.01) v1(144.96,160.35) v1(145.14,215.74) v1(145.14,215.08) v1(145.2,93.06) v1(145.53,218.74) v1(145.7,213.17) v1(145.7,212.51) v1(145.67,210.69) v1(145.78,217.19) v1(146.31,204.01) v1(146.44,217.19) v1(146.36,213.17) v1(146.36,212.51) v1(146.47,93.06) v1(146.64,208.03) v1(146.61,183.99) v1(146.8,218.74) v1(146.76,207.06) v1(147.04,205.57) v1(146.96,204.27) v1(147.27,184.02) v1(147.74,93.06) v1(147.98,184.02) v1(148.07,218.74) v1(148.33,183.38) v1(148.69,184.02) v1(148.67,126.92) v1(148.87,151) v1(148.87,150.34) v1(149.01,93.06) v1(149.23,126.56) v1(149.34,218.74) v1(149.38,184.02) v1(149.53,151) v1(149.53,150.34) v1(149.51,135.18) v1(149.51,134.52) v1(149.76,158.75) v1(150.12,158.16) v1(150.12,157.5) v1(150.19,151) v1(150.19,150.34) v1(150.17,135.18) v1(150.17,134.52) v1(150.28,93.06) v1(150.45,156.92) v1(150.61,218.74) v1(150.78,158.16) v1(150.78,157.5) v1(150.83,135.23) v1(150.83,134.57) v1(150.85,151) v1(150.85,150.34) v1(151.11,156.92) v1(151.14,146.35) v1(151.14,145.69) v1(151.11,117.24) v1(151.18,133.93) v1(151.44,158.16) v1(151.44,157.5) v1(151.51,151) v1(151.51,150.34) v1(151.49,135.23) v1(151.49,134.57) v1(151.55,93.06) v1(151.61,165.75) v1(151.63,163.98) v1(151.59,156.44) v1(151.66,163.29) v1(151.8,146.35) v1(151.8,145.69) v1(151.84,133.93) v1(151.88,218.74) v1(151.92,124.08) v1(152.02,164.74) v1(152.15,135.23) v1(152.15,134.57) v1(152.17,151) v1(152.17,150.34) v1(152.27,165.75) v1(152.29,163.98) v1(152.32,163.29) v1(152.25,156.44) v1(152.3,135.87) v1(152.46,146.35) v1(152.46,145.69) v1(152.5,133.93) v1(152.81,135.23) v1(152.81,134.57) v1(152.82,93.06) v1(152.91,156.44) v1(152.96,135.87) v1(153.15,218.74) v1(153.06,142.54) v1(153.06,141.88) v1(153.06,141.22) v1(153.55,116.4) v1(153.62,135.86) v1(153.72,142.54) v1(153.72,141.88) v1(153.72,141.22) v1(154.09,93.06) v1(154.21,152.57) v1(154.28,135.86) v1(154.42,218.74) v1(154.38,141.88) v1(154.38,141.22) v1(155.04,142.54) v1(155.04,141.88) v1(155.04,141.22) v1(155.36,93.06) v1(155.69,218.74) v1(155.91,141.68) v1(156.63,93.06) v1(156.96,218.74) v1(157.76,132.34) v1(157.94,218.72) v1(157.9,93.06) v1(158.42,132.34) v1(158.69,134.08) v1(158.91,133.4) v1(159.17,93.06) v1(159.34,133.97) v1(159.72,116.91) v1(160.04,116.08) v1(160.2,130.3) v1(160.2,129.64) v1(160.35,187.95) v1(160.3,186.33) v1(160.44,93.06) v1(160.63,130.98) v1(160.86,130.3) v1(160.86,129.64) v1(161.03,187.94) v1(161.19,186.05) v1(161.52,130.3) v1(161.52,129.64) v1(161.72,187.93) v1(161.71,93.06) v1(161.75,151.91) v1(161.95,186.05) v1(162.21,144.68) v1(162.21,143.46) v1(162.21,142.24) v1(162.21,141.02) v1(162.97,154.33) v1(162.98,93.06) v1(163.43,144.68) v1(163.43,143.46) v1(163.43,142.24) v1(163.43,141.02) v1(164.25,93.06) v1(164.65,144.68) v1(164.65,143.46) v1(164.65,142.24) v1(164.65,141.02) v1(165.52,93.06) v1(165.79,145.54) v1(165.9,144.68) v1(165.9,143.46) v1(165.9,142.24) v1(165.9,141.02) v1(166.79,93.06) v1(167.03,211.19) v1(167.03,209.92) v1(167.03,208.65) v1(167.03,207.38) v1(167.03,206.11) v1(167.03,204.84) v1(167.03,203.57) v1(167.03,202.3) v1(167.03,201.03) v1(167.03,199.76) v1(167.03,198.49) v1(167.03,197.22) v1(167.03,195.95) v1(167.9,194.54) v1(168.06,93.06) v1(169.24,194.34) v1(169.24,193.07) v1(169.24,191.8) v1(169.24,190.53) v1(169.24,189.26) v1(169.24,187.99) v1(169.24,186.72) v1(169.24,185.45) v1(169.24,184.18) v1(169.24,182.91) v1(169.24,181.64) v1(169.24,180.37) v1(169.24,179.1) v1(169.24,177.83) v1(169.24,176.56) v1(169.24,175.29) v1(169.24,174.02) v1(169.24,172.75) v1(169.24,171.48) v1(169.24,170.21) v1(169.24,168.94) v1(169.25,167.67) v1(169.27,166.4) v1(169.33,93.06) v1(169.37,165.14) v1(169.51,163.87) v1(169.56,117.06) v1(169.73,162.62) v1(169.97,161.37) v1(170.25,160.13) v1(170.58,158.91) v1(170.6,93.06) v1(170.96,157.69) v1(171.32,116.55) v1(171.38,156.5) v1(171.6,142.11) v1(171.68,140.85) v1(171.84,155.31) v1(171.79,143.37) v1(171.87,93.06) v1(172.05,139.63) v1(171.99,125.27) v1(172.16,97.58) v1(172.35,154.15) v1(172.26,144.55) v1(172.66,138.52) v1(172.66,131.34) v1(172.82,97.58) v1(172.9,153) v1(172.97,145.63) v1(173.14,93.06) v1(173.49,151.88) v1(173.51,137.58) v1(173.85,146.52) v1(174.12,150.78) v1(174.26,115.58) v1(174.41,93.06) v1(174.55,136.84) v1(174.74,147.42) v1(174.8,149.7) v1(174.76,97.58) v1(175.33,148.55) v1(175.33,117.02) v1(175.42,97.58) v1(175.72,136.34) v1(175.68,93.06) v1(176.95,93.06) v1(176.97,136.12) v1(177.17,126.31) v1(177.43,116.66) v1(177.59,97.84) v1(177.96,126.72) v1(178.23,136.17) v1(178.25,97.84) v1(178.22,93.06) v1(178.91,97.84) v1(179.46,136.51) v1(179.49,93.06) v1(180.1,97.9) v1(180.58,137.1) v1(180.78,97.89) v1(180.76,93.06) v1(181.7,137.71) v1(182.03,93.06) v1(182.45,97.81) v1(182.87,137.28) v1(183.3,93.06) v1(183.99,136.64) v1(184.13,97.96) v1(184.57,93.06) v1(184.79,97.96) v1(185.09,136.01) v1(185.09,123.65) v1(185.45,97.96) v1(185.75,123.65) v1(185.84,93.06) v1(186.19,135.37) v1(186.94,102.39) v1(186.95,97.96) v1(187.11,93.06) v1(187.18,106.66) v1(187.29,134.74) v1(187.61,97.96) v1(188.29,106.27) v1(188.27,97.96) v1(188.39,134.1) v1(188.38,93.06) v1(188.86,109.14) v1(189.06,102.39) v1(189.52,133.52) v1(189.65,93.06) v1(189.79,106.24) v1(189.92,126.25) v1(190.22,109.19) v1(190.58,126.25) v1(190.75,133.21) v1(190.76,97.96) v1(190.92,93.06) v1(191.24,126.25) v1(191.42,97.96) v1(192.02,133.25) v1(192.08,97.96) v1(192.19,93.06) v1(193.04,98.19) v1(193.24,133.61) v1(193.49,102.63) v1(193.46,93.06) v1(194.15,102.63) v1(194.48,133.86) v1(194.73,93.06) v1(194.81,102.63) v1(195.02,105.1) v1(195.02,104.44) v1(195.7,133.5) v1(196,93.06) v1(196.77,117.78) v1(196.93,133.18) v1(197.27,93.06) v1(198.17,132.9) v1(198.54,93.06) v1(199.42,132.66) v1(199.68,130.87) v1(199.71,92.56) v1(200.01,127.11) v1(199.96,91.32) v1(199.96,90.05) v1(200.34,130.87) v1(200.65,129.65) v1(200.67,132.47) v1(200.67,127.13) v1(200.84,89.13) v1(201,130.87) v1(201.93,132.32) v1(202.11,89.13) v1(203.2,132.22) v1(203.38,89.13) v1(203.71,115.39) v1(204.11,124.96) v1(204.47,132.16) v1(204.65,89.13) v1(205.03,130.58) v1(205.39,115.41) v1(205.74,132.15) v1(205.92,130.59) v1(205.92,89.13) v1(206.4,96.04) v1(206.71,117.37) v1(207.01,132.18) v1(207.19,89.13) v1(207.97,97.17) v1(208.27,132.25) v1(208.46,89.13) v1(208.84,117.42) v1(209.54,132.37) v1(209.73,89.13) v1(210.8,132.54) v1(211,89.13) v1(212.27,89.13) v1(213.54,89.13) v1(214.81,89.13) v1(216.08,89.13) v1(217.35,89.13) v1(218.18,135.62) v1(218.58,119.89) v1(218.62,89.13) v1(219.16,136.42) v1(219.23,107.62) v1(219.33,108.81) v1(219.79,107.98) v1(219.86,107.32) v1(219.89,89.13) v1(220.48,134.64) v1(220.68,119.83) v1(220.72,111.55) v1(221.14,138.02) v1(221.16,89.13) v1(222.12,138.82) v1(222.43,89.13) v1(223.7,89.13) v1(223.88,119.3) v1(224.51,135.54) v1(225,110.69) v1(224.97,89.13) v1(226.14,101.39) v1(226.24,89.13) v1(226.83,110.82) v1(226.91,139.79) v1(227.39,138.61) v1(227.39,137.34) v1(227.39,136.07) v1(227.39,134.8) v1(227.39,133.53) v1(227.39,132.26) v1(227.39,130.99) v1(227.51,89.13) v1(227.84,129.8) v1(228.04,99.17) v1(228.25,102.08) v1(228.7,104.21) v1(228.76,99.16) v1(228.91,102.08) v1(229.07,129.49) v1(229.72,108.28) v1(229.72,107.51) v1(229.72,106.75) v1(229.72,106.09) v1(229.77,122.04) v1(229.86,98.3) v1(230.34,129.49) v1(230.62,98.82) v1(230.91,94.69) v1(230.99,121.03) v1(231.09,105.58) v1(231.61,129.49) v1(232.57,118.89) v1(232.62,105.58) v1(232.88,129.49) v1(233.12,95.37) v1(233.33,118.89) v1(234.15,129.49) v1(235.42,129.49) v1(236.69,129.35) v1(236.69,128.08) v1(236.69,126.81) v1(236.74,125.35) v1(236.74,124.08) v1(236.74,122.81) v1(236.74,121.54) v1(236.74,120.27) v1(236.74,119) v1(236.74,117.73) v1(236.74,116.46) v1(236.74,115.19) v1(236.74,113.92) v1(236.74,112.65) v1(236.74,111.38) v1(236.74,110.11) v1(236.74,108.84) v1(236.74,107.57) v1(236.74,106.3) v1(236.74,105.03) v1(236.74,103.76) v1(236.74,102.49) v1(236.74,101.22) v1(236.74,99.95) v1(236.74,98.68) v2(91.95,135.56) v2(93.01,171.9) v2(93.06,145.3) v2(93.21,152.12) v2(93.29,171.35) v2(93.36,153.79) v2(93.42,136.6) v2(93.46,147.71) v2(93.78,154.97) v2(93.97,144.06) v2(94.04,138.31) v2(94.42,149.48) v2(94.42,139.9) v2(94.78,147.74) v2(94.89,145.35) v2(95,171.17) v2(95.13,152.12) v2(95.13,141.71) v2(95.16,153.58) v2(95.25,136.62) v2(95.87,155) v2(96.27,157.94) v2(96.25,139.96) v2(96.4,141.79) v2(96.63,147.71) v2(96.61,143.76) v2(96.83,149.47) v2(96.92,145.37) v2(96.96,152.16) v2(96.97,137.91) v2(97.05,163.76) v2(97.08,136.56) v2(97.2,165.84) v2(97.15,153.57) v2(97.72,155.04) v2(98,166.95) v2(98.34,165.8) v2(98.27,163.76) v2(98.66,156.61) v2(98.91,121.33) v2(99.21,166.94) v2(100.15,170.76) v2(101.94,159.78) v2(101.86,152.25) v2(101.94,149.72) v2(101.87,147.14) v2(101.86,144.68) v2(101.98,154.68) v2(102.15,170.8) v2(102.06,157.39) v2(102.92,160.27) v2(102.93,149.29) v2(102.91,145.71) v2(102.94,135.64) v2(102.99,158.49) v2(102.97,148.39) v2(103.28,168.25) v2(103.56,136.57) v2(103.71,167.38) v2(104.21,157.52) v2(104.22,154.75) v2(104.24,153.9) v2(104.24,152.07) v2(104.21,150.2) v2(104.21,146.61) v2(104.22,142.93) v2(104.28,158.46) v2(104.27,156.59) v2(104.26,155.66) v2(104.67,120.32) v2(104.86,157.52) v2(104.88,151.13) v2(104.86,150.2) v2(104.86,148.43) v2(104.86,146.61) v2(104.86,144.79) v2(104.86,142.96) v2(104.86,141.14) v2(104.86,137.5) v2(105.34,170.51) v2(105.44,159.34) v2(105.51,162.12) v2(105.51,157.52) v2(105.51,148.43) v2(105.51,147.52) v2(105.51,146.61) v2(105.51,140.23) v2(105.49,139.37) v2(105.47,137.5) v2(106.12,162.04) v2(106.15,161.15) v2(106.17,160.27) v2(106.16,159.37) v2(106.17,158.44) v2(106.2,157.58) v2(106.17,156.66) v2(106.17,155.64) v2(106.16,154.85) v2(106.18,153.87) v2(106.19,152.99) v2(106.17,152.09) v2(106.17,150.18) v2(106.38,171.12) v2(106.38,169.85) v2(106.45,167.84) v2(106.45,168.6) v2(107.77,129.41) v2(107.77,128.76) v2(107.77,126.81) v2(107.91,161.49) v2(107.91,160.85) v2(108,171.65) v2(107.99,163.46) v2(108.05,170.2) v2(108.98,170.11) v2(108.98,168.84) v2(108.98,167.57) v2(108.96,162.98) v2(110.8,163.46) v2(110.8,162.16) v2(110.8,160.86) v2(113.69,172.26) v2(114.88,134.54) v2(115.24,134.06) v2(116.48,155.34) v2(116.56,144.9) v2(116.61,142.34) v2(116.61,141.75) v2(116.61,141.17) v2(118.39,199.25) v2(118.57,134.72) v2(119.18,134.72) v2(119.15,133.71) v2(120.75,142.18) v2(121.39,145.74) v2(121.41,141.12) v2(122.38,139.85) v2(122.45,165.96) v2(122.94,165.48) v2(123.71,148.64) v2(123.8,147.03) v2(123.78,140.8) v2(124.47,128.79) v2(124.6,138.91) v2(124.79,135.62) v2(124.95,136.76) v2(125.25,150.5) v2(125.26,149.15) v2(125.31,134.7) v2(125.48,153.04) v2(125.62,151.86) v2(125.64,140.82) v2(126.86,150.44) v2(127.66,187.83) v2(127.66,142.68) v2(128.42,133.04) v2(128.88,136.47) v2(129.22,141.34) v2(130.45,128.38) v2(130.65,135.18) v2(130.59,132.92) v2(130.84,130.58) v2(131.06,180.86) v2(131.35,139.28) v2(131.85,133.04) v2(132,180.62) v2(132.33,162.95) v2(132.66,130.75) v2(132.78,162.42) v2(132.91,163.13) v2(133.32,162.11) v2(133.38,162.72) v2(138.44,196.82) v2(142.34,192.02) v2(142.65,199.64) v2(143.03,202.94) v2(143.15,201.04) v2(162.52,201.39) v2(163.38,147.45) v3(50.02,184.98) v3(50.02,184.22) v3(50.78,184.98) v3(50.78,184.22) v3(51.54,184.98) v3(51.54,184.22) v3(52.33,185.01) v3(52.33,184.25) v3(53.09,185.01) v3(53.09,184.25) v3(53.85,185.01) v3(53.85,184.25) v3(68.84,184.83) v3(69.6,184.83) v3(70.36,184.83) v3(76.13,184.78) v3(76.89,184.78) v3(77.65,184.78) v3(78.41,184.78) v3(79.18,184.78) v3(79.94,184.78) v3(80.7,184.78) v3(87.38,205.86) v3(88.14,205.86) v3(88.9,205.86) v3(89.67,205.86) v3(93.91,205.89) v3(97.89,199.96) v3(98.66,199.96) v3(99.42,206.17) v3(99.42,205.41) v3(99.42,199.95) v3(100.18,206.17) v3(100.18,205.41) v3(100.18,199.95) v3(100.54,206.93) v3(100.94,206.17) v3(100.94,205.41) v3(101.1,207.49) v3(101.5,206.83) v3(101.7,208.05) v3(102.11,207.39) v3(102.47,208.45) v3(103.25,208.51) v3(105.85,194.64) v3(105.85,193.87) v3(105.82,193.11) v3(106.6,200.44) v3(106.61,194.64) v3(106.61,193.87) v3(106.58,193.11) v3(107.34,193.11) v3(107.37,194.64) v3(107.37,193.87) v3(112.94,195.06) v3(112.94,194.3) v3(112.94,193.53) v3(113.97,203.68) v3(113.97,202.92) v3(139.97,125.18) v3(139.97,124.42) v3(139.97,123.66) v3(139.97,122.89) v3(139.97,122.13) v3(140.73,125.18) v3(140.73,124.42) v3(140.73,123.66) v3(140.73,122.89) v3(140.73,122.13) v3(142.76,119.56) v3(143.52,119.54) v3(152.11,117.54) v3(152.11,116.78) v3(152.11,116.02) v3(152.87,117.54) v3(152.87,116.78) v3(152.87,116.02) v3(156.01,117.57) v3(161.38,154.82) v3(161.38,154.06) v3(161.38,153.3) v3(161.38,152.54) v3(162.14,154.82) v3(162.14,154.06) v3(162.14,153.3) v3(162.14,152.54) v3(162.9,152.54) v3(165.69,132.66) v3(167.9,164.61) v3(168.02,163.31) v3(168.02,162.55) v3(168.02,161.79) v3(168.02,161.02) v3(169.95,124.46) v3(169.97,123.67) v3(170.7,124.29) v3(170.72,123.51) v3(173.51,124.66) v3(174.27,124.66) v3(175.03,124.66) v3(175.8,124.66) v3(176.56,124.66) v3(177.32,124.66) v3(177.64,127.66) v3(178,130.62) v3(178,129.85) v3(178,129.09) v3(178,128.33) v3(178.41,127.68) v3(189.19,131.95) v3(189.92,131.72) v3(192.69,131.77)
