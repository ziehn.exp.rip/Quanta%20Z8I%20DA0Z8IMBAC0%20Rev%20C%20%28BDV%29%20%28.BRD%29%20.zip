# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_SSDP_C: length 4
  BOTTOM w0.102: R2659.2 18.73,83.01 18.73,82.79 20.05,81.48 20.37,81.48 20.49,81.37 20.49,81.28 20.35,81.14 CN16.55
CLK_PCIE_WLANN: length 102
  IN4 w0.102: v1(170.21,117.19) 170.39,117.19 170.57,117.01 170.57,116.84 170.39,116.66 169.37,116.66 167.32,114.61 165.41,114.61 164.58,113.78 164.58,112.99 163.94,112.34 161.93,112.34 161.83,112.44 161.83,113.21 161.61,113.43 161.03,113.43 160.81,113.21 160.81,112.44 160.71,112.34 159.29,112.34 158.92,111.97 151.26,111.97 151.03,111.74 139.55,111.74 137.68,113.61 137.68,116 136.62,117.07 135.54,117.07 135.11,117.5 134.94,117.5 132.45,119.99 132.45,121.83 132.17,122.12 131.29,122.12 131.09,122.32 131.09,122.53 131.19,122.63 132.37,122.63 132.61,122.87 132.61,123.4 132.37,123.64 130.15,123.64 129.77,123.26 129.37,123.26 128.74,123.89 128.74,125.71 129.02,125.99 129.6,125.99 129.84,126.23 129.84,126.69 129.57,126.97 128.88,126.97 128.78,127.07 128.78,127.48 128.94,127.64 130.61,127.64 131.35,128.39 131.35,129.45 128.11,132.69 127.44,132.69 126.93,133.2 126.93,133.99 127.18,134.24 127.18,137.18 126.19,138.17 124.07,138.17 123.77,138.46 123.77,138.82 123.86,138.91 v2(123.97,138.91)
  BOTTOM w0.079: U1.BE1 122.96,139.29 123.59,139.29 v2(123.97,138.91)
  BOTTOM w0.102: CN17.49 183.08,111.65 182.93,111.8 179.24,111.8 177.55,113.48 177.55,113.93 177.42,114.06 175.1,114.06 174.48,114.68 173.4,114.68 173.02,115.06 173.02,116.76 172.92,116.86 172.5,116.86 172.4,116.76 172.4,116.15 172.15,115.89 171.04,115.89 170.51,116.43 170.51,117.03 170.36,117.19 v1(170.21,117.19)
CLK_PCIE_WLANP: length 102
  IN4 w0.102: v2(123.36,138.92) 123.57,138.71 123.57,138.38 123.99,137.96 126.11,137.96 126.98,137.09 126.98,134.33 126.72,134.07 126.72,133.12 127.36,132.48 128.03,132.48 131.15,129.36 131.15,128.47 130.52,127.85 128.86,127.85 128.57,127.56 128.57,126.99 128.79,126.77 129.48,126.77 129.64,126.61 129.64,126.32 129.52,126.2 128.94,126.2 128.54,125.8 128.54,123.81 129.29,123.06 129.85,123.06 130.24,123.44 132.28,123.44 132.4,123.32 132.4,122.96 132.28,122.83 131.11,122.83 130.89,122.61 130.89,122.23 131.21,121.91 132.08,121.91 132.25,121.75 132.25,119.91 134.86,117.3 135.03,117.3 135.46,116.86 136.53,116.86 137.48,115.92 137.48,113.53 139.47,111.54 151.12,111.54 151.35,111.77 159,111.77 159.37,112.14 160.8,112.14 161.02,112.36 161.02,113.13 161.12,113.23 161.53,113.23 161.63,113.13 161.63,112.36 161.85,112.14 164.02,112.14 164.79,112.9 164.79,113.7 165.5,114.41 167.41,114.41 169.45,116.45 170.47,116.45 170.77,116.75 170.77,116.95 v1(171.01,117.19)
  BOTTOM w0.079: U1.BE2 122.38,139.2 122.65,138.92 v2(123.36,138.92)
  BOTTOM w0.102: CN17.47 183.1,112.15 182.95,112 179.32,112 177.75,113.57 177.75,114.01 177.5,114.26 175.19,114.26 174.57,114.88 173.49,114.88 173.22,115.15 173.22,116.84 173,117.06 172.41,117.06 172.19,116.84 172.19,116.23 172.06,116.1 171.13,116.1 170.71,116.51 170.71,116.89 v1(171.01,117.19)
CLK_VGA_N: length 75.7
  IN4 w0.102: v2(125.16,201.84) 125.16,202.16 125.07,202.26 124.88,202.26 123.65,201.03 123.65,194.98 123.05,194.38 123.05,189.79 123.19,189.65 123.19,186.53 122.92,186.25 122.92,185.44 122.51,185.03 122.51,181.02 123.36,180.17 123.36,173.06 121.96,171.66 121.96,164.91 122.16,164.71 122.16,155.39 122.03,155.26 122.03,148.68 122.3,148.41 122.3,147.36 123.2,146.46 123.2,144.92 125.04,143.07 126.53,143.07 127.86,141.75 127.95,141.75 128.02,141.81 v2(128.02,142.19)
  BOTTOM w0.079: 126.09,141.38 126.07,141.39 126.04,141.39 125.28,142.15 122.68,142.15 122.35,142.48 121.93,142.48 121.87,142.54 121.87,142.72 121.91,142.76 U1.AW2
  BOTTOM w0.102: v2(128.02,142.19) 128.02,141.79 127.29,141.06 126.4,141.06 126.09,141.38 ; U8.AD8 v2(125.16,201.84)
CLK_VGA_P: length 76
  IN4 w0.102: v2(125.17,202.64) 124.99,202.46 124.79,202.46 123.45,201.12 123.45,195.07 122.84,194.46 122.84,189.71 122.99,189.56 122.99,186.61 122.71,186.34 122.71,185.53 122.3,185.12 122.3,180.94 123.15,180.08 123.15,173.14 121.75,171.74 121.75,164.83 121.95,164.63 121.95,155.47 121.83,155.35 121.83,148.59 122.1,148.32 122.1,147.28 123,146.38 123,144.83 124.96,142.87 126.44,142.87 127.77,141.54 128.03,141.54 128.14,141.65 v1(128.56,141.65)
  BOTTOM w0.079: U1.AY3 122.02,142.33 122.28,142.33 122.61,142 125.21,142 125.93,141.28 125.93,141.25 125.94,141.24
  BOTTOM w0.102: U8.AE8 v2(125.17,202.64) ; 125.94,141.24 126.32,140.86 127.37,140.86 128.16,141.65 v1(128.56,141.65)
CLKRUN#: length 91.3
  TOP w0.079: v2(104.16,129.32) 104.28,129.32 104.74,128.86 105.66,128.86 105.84,128.67 105.84,128.21 106.08,127.98 106.44,127.98 107.04,127.38 107.04,126.82 107.85,126.01 107.85,124.45 107.67,124.27 107.67,123.08 106.83,122.24 106.83,122.09
  TOP w0.114: v1(163.34,103.91) 163.34,106.33 164.96,107.95 165.85,107.95 166.23,108.34 U37.93 ; 106.83,122.09 106.83,119.83 107.01,119.65 107.01,114.32 106.21,113.53 106.21,112.31 106.1,112.2 v2(106.1,111.96) 106.47,111.59 R96.1
  IN1 w0.089: v1(163.34,103.91) 162.88,104.37 152.09,104.37 151.18,103.45 150.7,103.45 150.4,103.15 147.36,103.15 146.61,103.9 138.73,103.9 137.91,104.72 137.47,104.72 136.87,105.32 130.55,105.32 127.73,108.13 122.74,108.13 119.26,111.6 118.07,111.6 117.56,111.1 111.57,111.1 111.34,111.33 110.71,111.33 110.44,111.06 107.32,111.06 106.42,111.96 v2(106.1,111.96)
  BOTTOM w0.079: v2(104.16,129.32) 104.18,129.32 104.53,129.67 U1.BY30
CLR_CMOS: length 88
  TOP w0.114: U37.19 150.17,102.34 149.92,102.09 147.59,102.09 147.36,101.86 147.26,101.86 146.56,101.16 146.56,100.5 145.62,99.56 145.62,98.52 v1(145.32,98.22) 144.59,98.22 v1(144.58,98.22) ; Q6520.2 78.77,104.46 R409.2 78.09,104.25 77.65,103.81 76.64,103.81 Q22.2 76.29,103.22 76.93,102.58 v1(76.93,101.9)
  IN1 w0.089: v1(76.93,101.9) 76.93,99.49 79.07,97.35 87.92,97.35 88.08,97.18 97.89,97.18 98.29,97.59 99.3,97.59 100,98.3 113.46,98.3 114.55,99.39 133.29,99.39 134.36,98.32 138.7,98.32 139.38,97.64 144,97.64 v1(144.58,98.22)
CNV_BRI_DT: length 76.6
  TOP w0.102: v1(130.99,112.02) 130.99,112.38 131.05,112.44 R668.1
  IN2 w0.102: v1(193.35,114.83) 188.71,119.46 185.29,119.46 183.41,121.34 181.17,121.34 180.62,121.9 177.06,121.9 176.94,122.02 174.21,122.02 173.74,121.55 167.89,121.55 167.08,120.74 167.08,119.76 165.37,118.06 162.02,118.06 161.5,117.54 161.05,117.54 160.67,117.16 157.64,117.16 156.37,115.9 155.14,115.9 152.42,113.18 152.17,113.18 150.82,111.83 139.41,111.83 137.56,113.69 131.74,113.69 131.09,113.04 131.09,112.12 v1(130.99,112.02)
  BOTTOM w0.102: v1(193.35,114.83) 193.88,114.83 194.01,114.7 R664.2 193.94,114.37 193.12,114.37 192.59,114.9 CN17.36
CNV_BRI_DT_R: length 30.7
  TOP w0.102: R668.2 130.6,113.45 v1(130.95,113.8)
  IN2 w0.089: 114.22,122.22 114.01,122.43 113.71,122.43 112.84,123.31 112.84,124.61 112.94,124.71 112.94,125.51 112.7,125.76 112.02,125.76 111.49,125.22 v2(110.14,125.22)
  IN2 w0.102: 114.22,122.22 114.37,122.07 118.72,122.07 119,121.79 120.85,121.79 122.65,119.99 123,119.99 126.34,116.65 127.27,116.65 129.23,114.68 129.23,113.78 129.63,113.38 130.54,113.38 v1(130.95,113.8)
  BOTTOM w0.079: v2(110.14,125.22) 110.26,125.1 110.26,124.89 110.73,124.42 U1.CJ20
CNV_BRI_RSP: length 108.6
  TOP w0.102: R662.2 128.1,112.18 128.31,112.39 v1(128.96,112.39)
  IN2 w0.089: v2(110.18,124.21) 110.65,124.68 111.56,124.68 112.04,124.21 112.04,123.38 113.2,122.22
  IN2 w0.102: 113.2,122.22 114.03,121.38 118.1,121.38 119.03,120.45 119.28,120.45 120.23,119.5 120.23,119.4 121.23,118.41 121.92,118.41 123.6,116.73 124.24,116.73 125.71,115.25 127.73,115.25 128.57,114.41 128.57,113.03 128.96,112.64 v1(128.96,112.39) 129.22,112.14 129.22,111.75 129.72,111.25 131.3,111.25 131.79,111.74 131.79,112.75 132.07,113.03 134.71,113.03 137.81,109.92 139.71,109.92 140.9,111.12 151.17,111.12 151.82,111.76 152.76,111.76 153.68,112.68 153.68,113.5 155.41,115.24 160.79,115.24 162.96,117.4 165.65,117.4 167.94,119.69 167.94,119.91 168.92,120.89 174.01,120.89 174.48,121.36 176.66,121.36 176.79,121.24 180.34,121.24 180.9,120.68 181.56,120.68 182.3,119.95 183.87,119.95 185.01,118.8 188.03,118.8 192.85,113.99 193.82,113.99 194.22,114.38 194.22,115.98 194.78,116.54 v1(195.27,116.54)
  BOTTOM w0.079: v2(110.18,124.21) 110.68,123.71 U1.CK20
  BOTTOM w0.102: v1(195.27,116.54) 194.72,117.09 R665.2
CNV_BRI_RSP_L: length 3.7
  BOTTOM w0.102: R665.1 193.8,117.09 193.63,116.93 v4(193.14,116.93) 192.68,116.93 192.25,117.36 192.25,118.22 192.06,118.4 CN17.22
CNV_RF_RESET#: length 112.4
  TOP w0.114: U35.2 188.4,114.59 188.19,114.38 188.19,114.25 R677.1 ; R677.1 v1(188.14,113.23) 188.14,110.87 187.6,110.33 187.18,110.33 v1(186.7,110.8) ; R677.1 187.75,114.59 U35.1
  IN4 w0.089: v2(102.97,124.68) 102.97,124.65 103.4,124.23 106.66,124.23 107.31,123.58 107.31,123.11 107.7,122.71 108.62,122.71 110,121.34 111.81,121.34 112.41,120.74 112.41,120.13 113.01,119.53 114.29,119.53 115.57,118.25 115.57,115.13 116.4,114.3 116.4,111.61 122.11,105.9 123.66,105.9 124.21,105.35 124.21,104.67 126.77,102.11 130.94,102.11 131.77,101.28 139.36,101.28 140.19,100.45 141.35,100.45 141.62,100.72 146.62,100.72 146.87,100.47 151,100.47 151.74,101.21 154.92,101.21 155.84,100.29 165.99,100.29 167.4,101.71 171.94,101.71 173.18,102.95 179.09,102.95 185.14,109 185.35,109 186.7,110.35 v1(186.7,110.8)
  BOTTOM w0.079: v2(102.97,124.68) 102.97,124.54 U1.CJ32
CNV_RF_RESET#_L: length 6.2
  TOP w0.114: U35.4 189.05,118.47 188.78,118.73 R676.1 188.78,120.41 v1(188.78,120.42) 189.42,121.06 190,121.06 190.22,121.28 v1(190.22,121.56)
  BOTTOM w0.114: v1(190.22,121.56) 190.38,121.4 CN17.10
CNV_RGI_DT: length 80.9
  TOP w0.102: R183.2 129.95,112.98 R666.1 129.95,112.4 130.17,112.17 130.17,111.97 v1(130.37,111.78)
  IN2 w0.102: v1(193.27,116.07) 193.81,115.53 193.81,114.61 193.52,114.32 192.99,114.32 188.17,119.13 185.15,119.13 184.01,120.28 182.44,120.28 181.7,121.01 181.04,121.01 180.48,121.57 176.92,121.57 176.8,121.69 174.35,121.69 173.87,121.22 168.78,121.22 167.61,120.05 167.61,119.83 165.51,117.73 162.16,117.73 161.64,117.21 161.18,117.21 160.8,116.83 157.78,116.83 156.51,115.57 155.28,115.57 152.81,113.1 152.81,112.48 152.43,112.09 151.68,112.09 151.09,111.5 139.28,111.5 137.42,113.36 131.88,113.36 131.42,112.9 131.42,111.84 131.16,111.58 130.56,111.58 v1(130.37,111.78)
  BOTTOM w0.102: v1(193.27,116.07) 193.86,116.07 R180.2 193.68,116.56 192.79,116.56 192.13,115.9 CN17.32
CNV_RGI_DT_R: length 27.2
  TOP w0.102: v1(129.72,111.98) 129.5,112.2 R666.2
  IN2 w0.089: v2(112.29,125.27) 112.65,124.91 112.65,123.46
  IN2 w0.102: 112.65,123.46 112.65,123.24 114.17,121.71 118.23,121.71 118.78,121.17 121,121.17 122.52,119.66 122.52,118.28 123.74,117.06 124.37,117.06 125.85,115.58 127.87,115.58 128.9,114.54 128.9,113.16 129.72,112.35 v1(129.72,111.98)
  BOTTOM w0.102: U1.CG19 111.91,125.66 v2(112.29,125.27)
CNV_RGI_RSP: length 104.4
  TOP w0.102: R663.2 128.1,111.42 128.22,111.54 128.5,111.54 v1(128.73,111.77)
  IN2 w0.089: v2(111.34,123.51) 111.44,123.51 112.73,122.22
  IN2 w0.102: 112.73,122.22 113.9,121.05 117.96,121.05 118.94,120.07 119.19,120.07 119.9,119.36 119.9,119.27 121.09,118.08 121.78,118.08 123.47,116.39 124.1,116.39 125.58,114.92 126.81,114.92 127.58,114.15 127.58,113.39 127.44,113.25 127.44,112.43 128.09,111.77 v1(128.73,111.77) 129.58,110.92 131.6,110.92 132.52,111.84 135.43,111.84 137.67,109.59 139.84,109.59 141.04,110.79 151.31,110.79 151.95,111.43 152.9,111.43 154.45,112.98 155.44,112.98 157.37,114.91 160.93,114.91 161.95,115.93 165.46,115.93 165.77,116.25 165.77,117.06 168.27,119.55 168.27,119.78 169.05,120.56 174.15,120.56 174.62,121.03 176.25,121.03 177.12,120.16 181.62,120.16 182.16,119.62 183.73,119.62 184.87,118.47 187.9,118.47 192.72,113.66 193.96,113.66 v1(195.13,114.83)
  BOTTOM w0.079: v2(111.34,123.51) 111.34,123.68 111.71,124.05 111.86,124.05 112.05,124.24 112.05,124.72 U1.CH19
  BOTTOM w0.102: v1(195.13,114.83) 194.63,115.34 R667.2
CNV_RGI_RSP_L: length 2.6
  BOTTOM w0.102: CN17.34 193.27,115.4 193.33,115.34 R667.1
CNV_WR_CLK_DN: length 126
  IN4 w0.102: v1(189.47,106.82) 189.26,106.61 189.26,106.32 186.67,103.73 184.39,103.73 180.66,100 180.66,99.09 179.64,98.07 179.64,97.69 179.09,97.14 177.09,97.14 176.8,96.85 169.71,96.85 169.3,96.44 166.38,96.44 165.97,96.04 154.27,96.04 153.42,96.89 151.74,96.89 151.53,97.1 151.1,97.1 150.75,96.75 138.89,96.75 138.32,97.32 121.67,97.32 119.73,99.25 118.66,99.25 117.43,100.48 117.43,101.99 114.21,105.21 114.21,106.33 113.64,106.89 113.21,106.89 111.07,109.03 111.07,109.52 110.73,109.86 109.31,109.86 108.4,110.77 107.61,110.77 106.61,111.77 106.61,112.38 106.1,112.89 106.1,116.86 105.7,117.27 104.88,117.27 103.4,118.75 103.4,119.41 103.81,119.83 104.25,119.83 104.36,119.71 v2(104.6,119.71)
  BOTTOM w0.079: U1.CN31 103.95,121.88 104.38,121.44 104.38,120.79 104.27,120.68 104.27,119.98 104.54,119.71 v2(104.6,119.71)
  BOTTOM w0.102: CN17.21 184.61,118.65 184.76,118.5 185.42,118.5 185.99,117.93 185.99,110.79 186.9,109.87 186.9,108.5 187.27,108.14 188.36,108.14 189.22,107.28 189.22,107.06 v1(189.47,106.82)
CNV_WR_CLK_DP: length 126
  IN4 w0.102: v1(188.67,106.82) 188.78,106.93 188.86,106.93 189.06,106.73 189.06,106.4 186.59,103.93 184.3,103.93 180.45,100.09 180.45,99.18 179.44,98.16 179.44,97.77 179,97.34 177.01,97.34 176.72,97.06 169.63,97.06 169.21,96.64 166.29,96.64 165.89,96.24 154.35,96.24 153.5,97.09 151.82,97.09 151.61,97.3 151.02,97.3 150.67,96.95 138.98,96.95 138.41,97.52 121.75,97.52 119.82,99.46 118.74,99.46 117.63,100.57 117.63,102.08 114.41,105.3 114.41,106.42 113.73,107.1 113.3,107.1 111.28,109.12 111.28,109.6 110.82,110.06 109.39,110.06 108.49,110.97 107.7,110.97 106.81,111.86 106.81,112.47 106.3,112.98 106.3,116.95 105.78,117.47 104.96,117.47 103.6,118.83 103.6,119.33 103.9,119.63 104.16,119.63 104.27,119.52 104.27,119.38 v2(104.19,119.3)
  BOTTOM w0.079: U1.CP31 103.71,121.23 103.62,121.32 103.62,121.5 103.74,121.62 103.98,121.62 104.22,121.38 104.22,120.85 104.11,120.74 104.11,119.92 104.25,119.78 104.25,119.36 v2(104.19,119.3)
  BOTTOM w0.102: v1(188.67,106.82) 188.93,106.82 189.02,106.9 189.02,107.19 188.28,107.93 187.19,107.93 186.7,108.42 186.7,109.79 185.79,110.7 185.79,117.85 185.33,118.3 184.77,118.3 184.62,118.15 CN17.23
CNV_WR_LANE0_DN: length 126.6
  IN4 w0.102: v1(188.42,108.61) 188.12,108.31 188.12,107.42 187.79,107.09 187.79,105.7 186.62,104.54 184.33,104.54 180.02,100.23 177.32,100.23 176.97,99.88 176.97,98.47 176.66,98.17 176.2,98.17 175.9,98.46 175.9,98.89 175.8,98.99 175.42,98.99 175.32,98.89 175.32,98.33 175.07,98.08 174.48,98.08 174.24,98.32 174.24,98.8 174.07,98.96 173.8,98.96 173.68,98.84 173.68,98.29 173.47,98.08 172.97,98.08 172.72,98.33 172.72,98.86 172.62,98.96 172.3,98.96 172.2,98.86 172.2,98.35 171.93,98.08 171.4,98.08 171.15,98.34 171.15,98.56 170.96,98.75 169.8,98.75 168.52,97.47 164.76,97.47 164.31,97.02 160.86,97.02 160.67,97.21 154.27,97.21 153.83,97.65 152.02,97.65 151.81,97.86 150.34,97.86 150.07,97.6 139.36,97.6 138.44,98.51 122.81,98.51 121.35,99.97 119.14,99.97 118.27,100.85 118.27,102.38 114.94,105.7 114.94,106.47 113.72,107.69 113.35,107.69 111.77,109.28 111.77,110.72 110.1,112.39 109.18,112.39 109.08,112.29 108.02,112.29 107.55,112.76 107.55,113.48 107.06,113.96 107.06,118.45 106.17,119.35 105.74,119.35 v2(105.61,119.22)
  BOTTOM w0.079: v2(105.61,119.22) 105.41,119.43 105.23,119.43 105.07,119.58 105.07,120.46 104.74,120.79 104.74,121 U1.CR30
  BOTTOM w0.102: CN17.15 184.85,120.15 185,120 186.64,120 188.13,118.51 188.13,108.89 v1(188.42,108.61)
CNV_WR_LANE0_DP: length 126.6
  IN4 w0.102: v2(105.61,119.81) 105.86,119.55 106.25,119.55 107.27,118.54 107.27,114.04 107.75,113.56 107.75,112.85 108.11,112.49 108.99,112.49 109.1,112.6 110.18,112.6 111.97,110.81 111.97,109.36 113.44,107.9 113.8,107.9 115.14,106.56 115.14,105.78 118.47,102.46 118.47,100.93 119.22,100.17 121.43,100.17 122.89,98.72 138.53,98.72 139.44,97.8 149.99,97.8 150.26,98.07 151.9,98.07 152.11,97.86 153.91,97.86 154.36,97.41 160.76,97.41 160.95,97.22 164.23,97.22 164.68,97.67 168.44,97.67 169.72,98.95 171.05,98.95 171.35,98.65 171.35,98.42 171.49,98.28 171.85,98.28 172,98.44 172,98.95 172.22,99.17 172.7,99.17 172.92,98.94 172.92,98.41 173.05,98.28 173.39,98.28 173.47,98.37 173.47,98.92 173.72,99.17 174.15,99.17 174.44,98.88 174.44,98.41 174.56,98.28 174.99,98.28 175.12,98.41 175.12,98.98 175.34,99.2 175.88,99.2 176.11,98.98 176.11,98.55 176.28,98.37 176.58,98.37 176.76,98.56 176.76,99.96 177.23,100.43 179.93,100.43 184.25,104.74 186.54,104.74 187.58,105.79 187.58,107.17 187.92,107.51 187.92,108.48 187.79,108.61 v1(187.62,108.61)
  BOTTOM w0.079: v2(105.61,119.81) 105.39,119.58 105.29,119.58 105.23,119.65 105.23,120.53 104.9,120.86 104.9,121.42 U1.CP30
  BOTTOM w0.102: CN17.17 184.85,119.65 185,119.8 186.55,119.8 187.93,118.42 187.93,108.92 v1(187.62,108.61)
CNV_WR_LANE1_DN: length 126.1
  IN4 w0.102: v1(190.05,108.54) 189.87,108.54 189.75,108.67 189.75,109.35 189.17,109.93 187.13,109.93 186.1,108.9 186.1,108.42 185.27,107.58 184.73,107.58 179.28,102.14 176.05,102.14 175.57,101.65 175.57,101.24 175.45,101.13 175.15,101.13 175,101.27 175,102.03 174.77,102.27 174.22,102.27 174,102.05 174,101.24 173.86,101.1 173.53,101.1 173.03,101.61 172.69,101.61 172.19,101.1 167.65,101.1 166.24,99.69 162.33,99.69 161.77,99.13 156.04,99.13 154.77,100.4 151.79,100.4 151.23,99.85 145.9,99.85 145.63,100.11 141.92,100.11 141.65,99.84 139.89,99.84 139.06,100.67 131.49,100.67 130.66,101.5 124.32,101.5 121.81,104.01 121.81,105.35 115.77,111.39 115.77,114.08 114.59,115.25 113.76,115.25 110.33,118.68 110.33,120.15 108.6,121.88 107.48,121.88 106.51,122.86 104.84,122.86 104.47,123.22 104.47,123.54 104.6,123.68 v2(104.69,123.68)
  BOTTOM w0.079: v2(104.69,123.68) 104.6,123.68 104.45,123.52 104.45,123.13 104.53,123.06 U1.CM30
  BOTTOM w0.102: v1(190.05,108.54) 189.95,108.54 189.75,108.75 189.75,109.99 189.06,110.68 189.06,118.52 186.08,121.5 185,121.5 184.85,121.65 CN17.9
CNV_WR_LANE1_DP: length 126.1
  IN4 w0.102: v1(189.25,108.54) 189.54,108.84 189.54,109.27 189.09,109.72 187.22,109.72 186.31,108.81 186.31,108.33 185.36,107.38 184.81,107.38 179.37,101.94 176.14,101.94 175.77,101.57 175.77,101.16 175.53,100.92 175.06,100.92 174.8,101.19 174.8,101.95 174.68,102.06 174.3,102.06 174.2,101.96 174.2,101.16 173.94,100.9 173.45,100.9 172.94,101.4 172.78,101.4 172.27,100.9 167.73,100.9 166.32,99.49 162.41,99.49 161.85,98.93 155.96,98.93 154.69,100.2 151.87,100.2 151.31,99.64 145.81,99.64 145.55,99.91 142,99.91 141.74,99.64 139.8,99.64 138.98,100.47 131.41,100.47 130.58,101.3 124.23,101.3 121.6,103.93 121.6,105.27 115.56,111.31 115.56,114 114.51,115.05 113.67,115.05 110.13,118.6 110.13,120.07 108.52,121.68 107.4,121.68 106.42,122.65 104.75,122.65 104.27,123.14 104.27,123.5 104.11,123.66 v2(104.11,123.66)
  BOTTOM w0.079: U1.CN30 104.64,122.51 104.29,122.86 104.29,123.47 104.11,123.66 v2(104.11,123.66)
  BOTTOM w0.102: v1(189.25,108.54) 189.54,108.84 189.54,109.91 188.85,110.6 188.85,118.44 185.99,121.3 185,121.3 184.85,121.15 CN17.11
CNV_WT_CLK_DN: length 115.7
  IN4 w0.102: v2(102.08,120.62) 101.61,120.15 101.38,120.15 99.92,118.7 99.92,116.58 100.5,116 100.5,114.02 103.88,110.64 105.58,110.64 107.13,109.09 107.95,109.09 110.3,106.75 111.35,106.75 111.76,106.34 111.76,103.61 118.18,97.19 119.41,97.19 120.91,95.68 137.6,95.68 138.2,95.09 142.25,95.09 142.89,94.44 151.18,94.44 152.07,95.33 152.45,95.33 153.26,94.53 179.57,94.53 184.1,99.05 184.1,100.54 185.24,101.68 185.76,101.68 186.02,101.94 186.02,102.13 v1(186.28,102.39)
  BOTTOM w0.079: v2(102.08,120.62) 102.28,120.81 102.28,121.22 102.23,121.27 102.23,121.76 U1.CP34
  BOTTOM w0.102: v1(186.28,102.39) 185.99,102.68 185.99,102.84 186.45,103.31 186.45,105.05 185.5,106 185,106 184.85,106.15 CN17.71
CNV_WT_CLK_DP: length 115.7
  IN4 w0.102: v2(102.02,120.01) 101.96,119.95 101.46,119.95 100.13,118.61 100.13,116.67 100.71,116.09 100.71,114.1 103.97,110.84 105.67,110.84 107.22,109.29 108.04,109.29 110.38,106.95 111.43,106.95 111.96,106.42 111.96,103.69 118.27,97.39 119.49,97.39 120.99,95.89 137.69,95.89 138.28,95.29 142.33,95.29 142.98,94.65 151.09,94.65 151.98,95.54 152.54,95.54 153.34,94.73 179.49,94.73 183.89,99.13 183.89,100.63 185.15,101.89 185.68,101.89 185.82,102.03 185.82,102.22 185.65,102.39 v1(185.48,102.39)
  BOTTOM w0.079: U1.CN34 102.15,122.24 102.24,122.15 102.43,121.96 102.43,121.72 102.4,121.69 102.4,121.34 102.44,121.29 102.44,120.43 v2(102.02,120.01)
  BOTTOM w0.102: CN17.73 184.85,105.65 185,105.8 185.41,105.8 186.25,104.96 186.25,103.39 185.78,102.93 185.78,102.69 v1(185.48,102.39)
CNV_WT_LANE0_DN: length 108.6
  IN4 w0.102: v2(102.68,123.51) 102.86,123.33 102.86,123.27 104.29,121.84 106.01,121.84 107.15,120.71 108.01,120.71 109.3,119.42 109.3,118.08 110.57,116.8 110.57,114.9 111.33,114.14 111.33,112.32 112.69,110.95 112.69,110.41 113.79,109.31 113.79,108.78 115.99,106.58 117.01,106.58 118.39,105.2 118.39,104.21 119.08,103.53 119.08,101.2 119.5,100.78 122.42,100.78 123.56,99.65 138.47,99.65 139.62,98.5 141.81,98.5 142.41,99.09 145.07,99.09 145.42,98.74 152.11,98.74 152.36,98.49 154.63,98.49 155.04,98.09 162.31,98.09 162.78,98.56 167.66,98.56 169.17,100.07 175.95,100.07 176.91,101.04 179.67,101.04 184.57,105.93 186,105.93 186.31,106.24 186.31,106.47 v1(186.52,106.68)
  BOTTOM w0.079: v2(102.68,123.51) 102.99,123.2 102.99,123.04 103.33,122.71 U1.CN32
  BOTTOM w0.102: v1(186.52,106.68) 186.25,106.95 186.25,107.09 185.69,107.65 CN17.65
CNV_WT_LANE0_DP: length 108.6
  IN4 w0.102: v1(185.72,106.68) 186.01,106.68 186.11,106.57 186.11,106.33 185.91,106.13 184.48,106.13 179.59,101.24 176.83,101.24 175.86,100.28 169.09,100.28 167.57,98.76 162.7,98.76 162.23,98.29 155.12,98.29 154.72,98.7 152.44,98.7 152.2,98.94 145.51,98.94 145.15,99.3 142.32,99.3 141.73,98.7 139.71,98.7 138.56,99.85 123.64,99.85 122.5,100.99 119.58,100.99 119.28,101.29 119.28,103.61 118.6,104.3 118.6,105.29 117.1,106.79 116.07,106.79 113.99,108.87 113.99,109.4 112.89,110.5 112.89,111.04 111.53,112.4 111.53,114.23 110.77,114.98 110.77,116.89 109.5,118.16 109.5,119.5 108.09,120.91 107.23,120.91 106.1,122.04 104.37,122.04 103.07,123.35 103.07,123.83 103.17,123.93 103.33,123.93 103.46,123.8 v2(103.46,123.64)
  BOTTOM w0.079: v2(103.46,123.64) 103.31,123.64 103.15,123.48 103.15,123.16 103.25,123.06 U1.CM32
  BOTTOM w0.102: v1(185.72,106.68) 185.93,106.68 186.04,106.79 186.04,107.01 185.6,107.45 184.91,107.45 184.61,107.15 CN17.67
CNV_WT_LANE1_DN: length 121.7
  IN4 w0.102: v2(103.1,120.01) 102.89,120.21 102.74,120.2 102.64,120.1 102.64,119.63 101.46,118.45 101.46,116.73 101.55,116.65 101.55,114.7 102.71,113.53 103.97,113.53 107.45,110.05 108.14,110.05 110.35,107.84 111.4,107.84 112.62,106.62 112.62,103.98 113.94,102.66 115.55,102.66 116.28,101.93 116.28,100.7 118.34,98.64 119.45,98.64 121.39,96.71 138.03,96.71 138.61,96.13 146.24,96.13 146.89,95.48 150.96,95.48 151.71,96.23 152.82,96.23 153.68,95.37 179.18,95.37 183.22,99.41 183.22,101 184.17,101.95 184.17,102.66 184.64,103.12 187.86,103.12 188.2,102.78 188.2,102.6 v1(188.4,102.39)
  BOTTOM w0.079: v2(103.1,120.01) 102.97,119.88 102.76,119.88 102.64,119.99 102.64,120.92 102.76,121.04 102.76,121.37 U1.CP33
  BOTTOM w0.102: v1(188.4,102.39) 188.15,102.65 188.15,102.92 187.08,104 187.08,105 187.84,105.76 187.84,107.05 187.57,107.32 186.89,107.32 185.21,109 184.78,109 184.63,109.15 CN17.59
CNV_WT_LANE1_DP: length 121.7
  IN4 w0.102: v1(187.6,102.39) 187.9,102.39 188,102.5 188,102.7 187.78,102.92 184.72,102.92 184.38,102.57 184.38,101.87 183.42,100.92 183.42,99.32 179.27,95.17 153.59,95.17 152.73,96.03 151.79,96.03 151.04,95.27 146.8,95.27 146.15,95.93 138.53,95.93 137.95,96.51 121.3,96.51 119.37,98.44 118.26,98.44 116.08,100.62 116.08,101.84 115.46,102.46 113.86,102.46 112.42,103.9 112.42,106.54 111.32,107.64 110.27,107.64 108.05,109.85 107.36,109.85 103.88,113.33 102.62,113.33 101.34,114.61 101.34,116.56 101.26,116.65 101.26,118.54 102.44,119.72 102.44,120.18 102.66,120.4 102.86,120.41 v2(103.05,120.62)
  BOTTOM w0.079: U1.CN33 102.72,121.85 102.96,121.62 102.96,121.23 102.92,121.2 102.92,120.75 v2(103.05,120.62)
  BOTTOM w0.102: CN17.61 184.63,108.65 184.78,108.8 185.13,108.8 186.81,107.12 187.48,107.12 187.63,106.97 187.63,105.85 186.87,105.08 186.87,103.91 187.94,102.84 187.94,102.5 187.84,102.39 v1(187.6,102.39)
CNV_WT_RCOMP: length 14.2
  TOP w0.102: v2(103.63,120.81) 103.38,121.06 102.83,121.06 102.51,120.75 102.51,118.24 101.66,117.39 101.66,115.27 101.79,115.14 101.79,112.27 100.82,111.3 R146.2
  BOTTOM w0.079: v2(103.63,120.81) 103.52,120.81 U1.CR32 103.23,121.73 U1.CP32
CODEC_VREF: length 2.9
  BOTTOM w0.102: U20.28 15.95,31.41 15.84,31.29 14.64,31.29 14.1,30.75
  BOTTOM w0.114: C563.2 14.08,30.73 14.1,30.75
COMP_CORE: length 2.8
  BOTTOM w0.114: PC7011.1 165.18,137.9 PR7048.2 165.1,137.98 PU7000.4
COMP_GT: length 5.3
  BOTTOM w0.114: PU7000.26 162.3,146.5 162.12,146.69 161.99,146.69 161.56,147.11 v1(161.45,147.11) 161.28,147.28 159.65,147.28 159.38,147.54 PC7017.1 PR7055.2
COMP_SA: length 3.7
  BOTTOM w0.114: v1(170.01,143.38) 169.82,143.19 PR7060.2 169.36,142.46 169.35,142.46 PC7021.1 168.69,142.61 PU7000.43
CPU_C10_GATE#: length 13.7
  BOTTOM w0.079: U1.CN27 106.88,121.71 106.88,120.98 107.12,120.74 107.26,120.74 107.6,120.4 107.6,120.02 107,119.42 107,118.39 106.73,118.12 106.73,116.4 107.12,116.01 107.12,115.72
  BOTTOM w0.114: 107.12,115.72 107.12,114.28 106.1,113.26 104.32,113.26 104.07,113.01 104.07,112.52 103.67,112.11 R161.1
CPU_C10_GATE#_R: length 60.1
  TOP w0.114: PQ35.4 130.35,124.42 130,124.76 PR2060.2 129.5,125.11 v2(129.42,125.04)
  IN1 w0.089: v1(116.57,105.92) 114.99,105.92 114.1,106.81 112.86,106.81 111.39,108.28 109.61,108.28 108.89,108.99 v1(102.95,108.99)
  IN3 w0.102: v1(116.57,105.92) 116.93,105.56 121.13,105.56 126.45,110.88 126.85,110.88 128.3,112.34 128.3,112.66 128.36,112.72 128.36,112.94 128.5,113.08 128.5,115.24 129.64,116.38 129.64,118.8 130.8,119.96 130.8,122.25 129.9,123.15 129.9,124.56 v2(129.42,125.04)
  IN4 w0.089: v2(129.42,125.04) 130.07,124.39 132.16,124.39 132.65,124.89 132.65,126.52 135.85,129.71 136.06,129.71 v1(136.51,130.17)
  BOTTOM w0.114: v1(136.51,130.17) 136.51,130.53 PR9272.2 ; R161.2 102.89,111.47 R1252.1 103.43,110.59 103.05,110.21 103.05,110.08 v1(102.87,109.9) 102.95,109.83 v1(102.95,108.99)
CRT_11: length 2.3
  BOTTOM w0.114: TP9063.1 8.89,152.09 CN21.11
CRT_B: length 12.2
  TOP w0.114: U67.21 26.4,152.48 25.74,153.14 24.87,153.14 24.23,153.78 23.41,153.78 22.98,154.21 R850.1 22.69,154.31 20.52,156.47 C858.2 19.37,156.98 18.61,156.98 L31.1
CRT_B1: length 14.5
  TOP w0.114: L31.2 16.89,156.92 16.03,156.92 C859.2 15.27,156.46 14.86,156.04 12.12,156.04 11.77,155.69 ESD3.4 ESD3.7 9.05,155.69 8.53,155.17 8.53,155.02 8.22,154.71 7.57,154.71 7.07,155.21 7.07,157.09 CN21.3
CRT_G: length 12.3
  TOP w0.114: L27.1 17.6,154.72 C857.2 19.08,155.22 20.53,155.22 22.6,153.15 23.03,153.15 23.3,152.88 R849.1 23.77,152.88 24.27,152.39 25.12,152.39 25.66,151.85 26.29,151.85 26.51,152.08 U67.22
CRT_G1: length 11.8
  TOP w0.114: CN21.2 7.78,154.09 8.47,154.09 9.08,154.69 ESD3.9 ESD3.2 11.71,154.69 11.97,154.95 12.39,154.95 12.81,155.37 14.58,155.37 15.25,154.7 C860.2 16.79,154.7 L27.2
CRT_R: length 12.1
  TOP w0.114: U67.23 27.1,151.68 26.36,150.94 25.12,150.94 R803.1 24.96,151.26 24.62,151.61 23.17,151.61 22.55,152.22 18.57,152.22 18.29,152.5 C856.2 17.32,152.7 L22.1
CRT_R1: length 12.8
  TOP w0.114: L22.2 16.31,152.69 C861.2 14.3,154.69 13.09,154.69 12.36,153.96 11.92,153.96 11.69,154.19 ESD3.1 ESD3.10 9.46,154.19 8.82,153.56 8.82,153.02 8.18,152.37 7.21,152.37 CN21.1
CRT_VCC_R: length 27.9
  TOP w0.254: v1(9.4,156.55) 9.76,156.19 ESD3.6 ESD3.5
  IN1 w0.762: 26.6,156.28 25.89,155.57 24.77,155.57 23.77,154.57 23.77,153.5 24.31,152.96 24.31,150.32 23.55,149.56 16.56,149.56 ; 10.07,156.2 10.85,155.41 10.85,150.84 12.45,149.25 14.29,149.25
  vias: v1(9.13,157.99) v1(9.72,157.61) v1(15.34,149.95) v1(15.34,149.29) v1(26.67,157.83) v1(26.67,157.15) v1(27.38,155.67)
CRTHSYNC: length 9.1
  TOP w0.114: CN21.13 7.8,158.44 8.39,159.03 ESD4.9 ESD4.2 11.62,159.03 12.04,159.46 12.44,159.46 C20008.2 13.39,158.51 13.95,158.51 14.25,158.21 v1(14.35,158.21) 14.91,158.21 R25532.1
CRTHSYNC_R: length 15
  TOP w0.114: R25532.2 16.32,158.11 v1(16.82,158.11) 17.18,157.75 18.56,157.75 18.95,158.13 20.32,158.13 23.05,155.4 25.97,155.4 26.89,154.48 26.89,153.9 27.52,153.28 U67.19
CRTVSYNC: length 12.7
  TOP w0.114: R25535.1 19.04,158.74 18.41,158.11 17.71,158.11 17.17,158.65 16.52,158.65 15.87,159.31 14.77,159.31 14.57,159.51 13.53,159.51 C20003.2 12.74,160.03 ESD4.4 ESD4.7 9.06,160.03 v1(8.77,159.74) 8.11,159.74 CN21.14
CRTVSYNC_R: length 10.7
  TOP w0.114: R25535.2 20.23,158.74 23.1,155.88 v1(23.3,155.88) 23.4,155.77 26.12,155.77 27.26,154.63 27.26,154.05 27.64,153.68 U67.18
CTL2: length 3.3
  TOP w0.114: U14.7 16.49,96.72 16.08,97.13 16.08,98.3 16.06,98.32 R418.2
CTL3: length 3.6
  TOP w0.114: R417.2 16.22,96.6 16.22,95.92 v1(16.77,95.37) 16.77,95.98 17.01,96.22 U14.8
DC-DET: length 6.7
  BOTTOM w0.114: R732.1 R25495.2 27.6,33.8 v1(27.3,33.51) 24.91,33.51 24.81,33.41 U20.4
DCPRTC: length 1.3
  TOP w0.254: v2(108.67,134.3) 108.72,134.36 108.72,134.68 C225.2
  BOTTOM w0.079: 108.26,133.65 U1.BP24
  BOTTOM w0.254: v2(108.67,134.3) 108.67,134.17 108.26,133.76 108.26,133.65
DDI2_AUXN: length 196.6
  TOP w0.102: C20078.1 13.79,69.09 13.62,69.25 13.23,69.25 13.01,69.47 13.01,71.89 12.61,72.3 12.61,75.21 15.76,78.36 22.2,78.36 23.21,77.35 24.02,77.35 v1(24.28,77.6)
  IN3 w0.102: v2(125.13,151.5) 124.92,151.29 124.92,151.06 124.7,150.85 123.97,150.85 123.87,150.94 123.51,150.94 122.36,149.8 122.36,145.52 122.72,145.17 122.72,140.48 123.04,140.16 123.04,139.55 122.84,139.35 122.84,133.82 126.54,130.11 126.54,127.39 126.03,126.87 126.03,124.89 126.49,124.44 126.49,122.66 125.28,121.46 125.28,119.01 124.34,118.07 124.34,117.76 123.78,117.2 123.2,117.2 122.11,116.12 122.11,115.05 121.78,114.72 121.78,113.13 120.45,111.8 117.94,111.8 117.32,111.19 115,111.19 112.13,108.31 110.9,107.08 110.9,105.56 104.3,98.97 98.55,98.97 98.31,98.73 88.98,98.73 88.4,99.31 85.96,99.31 85.31,98.66 81.09,98.66 80.99,98.56 79.49,98.56 78.66,97.73 73.25,97.73 71.51,96 70.25,96 69.82,95.57 57.71,95.57 57.36,95.92 45.36,95.92 44.78,96.51 38.73,96.51 37.89,95.67 34.52,95.67 32.86,97.32 27.73,97.32 24.2,93.79 24.2,85.61 24.84,84.96 24.84,79.48 23.79,78.42 23.79,77.42 23.89,77.32 23.99,77.32 v1(24.28,77.6)
  BOTTOM w0.079: v2(125.13,151.5) 124.94,151.68 124.94,151.81 124.74,152.02 122.36,152.02 122.16,152.22 121.5,152.22 U1.AD4
DDI2_AUXP: length 196.6
  TOP w0.102: v1(24.28,76.84) 24.28,77.08 24.21,77.15 23.13,77.15 22.12,78.15 15.85,78.15 12.81,75.12 12.81,72.38 13.21,71.98 13.21,69.56 13.32,69.46 13.57,69.46 C390.1
  IN3 w0.102: v1(24.28,76.84) 24.28,77.01 24.15,77.13 23.81,77.13 23.6,77.34 23.6,78.5 24.65,79.56 24.65,84.88 24.01,85.53 24.01,93.87 27.65,97.51 32.94,97.51 34.6,95.86 37.81,95.86 38.65,96.7 44.85,96.7 45.44,96.11 57.44,96.11 57.79,95.76 69.74,95.76 70.17,96.19 71.43,96.19 73.17,97.92 78.58,97.92 79.41,98.75 80.91,98.75 81.01,98.85 85.23,98.85 85.88,99.5 88.47,99.5 89.06,98.92 98.23,98.92 98.47,99.16 104.22,99.16 110.71,105.64 110.71,107.16 111.94,108.39 111.94,108.39 114.92,111.38 117.24,111.38 117.86,112 120.38,112 121.59,113.21 121.59,114.79 121.92,115.12 121.92,116.2 123.12,117.4 123.7,117.4 124.15,117.84 124.15,118.14 125.09,119.09 125.09,121.54 126.3,122.74 126.3,124.36 125.84,124.81 125.84,126.95 126.35,127.47 126.35,130.03 122.65,133.74 122.65,139.43 122.85,139.63 122.85,140.08 122.53,140.4 122.53,145.09 122.17,145.45 122.17,149.87 123.43,151.13 123.95,151.13 124.04,151.04 124.62,151.04 124.73,151.14 124.73,151.4 124.63,151.5 v2(124.52,151.5)
  BOTTOM w0.079: v2(124.52,151.5) 124.68,151.5 124.79,151.6 124.79,151.74 124.67,151.86 122.28,151.86 122.09,151.67 121.59,151.67 121.51,151.75 121.51,151.92 121.66,152.06 121.79,152.06 U1.AD3
DDI2_TXN0: length 182.7
  TOP w0.102: v1(21.43,75.35) 21.6,75.18 21.6,74.31 C20067.1
  IN3 w0.102: v2(124.16,153.04) 124.4,152.81 124.4,152.58 123.91,152.1 123.47,152.1 120.8,149.43 120.8,148.32 120.75,148.27 120.75,147.88 120.95,147.69 120.95,146.64 120.67,146.37 120.67,145.52 121.83,144.36 121.83,140.77 121.46,140.4 121.46,139.22 121.92,138.77 121.92,132.11 123.41,130.62 124.65,130.62 125.63,129.64 125.63,128.99 124.53,127.9 124.53,126.53 125.32,125.74 125.32,124.47 124.98,124.13 124.76,124.13 124.15,123.51 124.15,121.59 124.41,121.32 124.41,119.29 123.62,118.5 123.29,118.5 121.32,116.53 121.32,115.39 120.36,114.42 120.36,112.88 120.07,112.59 117.6,112.59 117.01,112 114.7,112 107.99,105.29 107.98,105.29 107.7,105.01 107.7,103.55 103.9,99.76 98.22,99.76 97.98,99.51 89.3,99.51 88.71,100.11 85.62,100.11 84.97,99.45 81.46,99.45 81.46,99.45 80.77,99.45 80.67,99.35 73.71,99.35 71.2,96.84 69.88,96.84 69.4,96.36 58.3,96.36 57.95,96.71 45.72,96.71 45.13,97.3 38.36,97.3 37.53,96.47 34.9,96.47 33.22,98.14 27.44,98.14 23.41,94.12 23.41,85.28 24.06,84.63 24.06,81.7 22.54,80.19 22.54,78.25 21.67,77.37 21.67,75.6 v1(21.43,75.35)
  BOTTOM w0.079: v2(124.16,153.04) 124.38,152.83 124.38,152.73 124.34,152.69 123.33,152.69 123.09,152.93 122.06,152.93 121.83,152.84 121.22,152.84 U1.AC4
DDI2_TXN1: length 181.9
  TOP w0.102: C20077.1 19.86,74.31 19.86,75.12 v1(19.66,75.32)
  IN3 w0.102: v2(126.72,151.47) 126.51,151.26 126.51,151.11 126.59,151.04 127.2,151.04 127.63,150.6 127.63,147.19 126.92,146.47 126.92,142.19 127.97,141.14 127.97,134.92 129.87,133.02 129.87,130.31 129.31,129.75 128.9,129.75 128.52,129.37 128.52,128.72 128.97,128.27 128.97,123.61 129.17,123.41 129.17,122.89 128.46,122.18 128.46,119.78 128.34,119.66 128.34,117.35 127.52,116.53 127.52,114.22 127.73,114.02 127.73,113.4 127.19,112.87 127.19,112.3 120.93,106.04 117.38,106.04 117.02,106.4 116.37,106.4 112.45,102.49 110.57,102.49 104.14,96.06 101.01,96.06 100.38,96.69 98.85,96.69 98.5,96.34 92.95,96.34 92.33,95.72 78.65,95.72 77.05,94.12 71.08,94.12 70.73,93.77 56.87,93.77 56.51,94.12 52.13,94.12 51.27,93.26 37.64,93.26 34.32,89.94 34.32,89.63 34.09,89.4 34.09,89.05 31.21,86.16 30.09,86.16 28.53,84.6 28.53,76.21 25.57,73.25 20.06,73.25 19.63,73.68 19.63,74.38 19.89,74.64 19.89,74.75 19.9,75.08 v1(19.66,75.32)
  BOTTOM w0.079: U1.AC1 123.05,152.34 123.64,152.34 123.64,152.34 125.07,152.34 125.2,152.46 126.07,152.46 126.52,152.02 126.52,151.67 v2(126.72,151.47)
DDI2_TXN2: length 189.4
  TOP w0.102: v1(17.86,74.66) 18.12,74.4 18.12,74.32 C20075.1
  IN3 w0.102: v2(124.15,150.13) 124.36,149.92 124.36,149.74 123.96,149.34 123.39,149.34 122.77,148.72 122.77,145.73 124.52,143.98 124.52,142.56 126.58,140.5 126.58,136.47 125.77,135.67 125.77,131.62 126.95,130.44 126.95,125.45 127.56,124.84 127.56,124.18 126.92,123.54 126.92,120.86 125.92,119.86 125.92,119.08 124.74,117.9 124.74,117.47 123.88,116.61 123.52,116.61 123.04,116.13 123.04,115.35 122.34,114.65 122.34,113.98 122.76,113.56 122.76,112.95 121.21,111.4 119.29,111.4 118.4,110.51 114.9,110.51 113.77,109.38 113.77,108.73 111.77,106.73 111.77,105.18 110.46,103.87 109.82,103.87 104.28,98.33 98.4,98.33 97.81,97.75 92.47,97.75 92.07,98.15 88.94,98.15 88.2,98.89 86.2,98.89 85.42,98.12 83.15,98.12 82.55,97.52 81.9,97.52 81.39,98.03 79.56,98.03 78.76,97.23 76.78,97.23 76.24,96.69 74.49,96.69 74.06,97.12 73.4,97.12 71.79,95.51 70.39,95.51 70.04,95.16 57.44,95.16 57.08,95.51 45.17,95.51 44.6,96.08 38.96,96.08 38.11,95.23 34.37,95.23 32.72,96.87 27.93,96.87 24.6,93.55 24.6,88.54 26.24,86.9 26.24,85.15 25.74,84.65 25.74,83.1 26.96,81.88 26.96,77.6 25.58,76.22 23.21,76.22 22.72,75.73 22.72,75.06 22.34,74.68 21.43,74.68 20.99,75.11 20.99,75.6 20.64,75.96 18.92,75.96 18.21,75.25 18.21,75.01 v1(17.86,74.66)
  BOTTOM w0.079: U1.AE4 121.2,151.11 121.63,151.11 121.71,151.03 121.93,151.03 122.08,150.99 122.34,150.99 122.39,151.01 122.65,151.01 122.69,150.99 122.74,150.98 123.78,150.98 124.32,150.44 124.32,150.31 v2(124.15,150.13)
DDI2_TXN3: length 192.1
  TOP w0.102: C20069.1 16.47,74.22 16.55,74.31 16.55,76.3 17.83,77.57 21.68,77.57 22.85,76.4 23.61,76.4 23.94,76.07 23.94,75.52 24,75.46 24.33,75.46 v1(24.33,75.46)
  IN3 w0.102: v2(125.74,150.1) 125.86,150.1 125.95,150 125.95,149.56 126.63,148.88 126.63,147.6 126.13,147.1 126.13,141.79 127.18,140.74 127.18,136.08 126.65,135.55 126.65,133.52 128.72,131.45 128.72,131.2 127.58,130.06 127.58,125.76 128.18,125.16 128.18,123.72 127.56,123.1 127.56,120.29 126.97,119.7 126.97,119.28 125.78,118.09 125.78,117.64 124.59,116.46 124.59,115.82 124.11,115.34 124.11,113.45 121.36,110.7 120.11,110.7 119.31,109.9 115.16,109.9 114.39,109.14 114.39,108.25 112.39,106.25 112.39,104.96 110.7,103.27 110.24,103.27 103.83,96.86 101.35,96.86 100.69,97.52 98.56,97.52 98.17,97.13 92,97.13 91.6,97.52 83.44,97.52 82.83,96.91 81.64,96.91 81.12,97.43 79.81,97.43 78.91,96.53 77.08,96.53 76.12,95.58 73.62,95.58 72.96,94.92 70.66,94.92 70.3,94.56 57.19,94.56 56.83,94.92 44.84,94.92 44.3,95.45 39.3,95.45 38.36,94.51 34.2,94.51 32.48,96.23 28.3,96.23 25.21,93.14 25.21,88.86 27.74,86.33 27.74,76.95 25.74,74.94 24.06,74.94 23.9,75.11 23.9,75.37 24,75.47 v1(24.33,75.46)
  BOTTOM w0.079: U1.AE1 122.97,151.5 123.77,151.5 124.35,150.92 125.59,150.92 126.01,150.5 126.01,150.19 125.92,150.1 v2(125.74,150.1)
DDI2_TXP0: length 182.7
  TOP w0.102: C20066.1 21.89,74.03 21.8,74.12 21.8,75.08 22.05,75.33 v1(22.1,75.33)
  IN3 w0.102: v1(22.1,75.33) 21.92,75.33 21.86,75.39 21.86,77.3 22.74,78.17 22.74,80.11 24.25,81.62 24.25,84.71 23.6,85.36 23.6,94.04 27.52,97.95 33.15,97.95 34.82,96.28 37.61,96.28 38.44,97.1 45.05,97.1 45.64,96.52 57.87,96.52 58.22,96.17 69.48,96.17 69.96,96.65 71.28,96.65 73.79,99.16 80.75,99.16 80.85,99.26 81.53,99.26 85.05,99.26 85.7,99.92 88.63,99.92 89.23,99.32 98.06,99.32 98.3,99.56 103.98,99.56 107.89,103.48 107.89,104.93 108.06,105.1 108.07,105.1 114.78,111.81 117.08,111.81 117.68,112.4 120.15,112.4 120.55,112.8 120.55,114.34 121.51,115.31 121.51,116.45 123.37,118.31 123.7,118.31 124.6,119.21 124.6,121.4 124.34,121.67 124.34,123.44 124.84,123.94 125.06,123.94 125.51,124.39 125.51,125.82 124.72,126.61 124.72,127.82 125.82,128.91 125.82,129.72 124.73,130.81 123.49,130.81 122.11,132.19 122.11,138.85 121.65,139.3 121.65,140.32 122.03,140.69 122.03,144.44 120.86,145.6 120.86,146.29 121.14,146.56 121.14,147.77 120.95,147.96 120.95,148.19 120.99,148.24 120.99,149.35 123.55,151.91 123.99,151.91 124.59,152.5 124.59,152.81 v2(124.82,153.04)
  BOTTOM w0.079: U1.AC3 121.72,152.68 121.86,152.68 122.09,152.77 123.02,152.77 123.26,152.53 124.4,152.53 124.54,152.66 124.54,152.95 124.63,153.04 v2(124.82,153.04)
DDI2_TXP1: length 181.9
  TOP w0.102: C20076.1 20.16,74.03 20.07,74.12 20.07,75.05 v1(20.33,75.31)
  IN3 w0.102: v2(126.11,151.47) 126.32,151.26 126.32,151.03 126.51,150.85 127.12,150.85 127.44,150.53 127.44,147.27 126.73,146.55 126.73,142.11 127.77,141.06 127.77,134.85 129.68,132.94 129.68,130.39 129.23,129.94 128.82,129.94 128.33,129.45 128.33,128.64 128.78,128.19 128.78,123.53 128.98,123.33 128.98,122.97 128.27,122.26 128.27,119.86 128.15,119.74 128.15,117.42 127.33,116.61 127.33,114.14 127.54,113.94 127.54,113.48 127,112.95 127,112.38 120.85,106.23 117.46,106.23 117.1,106.59 116.29,106.59 112.37,102.68 110.49,102.68 104.06,96.25 101.09,96.25 100.45,96.88 98.77,96.88 98.42,96.53 92.87,96.53 92.25,95.91 78.57,95.91 76.97,94.31 71,94.31 70.65,93.96 56.94,93.96 56.59,94.31 52.05,94.31 51.19,93.45 37.56,93.45 34.13,90.02 34.13,89.71 33.9,89.47 33.9,89.12 31.13,86.35 30.01,86.35 28.34,84.68 28.34,76.29 25.49,73.44 20.14,73.44 19.82,73.76 19.82,74.3 20.09,74.56 20.09,74.74 20.09,75.08 v1(20.33,75.31)
  BOTTOM w0.079: U1.AC2 122.57,152.18 123.64,152.18 123.64,152.18 125.14,152.18 125.26,152.3 126.01,152.3 126.36,151.95 126.36,151.61 126.21,151.47 v2(126.11,151.47)
DDI2_TXP2: length 189.4
  TOP w0.102: v1(18.62,74.66) 18.38,74.66 18.32,74.6 18.32,74.11 18.39,74.03 C20074.1
  IN3 w0.102: v2(124.76,150.13) 124.64,150.13 124.55,150.04 124.55,149.66 124.03,149.15 123.47,149.15 122.96,148.64 122.96,145.81 124.71,144.06 124.71,142.64 126.77,140.58 126.77,136.4 125.96,135.59 125.96,131.7 127.15,130.52 127.15,125.53 127.75,124.92 127.75,124.1 127.11,123.46 127.11,120.78 126.11,119.78 126.11,119 124.93,117.82 124.93,117.39 123.96,116.42 123.6,116.42 123.23,116.05 123.23,115.27 122.53,114.58 122.53,114.06 122.95,113.64 122.95,112.87 121.29,111.21 119.37,111.21 118.48,110.32 114.98,110.32 113.96,109.3 113.96,108.65 111.96,106.65 111.96,105.1 110.53,103.68 109.9,103.68 104.36,98.14 98.48,98.14 97.89,97.56 92.39,97.56 91.99,97.96 88.86,97.96 88.8,98.02 88.12,98.7 86.27,98.7 85.5,97.93 83.23,97.93 82.63,97.33 81.82,97.33 81.31,97.84 79.64,97.84 78.84,97.03 76.86,97.03 76.32,96.5 74.41,96.5 73.98,96.93 73.48,96.93 71.87,95.32 70.47,95.32 70.11,94.97 57.36,94.97 57,95.32 45.09,95.32 44.52,95.89 39.04,95.89 38.19,95.04 34.29,95.04 32.64,96.68 28.01,96.68 24.79,93.47 24.79,88.62 26.43,86.98 26.43,85.07 25.93,84.57 25.93,83.18 27.15,81.96 27.15,77.52 25.66,76.03 23.29,76.03 22.91,75.65 22.91,74.98 22.42,74.49 21.35,74.49 20.8,75.03 20.8,75.52 20.56,75.77 18.99,75.77 18.4,75.17 18.4,74.81 18.54,74.66 v1(18.62,74.66)
  BOTTOM w0.079: U1.AE3 121.62,151.35 121.77,151.19 121.95,151.19 122.11,151.14 122.31,151.14 122.36,151.17 122.67,151.17 122.74,151.15 122.76,151.14 123.84,151.14 124.48,150.5 124.48,150.25 124.61,150.13 v2(124.76,150.13)
DDI2_TXP3: length 192
  TOP w0.102: v1(23.48,75.47) 23.73,75.72 23.73,75.98 23.52,76.19 22.77,76.19 21.59,77.37 17.91,77.37 16.76,76.21 16.76,74.42 C20068.1
  IN3 w0.102: v1(23.48,75.47) 23.71,75.23 23.71,75.03 23.98,74.75 25.82,74.75 27.93,76.87 27.93,86.41 25.4,88.94 25.4,93.06 28.38,96.04 32.4,96.04 34.12,94.32 38.44,94.32 39.38,95.26 44.22,95.26 44.76,94.73 56.75,94.73 57.11,94.37 70.38,94.37 70.74,94.73 73.04,94.73 73.7,95.39 76.2,95.39 77.16,96.34 78.99,96.34 79.89,97.24 81.04,97.24 81.56,96.72 82.91,96.72 83.52,97.33 91.52,97.33 91.92,96.94 98.25,96.94 98.64,97.33 100.61,97.33 101.27,96.67 103.9,96.67 110.32,103.08 110.78,103.08 112.58,104.88 112.58,106.17 114.58,108.17 114.58,109.06 115.23,109.71 119.39,109.71 120.19,110.51 121.44,110.51 124.3,113.37 124.3,115.26 124.78,115.74 124.78,116.38 125.97,117.56 125.97,118.01 127.16,119.2 127.16,119.62 127.75,120.21 127.75,123.02 128.37,123.64 128.37,125.24 127.77,125.84 127.77,129.98 128.91,131.12 128.91,131.53 126.84,133.6 126.84,135.47 127.37,136 127.37,140.82 126.32,141.87 126.32,147.02 126.82,147.52 126.82,148.96 126.14,149.64 126.14,149.89 v2(126.35,150.1)
  BOTTOM w0.079: U1.AE2 122.48,151.66 123.83,151.66 124.42,151.08 125.65,151.08 126.17,150.57 126.17,150.28 v2(126.35,150.1)
DDPC_CTRLDATA: length 4.1
  TOP w0.102: v2(120.75,125.04) 121.06,125.35 121.82,125.35 122.1,125.07 122.1,124.54 R67889.2
  BOTTOM w0.079: U1.CH3 121.69,125.11 121.41,124.83 120.96,124.83 v2(120.75,125.04)
DDR4_DRAMRST#: length 49
  TOP w0.114: v1(45.99,144.86) 45.87,144.98 C249.2 ; v1(76.24,128.27) 77.4,128.27 77.68,128.55 C3.2 77.81,128.88 R27.1 ; C20103.1 54.41,145.49 v1(54.19,145.71)
  IN1 w0.089: v1(76.24,128.27) 68.69,135.82 68.69,137.9 61.24,145.35 54.55,145.35 v1(54.19,145.71)
  IN3 w0.084: v1(45.99,144.86) 47.54,143.31 50.04,143.31 52.44,145.71 v1(54.19,145.71)
  BOTTOM w0.114: v1(45.99,144.86) 45.95,144.82 JDIM1.108 ; v1(54.19,145.71) 55.08,144.82 JDIM02.108
DDR4_SUSON_2V5: length 269.5
  TOP w0.114: U37.122 155.36,110.17 v1(156.79,108.74) ; v1(181.36,112.47) 181.36,116.44 182.17,117.26 v1(182.17,117.95) 182.17,117.96 v1(182.17,118.68) ; v1(70.31,186.51) PR5010.1
  IN3 w0.102: v1(181.36,112.47) 181.36,112.33 180.64,111.61 175.38,111.61 171.97,108.2 166.98,108.2 166.34,107.57 164.18,107.57 163.54,106.92 160.31,106.92 159.36,107.87 157.66,107.87 v1(156.79,108.74) ; v1(70.31,186.51) 71.38,187.58 71.94,187.58 72.72,188.36 74.45,188.36 74.5,188.31 78.7,188.31 79.58,187.44 82.31,187.44 82.56,187.19 84.73,187.19 85.21,187.67 86.82,187.67 88.93,185.56 90.9,185.56 93.44,183.01 96.34,183.01 96.52,183.19 98.21,183.19 99.33,182.07 100,182.07 100.14,181.92 103.29,181.92 104.09,181.13 104.09,180.66 105.42,179.32 106.51,179.32 108.44,177.39 111.69,177.39 116.04,173.04 116.04,170.86 117.49,169.42 117.49,166.77 119.08,165.18 120.24,165.18 121.79,163.63 121.79,154.95 123.09,153.65 126.9,153.65 128.21,152.34 128.21,151.69 128.99,150.91 128.99,143.04 130.26,141.77 130.26,139.76 131.22,138.79 132.91,138.79 134.45,137.25 134.45,132.98 136.95,130.48 136.95,129.66 136.27,128.98 135.28,128.98 133.42,127.12 133.42,123.4 132.5,122.48 132.5,117.53 135.13,114.91 135.13,111.96 137.31,109.78 140.14,109.78 140.55,110.19 147.1,110.19 149.8,112.9 151.47,112.9 152.34,113.76 153.49,113.76 155.07,115.34 156.97,115.34 157.28,115.03 159.93,115.03 160.72,115.81 160.72,116.62 161.14,117.04 163.84,117.04 164.79,117.99 164.79,118.8 167.21,121.22 167.79,121.22 168.11,120.9 169.4,120.9 169.69,121.2 174.57,121.2 174.87,121.49 175.87,121.49 176.41,120.95 176.41,120.71 177.75,119.38 181.47,119.38 v1(182.17,118.68) 191.47,118.68 192.63,119.83 203.6,119.83 206.5,122.73 209.45,122.73 211.66,120.52 215.45,120.52 216.36,121.43 216.36,121.94 v1(216.41,121.99)
  BOTTOM w0.114: CN49.6 221.5,125.25 220.37,124.13 217.53,124.13 216.71,123.31 216.71,122.29 v1(216.41,121.99)
DE1: length 3.3
  TOP w0.114: R503.1 224.89,114.92 225.24,115.27 226.09,115.27 226.15,115.2 226.42,114.94 R1235.2 226.83,115.22 U42.9
DE2: length 3.2
  TOP w0.114: U42.8 226.44,115.72 R504.2 226.42,115.88 226.15,116.14 226.09,116.21 225.24,116.21 224.89,115.86 R505.1
DEVSLP0: length 137.9
  TOP w0.114: v1(215.39,105.72) v1(217.91,105.72) 218.09,105.54 219.61,105.54 220.4,104.75 R67358.2
  IN4 w0.089: v1(215.39,105.72) 213.61,105.72 212.83,106.5 212.29,106.5 210.3,104.5 210.3,102.66 209.23,101.59 199.46,101.59 194.42,106.63 194.42,108.49 194.82,108.89 195.12,108.89 195.43,109.21 195.43,110.99 195.17,111.26 190.99,111.26 189.07,113.18 185.92,113.18 183.59,110.84 181.57,110.84 181.35,110.62 175.71,110.62 173.09,108.01 173.09,107.22 170.21,104.35 166.78,104.35 165.71,103.27 164.48,103.27 164.19,103.55 164.19,104.08 163.63,104.64 158.68,104.64 158.59,104.54 158.23,104.54 158.13,104.64 157.23,104.64 156.67,104.09 156.67,103.78 155.85,102.96 150.96,102.96 150.85,102.85 147.26,102.85 147.1,102.68 145.14,102.68 144.5,103.33 141.13,103.33 140.83,103.03 138.01,103.03 137.46,103.58 135.39,103.58 135.29,103.48 133.87,103.48 132.36,104.99 131.97,104.99 128.66,108.3 125.34,108.3 124.86,108.78 123.42,108.78 122.09,110.12 122.09,111.35 120.71,112.73 120.71,114.52 120.84,114.65 121.43,114.65 122.12,115.34 122.12,117.07 121.66,117.54 121.66,117.83 121.53,117.96 120.82,117.96 120.16,118.61 v2(119.28,118.61)
  BOTTOM w0.079: v2(119.28,118.61) 119.05,118.61 118.52,119.15 118.52,120.63 118.2,120.94 118.2,121.23 118.37,121.6 U1.CP8
  BOTTOM w0.102: R25434.1 119.41,118.49 v2(119.28,118.61)
DEVSLP0_R: length 6.2
  TOP w0.114: v1(221.82,103.97) 222.08,103.97 222.51,104.39 v1(222.51,104.59) 222.35,104.75 R67358.1
  BOTTOM w0.114: CN11.1 224.64,104.24 224.46,104.42 222.27,104.42 v1(221.82,103.97)
DEVSLP1: length 6.3
  BOTTOM w0.079: 119.79,118.41 119.79,118.74 119.46,119.07 118.87,119.07 118.69,119.25 118.69,120.7 118.46,120.93 U1.CR8
  BOTTOM w0.102: 119.79,118.41 119.79,116.4 119.35,115.97 R554.1
DEVSLP2: length 153.7
  TOP w0.114: v1(27.46,74.05) 26.67,74.84 23.28,74.84 22.84,74.4 R645.2 ; R551.1 120.43,113.43 120.01,113.01 v2(119.88,113.01) 118.83,113.01 116.69,110.86 113.9,110.86 112.94,109.9 111.89,109.9 111.53,109.54 111.53,109.03 110.53,108.03 106.61,108.03 105.49,106.92 105.49,106.28 105.83,105.94 105.83,104.61 104.52,103.3 101.19,103.3 100.36,102.48 100.36,99.46 v1(101.35,98.47) 101.99,97.84 v1(101.99,97.63)
  IN2 w0.102: v1(101.99,97.63) 101.63,97.28 101.15,97.28 101.05,97.38 98.53,97.38 98,96.85 92.57,96.85 91.93,96.21 85.08,96.21 84.34,96.95 83.79,96.95 83.06,96.21 78.55,96.21 77.82,96.95 77.16,96.95 75.9,95.69 73.89,95.69 73.41,95.21 68.94,95.21 68.03,94.29 51.47,94.29 50.49,93.32 35.04,93.32 32.24,96.11 28.18,96.11 25.38,93.32 25.38,89.04 28.93,85.5 28.93,75.52 v1(27.46,74.05)
  BOTTOM w0.079: 118.34,119.05 118.34,120.57 118.04,120.87 118.04,121.26 118.12,121.45 118.12,121.84 118.26,121.98 118.26,122.76 U1.CM8
  BOTTOM w0.102: 118.34,119.05 118.92,118.46 118.92,115.62
  BOTTOM w0.114: v2(119.88,113.01) 119.88,113.01 118.6,114.29 118.6,115.13 118.92,115.45 118.92,115.62
DEW1: length 4.4
  TOP w0.114: U42.16 232.46,114.72 232.91,114.27 R499.2 233.13,114.13 233.78,113.48 v1(234.17,113.48) 234.65,113.97 R500.1
DEW2: length 4.2
  TOP w0.114: U42.6 226.97,116.72 226.83,116.86 226.83,117.26 R506.2 226.42,117.96 v1(225.89,118.49) 225.59,118.49 224.89,117.79 R1237.1
DGPU_EDIDCLK: length 6.8
  BOTTOM w0.102: 124.13,179.6 125.09,180.57 125.79,180.57 126.42,181.19 126.42,182.43 U8.A9
  BOTTOM w0.114: R363.1 122.05,178.66 123,179.6 124.13,179.6
DGPU_EDIDDATA: length 8.5
  BOTTOM w0.102: U8.B9 126.4,183.01 126.03,182.64 126.03,182.29 126.19,182.14 126.19,181.29 125.69,180.8 125,180.8 124.01,179.81 122.62,179.81 122.18,179.38
  BOTTOM w0.114: 122.18,179.38 122.04,179.24 121.54,179.24 R366.1
DGPU_HOLD_RST#: length 91.8
  TOP w0.079: 104.04,122.09 103.09,123.05 103.09,123.88 103.34,124.13 105.6,124.13 106.07,124.6 106.07,125.33 105.97,125.43 105.97,126.21 106.14,126.38 v2(106.14,126.66)
  TOP w0.114: 104.04,122.09 104.09,122.05 104.09,120.59 103.57,120.08 103.57,118.87 104.66,117.79 105.57,117.79 105.71,117.65 105.71,114.86 105.02,114.17 102.75,114.17 102.13,113.54 102.13,111.73 101.71,111.32 R25428.2
  IN3 w0.102: v1(107.72,174.75) 108.8,174.75 110.54,173.01 110.54,166.97 111.5,166.01 111.5,158.59 111.15,158.25 111.15,151.7 110.24,150.79 110.24,138.13 109.94,137.83 109.94,127.36 109.64,127.05 108.13,127.05 107.94,127.25 107.2,127.25 106.62,126.66 v2(106.14,126.66)
  IN4 w0.089: v1(107.72,174.75) 107.72,179.87 106.73,180.86 v1(106.76,181.33)
  BOTTOM w0.079: U1.CE28 105.83,126.98 v2(106.14,126.66)
  BOTTOM w0.114: U9.1 106.89,184.54 107,184.42 107,183.02 106.7,182.72 106.21,182.72 106.09,182.6 106.09,182.55 106.08,182.54 106.08,181.99 106.21,181.87 106.6,181.87 106.76,181.71 v1(106.76,181.33) 106.76,180.77 v1(106.66,180.67)
DGPU_OPP#: length 202.3
  TOP w0.114: v1(208.76,127.65) 208.76,127.75 208.27,128.23 v1(207.7,128.23) 207.51,128.23 205.55,126.27 202.51,126.27 200.58,124.35 200.58,120.02 199.91,119.35 199.91,116.98 199.91,112.33 200.57,111.67 200.57,109.86 199.43,108.72 199.43,106.76 200.09,106.11 200.09,104.5 198.86,103.27 198.86,98.46 195.98,95.58 175.02,95.58 173.75,96.85 172.13,96.85 171.68,97.3 171.68,97.78 171.41,98.05 171.13,98.05 170.86,98.32 169.83,98.32 169.52,98.62 169.52,98.9 169.02,99.41 168.05,99.41 167.92,99.54 U37.71
  IN3 w0.102: v1(131.58,176.77) 132.4,177.59 134.26,177.59 135.19,176.66 140.01,176.66 140.62,177.27 146.97,177.27 149.99,174.25 149.99,172.39 150.56,171.82 154.5,171.82 155.49,170.83 158.58,170.83 159.13,170.27 163.57,170.27 166.61,167.24 166.61,160.98 168.64,158.94 168.64,157.09 169.53,156.2 169.53,153.13 170.28,152.38 171.17,152.38 171.9,151.65 171.9,151.19 172.75,150.34 172.75,148.01 170.27,145.54 170.27,143.75 170.41,143.61 170.41,142.45 170.27,142.31 170.27,140.49 169.93,140.14 169.93,139.81 170.83,138.9 170.83,136.67 169.97,135.81 169.97,134.07 172.17,131.87 172.17,131.02 173.07,130.11 173.07,128.62 175.33,126.36 178.14,126.36 179.13,125.37 188.31,125.37 188.59,125.65 191.43,125.65 192.12,126.34 192.12,126.72 194.13,128.73 196.93,128.73 198.31,130.11 199.01,130.11 200,129.12 207.28,129.12 v1(208.76,127.65)
  BOTTOM w0.114: R378.1 130.17,176.42 Q6512.3 130.52,176.77 v1(131.58,176.77)
