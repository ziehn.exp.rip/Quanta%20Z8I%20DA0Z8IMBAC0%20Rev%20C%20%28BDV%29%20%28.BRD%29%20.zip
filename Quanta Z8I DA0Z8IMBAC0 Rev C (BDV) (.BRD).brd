# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A4: length 58.1
  IN3 w0.079: v2(95.74,152.15) 95.26,152.63 94.48,152.63 94.14,152.96 92.59,152.96 92.3,153.25 90.91,153.25
  IN3 w0.102: 90.91,153.25 90.61,153.25 90.11,152.75 78.04,152.75 67.04,141.75 62.04,141.75 61.94,141.65 61.94,141.2 61.81,141.06 60.35,141.06 60.24,140.95 60.24,138.25 60.13,138.14 59.79,138.14 59.4,137.75 58.99,137.75 58.88,137.86 58.88,138.59 58.79,138.68 58.55,138.68 58.44,138.57 58.44,137.81 58.35,137.73 58.03,137.73 57.91,137.86 57.91,138.98 v1(58.04,139.11)
  BOTTOM w0.079: U1.AE35 101.33,151.62 100.98,151.97 100.53,151.97 100.41,152.04 99.99,152.04 99.86,151.92 99,151.92 98.38,152.53 96.11,152.53 v2(95.74,152.15)
  BOTTOM w0.14: v1(58.04,139.11) 58.2,139.28 58.2,139.46 57.84,139.82 JDIM02.128
M_B_A5: length 59.8
  IN3 w0.079: v2(94.43,152.12) 93.91,152.65 92.45,152.65 92.19,152.91 91.1,152.91 90.96,152.77 90.91,152.77
  IN3 w0.102: v1(61.36,140.59) 61.63,140.59 62.17,140.04 63.02,140.04 63.91,140.94 67.8,140.94 78.75,151.88 89.95,151.88 90.83,152.77 90.91,152.77
  BOTTOM w0.079: v2(94.43,152.12) 94.47,152.12 95.38,151.21 98.32,151.21 98.4,151.28 99.92,151.28 99.99,151.21 100.42,151.21 100.52,151.24 100.66,151.24 100.76,151.2 100.98,151.2 U1.AF35
  BOTTOM w0.14: v1(61.36,140.59) 61.24,140.71 60.95,140.71 60.8,140.56 60.8,140.23 60.91,140.11 61.33,140.11 61.41,140.04 61.41,139.72 61.23,139.54 60.76,139.54 60.67,139.45 60.67,138.34 60.82,138.18 61.01,138.18 61.09,138.09 61.09,137.11 60.96,136.97 60.76,136.97 60.57,137.17 60.57,137.65 60.48,137.74 60.3,137.74 60.11,137.93 60.11,138.22 59.88,138.45 59.88,138.7 60.15,138.97 60.15,139.83 60.06,139.92 59.8,139.92 59.53,139.66 59.32,139.66 58.91,140.07 58.7,140.07 58.43,139.8 58.27,139.8 57.74,140.32 JDIM02.126
M_B_A6: length 58.7
  IN3 w0.102: v2(97.57,152.17) 96.64,153.1 94.52,153.1 94.3,153.31 92.73,153.31 92.25,153.8 90.32,153.8 90.13,153.61 77.75,153.61 66.79,142.65 60.13,142.65 59.7,142.22 58.77,142.22 58.64,142.08 58.64,141.82 58.72,141.74 59.26,141.74 59.37,141.63 59.37,141.38 59.26,141.27 58.92,141.27 58.81,141.15 58.81,140.94 58.89,140.85 59.23,140.85 59.37,140.71 v1(59.37,140.43)
  BOTTOM w0.079: U1.AE37 100.04,151.62 100.02,151.6 98.14,151.6 v2(97.57,152.17)
  BOTTOM w0.14: JDIM02.127 62.75,140.07 62.6,139.93 62.07,139.93 61.79,140.21 61.79,140.87 61.52,141.15 60.98,141.15 60.39,141.74 60.19,141.74 60.05,141.6 60.05,141.23 60.38,140.9 60.38,140.7 60.11,140.43 v1(59.37,140.43)
M_B_A7: length 57.6
  IN3 w0.079: v2(104.91,152.99) 103.68,152.63 103.42,152.63 103.15,152.91
  IN3 w0.102: 103.15,152.91 102.75,152.91 102.15,153.21 100.08,153.79 99.26,153.79 98.93,154.13 98.24,154.13 98.12,154.25 94.43,154.25 94.28,154.4 92.32,154.4 92.21,154.29 91.28,154.29 91.09,154.48 77.47,154.48 67.17,144.18 65.93,144.18 65.22,143.46 59.48,143.46 59.22,143.72 v1(58.96,144.16)
  BOTTOM w0.102: v2(104.91,152.99) 105.16,152.74 105.18,152.72 U1.AC29
  BOTTOM w0.14: v1(58.96,144.16) 58.96,143.88 59.77,143.07 59.77,142.71 58.38,141.32 JDIM02.122
M_B_A8: length 60
  IN3 w0.079: 90.91,153 90.96,153 91.04,153.08 92.25,153.08 92.52,152.81 94.07,152.81 94.41,152.47 94.62,152.47 94.78,152.31 94.78,151.89 94.94,151.74 97.74,151.74 v2(98.18,152.17)
  IN3 w0.102: v1(62.96,140.6) 62.96,140.8 62.85,140.91 62.53,140.91 62.35,141.09 62.35,141.28 62.41,141.34 67.64,141.34 68.12,141.82 68.12,141.97 68.05,142.04 68.05,142.18 68.19,142.32 68.33,142.32 68.4,142.25 68.55,142.25 68.69,142.4 68.69,142.54 68.62,142.61 68.62,142.75 68.76,142.9 68.91,142.9 68.98,142.83 69.12,142.83 69.27,142.97 69.27,143.12 69.2,143.19 69.2,143.33 69.34,143.47 69.48,143.47 69.55,143.4 69.7,143.4 69.84,143.55 69.84,143.69 69.77,143.76 69.77,143.9 69.91,144.05 70.06,144.05 70.13,143.98 70.27,143.98 70.42,144.12 70.42,144.27 70.35,144.34 70.35,144.48 70.49,144.62 70.63,144.62 70.7,144.55 70.85,144.55 70.99,144.7 70.99,144.84 70.92,144.91 70.92,145.05 71.06,145.2 71.21,145.2 71.28,145.13 71.42,145.13 71.57,145.27 71.57,145.42 71.5,145.49 71.5,145.63 71.64,145.77 71.78,145.77 71.85,145.7 72,145.7 72.14,145.85 72.14,145.99 72.07,146.06 72.07,146.2 72.21,146.35 72.36,146.35 72.43,146.28 72.57,146.28 72.72,146.42 72.72,146.57 72.65,146.64 72.65,146.78 72.79,146.92 72.93,146.92 73,146.85 73.15,146.85 73.29,147 73.29,147.14 73.22,147.21 73.22,147.36 73.36,147.5 73.51,147.5 73.58,147.43 73.72,147.43 73.87,147.57 73.87,147.72 73.8,147.79 73.8,147.93 73.94,148.07 74.08,148.07 74.15,148 74.3,148 74.44,148.15 74.44,148.29 74.37,148.36 74.37,148.51 74.51,148.65 74.66,148.65 74.73,148.58 74.87,148.58 75.02,148.72 75.02,148.87 74.95,148.94 74.95,149.08 75.09,149.22 75.23,149.22 75.3,149.15 75.45,149.15 75.59,149.3 75.59,149.44 75.52,149.51 75.52,149.66 75.66,149.8 75.81,149.8 75.88,149.73 76.02,149.73 76.17,149.87 76.17,150.02 76.1,150.09 76.1,150.23 76.24,150.37 76.38,150.37 76.45,150.3 76.6,150.3 76.74,150.45 76.74,150.59 76.67,150.66 76.67,150.81 76.81,150.95 76.96,150.95 77.03,150.88 77.17,150.88 77.32,151.02 77.32,151.17 77.25,151.24 77.25,151.38 77.39,151.52 77.53,151.52 77.6,151.45 77.75,151.45 77.89,151.6 77.89,151.74 77.82,151.81 77.82,151.96 77.96,152.1 78.11,152.1 78.18,152.03 78.32,152.03 78.61,152.32 90.03,152.32 90.71,153 90.91,153
  BOTTOM w0.079: U1.AE36 100.7,151.81 100.48,151.81 100.37,151.88 100.06,151.88 99.94,151.75 98.59,151.75 v2(98.18,152.17)
  BOTTOM w0.14: v1(62.96,140.6) 62.96,141.06 62.65,141.38 62.02,141.38 61.26,142.13 61.26,142.34 61.48,142.55 61.68,142.55 62.33,141.9 62.84,141.9 63.6,141.13 63.6,140.72 63.75,140.57 JDIM02.125
M_B_A9: length 56.3
  IN3 w0.079: v2(104.96,153.9) 104.59,153.53 102.75,153.53
  IN3 w0.102: 102.75,153.53 102.31,153.97 101.41,153.97 101.08,154.3 99.6,154.3 98.48,155.42 91.59,155.42 91.51,155.34 77.18,155.34 66.9,145.06 64.67,145.06 64.16,144.54 60.99,144.54 v1(60.37,143.92)
  BOTTOM w0.102: v2(104.96,153.9) 105.18,153.67 U1.AB29
  BOTTOM w0.14: JDIM02.121 63.65,141.57 62.91,142.31 62.62,142.31 62.05,142.88 61.4,142.88 v1(60.37,143.92)
M_B_A10: length 58.7
  IN3 w0.102: v1(58.19,133.45) 58.45,133.2 58.45,132.15 58.61,131.99 58.83,131.99 59.02,132.18 59.02,134.1 58.86,134.26 58.49,134.26 58.42,134.34 58.42,134.74 58.51,134.83 59.08,134.83 59.26,135.01 59.26,135.23 59.36,135.33 59.67,135.33 59.77,135.23 59.77,134.97 59.91,134.83 60.67,134.83 60.88,135.04 64.59,135.04 64.98,135.42 68.7,135.42 81.28,147.99 90.23,147.99 91.29,149.05 91.86,149.05 91.96,149.15 91.96,149.38 92.12,149.54 93.76,149.54 94.25,149.05 94.68,149.05 v2(95.09,149.46)
  BOTTOM w0.079: v2(95.09,149.46) 95.98,150.35 97.89,150.35 98.43,149.81 99.85,149.81 99.93,149.89 100.38,149.89 100.39,149.9 100.7,150.07 101.72,150.07 101.97,150.32 U1.AG34
  BOTTOM w0.14: v1(58.19,133.45) 58.07,133.32 JDIM02.146
M_B_A11: length 58.3
  IN3 w0.079: v2(105.58,152.96) 105.18,152.56 104.74,152.56 104.62,152.44 103.39,152.44 103.16,152.67 102.27,152.67
  IN3 w0.102: v1(59.35,142.89) 59.52,143.06 66.62,143.06 77.61,154.04 92.31,154.04 92.45,154.18 94.17,154.18 94.37,153.99 98.01,153.99 98.37,153.63 98.37,153.43 98.1,153.16 97.64,153.16 97.55,153.07 97.55,152.81 97.79,152.57 98.14,152.57 98.85,153.28 100.41,153.28 100.84,152.85 102.1,152.85 102.27,152.67
  BOTTOM w0.102: v2(105.58,152.96) 105.83,152.72 U1.AC28
  BOTTOM w0.14: v1(59.35,142.89) 59.35,142.8 58.88,142.33 58.08,142.33 57.97,142.22 57.97,141.92 57.87,141.82 JDIM02.120
M_B_A12: length 57.5
  IN3 w0.079: 103.19,153.16 103.39,153.37 105.43,153.37 105.57,153.51 v2(105.57,153.89)
  IN3 w0.102: 103.19,153.16 102.73,153.16 102.22,153.67 101.35,153.67 100.95,154.07 99.32,154.07 98.89,154.5 98.21,154.5 98.03,154.68 97.68,154.68 97.56,154.56 94.54,154.56 94.49,154.61 91.58,154.61 91.28,154.91 77.32,154.91 67.06,144.65 65.82,144.65 65.48,144.31 65.21,144.31 65.13,144.39 65.13,144.54 65.03,144.65 64.85,144.65 64.71,144.51 64.71,143.98 64.6,143.87 64.37,143.87 64.27,143.97 64.27,144.06 64.19,144.14 63.95,144.14 63.86,144.05 63.86,143.97 63.76,143.87 63.55,143.87 63.46,143.96 63.46,144.05 63.37,144.14 63.12,144.14 63.05,144.07 63.05,143.97 62.95,143.87 62.72,143.87 62.64,143.95 62.64,144.07 62.58,144.14 62.32,144.14 62.24,144.06 62.24,143.95 62.16,143.87 61.73,143.87 v1(61.69,143.91)
  BOTTOM w0.102: U1.AB28 105.57,153.71 v2(105.57,153.89)
  BOTTOM w0.14: JDIM02.119 63.74,142.07 63.62,142.2 63.62,142.71 63.38,142.94 63.24,142.94 63.05,142.75 62.8,142.75 62.6,142.95 62.6,143.26 62.37,143.48 62.17,143.48 61.92,143.23 61.59,143.23 61.41,143.42 61.41,143.63 v1(61.69,143.91)
M_B_A13: length 59.1
  IN3 w0.102: v1(59.43,131.09) 59.29,131.23 59.29,131.68 59.55,131.94 59.97,131.94 60.05,132.03 63.07,132.03 63.74,132.69 69,132.69 70.08,133.77 70.22,133.77 70.4,133.59 70.54,133.59 70.69,133.74 70.69,133.88 70.51,134.06 70.51,134.2 70.65,134.35 70.79,134.35 70.97,134.17 71.12,134.17 71.26,134.31 71.26,134.46 71.08,134.64 71.08,134.78 71.23,134.92 71.37,134.92 71.55,134.74 71.69,134.74 71.84,134.89 71.84,135.03 71.66,135.21 71.66,135.35 71.8,135.5 71.94,135.5 72.12,135.32 72.27,135.32 72.41,135.46 72.41,135.61 72.23,135.79 72.23,135.93 72.38,136.07 72.52,136.07 72.7,135.89 72.84,135.89 72.99,136.04 72.99,136.18 72.81,136.36 72.81,136.5 72.95,136.65 73.09,136.65 73.27,136.47 73.42,136.47 73.56,136.61 73.56,136.76 73.38,136.94 73.38,137.08 73.53,137.22 73.67,137.22 73.85,137.04 73.99,137.04 74.14,137.19 74.14,137.33 73.96,137.51 73.96,137.65 74.1,137.8 74.24,137.8 74.42,137.62 74.57,137.62 74.71,137.76 74.71,137.91 74.53,138.09 74.53,138.23 74.68,138.37 74.82,138.37 75,138.19 75.14,138.19 81.81,144.86 81.81,145 81.63,145.18 81.63,145.33 81.77,145.47 81.92,145.47 82.1,145.29 82.24,145.29 82.53,145.58 90.1,145.58 91.64,147.11 93.45,147.11 v2(94.07,147.74)
  BOTTOM w0.079: U1.AK35 100.98,148.68 100.72,148.68 100.64,148.71 100.45,148.71 100.38,148.68 99.79,148.68 99.79,148.69 98.95,148.69 98.61,148.35 94.69,148.35 v2(94.07,147.74)
  BOTTOM w0.14: JDIM02.158 58.67,130.32 v1(59.43,131.09)
M_B_ACT#: length 57.8
  IN3 w0.102: v1(59.37,147.12) 59.94,147.7 62.16,147.7 62.48,147.37 62.48,146.86 62.65,146.7 63.8,146.7 64.47,147.37 65.15,147.37 66.04,148.26 67.74,148.26 76.55,157.07 92.82,157.07 92.88,157.01 99.06,157.01 99.4,156.68 99.4,156.67 99.65,156.56 100.06,156.56 102.12,156.11 102.63,156.03 104.98,156.03 v2(105.53,155.65)
  BOTTOM w0.102: U1.W28 105.83,155.35 v2(105.53,155.65)
  BOTTOM w0.14: JDIM02.114 57.66,143.32 57.93,143.6 57.93,144.41 58.95,145.42 58.95,146.7 v1(59.37,147.12)
M_B_ALERT#: length 58.5
  IN3 w0.102: v1(57.93,142.82) 58.11,143 58.11,145.38 58.24,145.51 58.71,145.51 58.81,145.41 58.81,144.76 58.91,144.66 59.22,144.66 59.31,144.75 59.31,145.36 59.39,145.44 59.75,145.44 59.81,145.37 59.81,145.03 59.89,144.95 63.99,144.95 64.5,145.46 66.73,145.46 77.04,155.77 91.87,155.77 91.87,155.77 95.57,155.77 95.72,155.62 98.58,155.62 99.05,155.14 100.64,155.14 101.49,154.29 104.38,154.29 v2(104.9,154.82)
  BOTTOM w0.102: U1.Y29 105.18,154.54 v2(104.9,154.82)
  BOTTOM w0.14: JDIM02.116 v1(57.93,142.82)
M_B_BG#0: length 56.1
  IN3 w0.079: 102.62,155.36 102.69,155.29 104.55,155.29 v2(104.89,155.64)
  IN3 w0.102: v1(62.01,147.14) 61.78,146.91 61.78,146.63 62.14,146.27 64.09,146.27 64.79,146.96 64.98,146.96 65.07,146.88 65.07,146.64 65.19,146.52 65.41,146.52 65.53,146.63 65.53,146.84 65.65,146.96 67.02,146.96 76.69,156.63 92.32,156.63 92.37,156.58 95.65,156.58 96.2,156.03 98.79,156.03 99.18,155.64 100.97,155.64 101.19,155.42 102.56,155.42 102.62,155.36
  BOTTOM w0.102: v2(104.89,155.64) 105.18,155.35 U1.W29
  BOTTOM w0.14: v1(62.01,147.14) 62.01,144.34 62.7,143.64 63.17,143.64 63.74,143.07 JDIM02.115
M_B_BG#1: length 58.5
  IN3 w0.102: v2(105.55,154.82) 105.18,155.18 104.71,155.18 104.65,155.13 101.05,155.13 100.76,155.42 99.11,155.42 98.69,155.84 95.96,155.84 95.62,156.18 91.91,156.18 91.88,156.2 76.84,156.2 67.17,146.53 66.13,146.53 65.56,145.96 64.39,145.96 64.27,145.83 62,145.83 v1(60.69,147.14)
  BOTTOM w0.102: U1.Y28 105.83,154.54 v2(105.55,154.82)
  BOTTOM w0.14: v1(60.69,147.14) 61.12,147.57 62.21,147.57 62.46,147.31 62.46,144.5 62.92,144.04 63.34,144.04 63.81,143.57 JDIM02.113
M_B_BS#0: length 58.2
  IN3 w0.102: v1(59.82,133.86) 59.43,133.47 59.43,132.5 59.55,132.39 59.77,132.39 59.91,132.52 59.91,133.29 60.01,133.4 60.23,133.4 60.37,133.25 60.37,132.53 60.46,132.43 60.73,132.43 60.84,132.54 60.84,133.22 60.9,133.28 61.21,133.28 61.31,133.18 61.31,132.54 61.41,132.43 61.62,132.43 61.72,132.54 61.72,133.18 61.82,133.28 62.77,133.28 62.99,133.51 68.62,133.51 81.89,146.77 87.51,146.77 87.61,146.67 87.61,146.49 87.71,146.39 87.92,146.39 88.02,146.49 88.02,146.67 88.12,146.77 88.32,146.77 88.42,146.67 88.42,146.49 88.53,146.39 88.73,146.39 88.83,146.49 88.83,146.67 88.93,146.77 89.13,146.77 89.24,146.67 89.24,146.49 89.34,146.39 89.54,146.39 89.64,146.49 89.64,146.67 89.74,146.77 90.31,146.77 91.29,147.76 v2(91.64,147.76)
  BOTTOM w0.079: 92.22,148.34 92.58,148.7 98.48,148.7 98.81,149.02 100.15,149.02 U1.AJ37
  BOTTOM w0.14: JDIM02.150 57.75,132.32 58.75,132.79 v1(59.82,133.86) ; v2(91.64,147.76) 92.22,148.34
M_B_BS#1: length 58.7
  IN3 w0.102: v2(96.17,149.46) 96.3,149.34 96.3,148.9 96.19,148.79 95.93,148.79 95.8,148.93 95.8,149.18 95.7,149.28 95.54,149.28 95.43,149.18 95.43,148.89 95.31,148.77 93.68,148.77 93.58,148.87 93.58,149.13 93.48,149.23 93.28,149.23 93.18,149.13 93.18,148.87 93.07,148.77 92.87,148.77 92.77,148.87 92.77,149.13 92.67,149.23 92.46,149.23 92.36,149.13 92.36,148.87 92.26,148.77 91.45,148.77 90.27,147.59 81.48,147.59 68.91,135.01 65.15,135.01 65.05,134.92 65.05,134.41 64.96,134.32 64.72,134.32 64.62,134.42 64.62,134.53 64.51,134.63 64.25,134.63 64.15,134.53 64.15,134.42 64.05,134.32 63.84,134.32 63.74,134.42 63.74,134.53 63.64,134.63 63.23,134.63 63.13,134.53 63.13,134.42 63.03,134.32 62.83,134.32 62.73,134.42 62.73,134.53 62.62,134.63 62.22,134.63 62.12,134.53 62.12,134.35 62.04,134.27 61.79,134.27 61.71,134.35 61.71,134.53 61.61,134.63 61.19,134.63 60.98,134.42 60.98,133.99 61.08,133.89 v1(61.27,133.89)
  BOTTOM w0.079: U1.AJ36 100.73,149.26 100.58,149.26 100.32,149.36 100.1,149.36 99.93,149.19 98.74,149.19 98.42,148.87 96.76,148.87 v2(96.17,149.46)
  BOTTOM w0.14: JDIM02.145 65.78,133.57 65.91,133.7 65.91,134.36 65.73,134.54 61.92,134.54 v1(61.27,133.89)
M_B_CAS#: length 59.1
  IN3 w0.102: v1(58.11,131.09) 58.11,130.17 58.21,130.07 58.5,130.07 58.6,130.17 58.6,130.49 58.69,130.58 58.92,130.58 59.03,130.48 59.03,130.24 59.12,130.15 59.33,130.15 59.44,130.26 59.44,130.58 59.52,130.66 59.83,130.66 59.91,130.58 59.91,130.23 60.01,130.13 60.23,130.13 60.32,130.22 60.32,131.52 60.42,131.62 60.7,131.62 60.8,131.53 60.8,130.24 60.89,130.14 61.11,130.14 61.21,130.25 61.21,131.38 61.43,131.6 63.25,131.6 63.94,132.29 69.17,132.29 69.98,133.1 70.66,133.1 82.73,145.17 90.08,145.17 91.79,146.88 93.69,146.88 94.15,147.34 95.02,147.34 v2(95.41,147.73)
  BOTTOM w0.079: U1.AK34 101.63,148.23 101.39,148.23 101.31,148.2 101.12,148.2 101.04,148.23 100.76,148.23 100.69,148.2 100.46,148.2 100.39,148.23 99.51,148.23 99.24,147.96 98.87,147.96 98.63,148.19 95.88,148.19 v2(95.41,147.73)
  BOTTOM w0.14: JDIM02.156 57.85,130.82 v1(58.11,131.09)
M_B_CB0: length 2.1
  TOP w0.114: R25602.2 57.91,149.03 v1(57.91,149.03)
  BOTTOM w0.114: v1(57.91,149.03) 57.7,148.82 JDIM02.92
M_B_CB1: length 2.2
  TOP w0.114: v1(66.12,149.16) 65.55,149.73 R25603.2
  BOTTOM w0.114: v1(66.12,149.16) 66.04,149.07 JDIM02.91
M_B_CB2: length 2.5
  TOP w0.114: v1(66.11,145.89) 65.9,145.69 R25604.2
  BOTTOM w0.114: JDIM02.101 65.76,146.57 66.11,146.22 v1(66.11,145.89)
M_B_CB3: length 3.4
  TOP w0.114: R25605.2 66.9,145.93 v1(66.74,146.09)
  BOTTOM w0.114: v1(66.74,146.09) 66.74,145.77 66.37,145.39 65.85,145.39 65.67,145.57 JDIM02.105
M_B_CB4: length 3.3
  TOP w0.114: v1(58.57,149.05) 58.57,149.19 R25606.2
  BOTTOM w0.114: v1(58.57,149.05) 57.79,149.82 JDIM02.88
M_B_CB5: length 3.5
  TOP w0.114: R25608.2 66.9,151.2 v1(66.78,151.08)
  BOTTOM w0.114: JDIM02.87 66.3,150.07 66.78,150.55 v1(66.78,151.08)
M_B_CB6: length 3.4
  TOP w0.114: v1(54.48,147.37) 53.92,147.94 R25609.2
  BOTTOM w0.114: JDIM02.100 55.04,146.82 v1(54.48,147.37)
M_B_CB7: length 2.2
  TOP w0.114: v1(55.31,145.92) 55.62,145.61 R25610.2
  BOTTOM w0.114: v1(55.31,145.92) 55.4,145.82 JDIM02.104
M_B_CKE0: length 54
  IN3 w0.102: v1(63.55,147.22) 63.55,147.45 64.43,148.33 64.67,148.33 64.8,148.2 64.8,147.91 64.9,147.81 65.02,147.81 65.31,148.11 65.31,148.3 65.13,148.48 65.13,148.66 65.3,148.83 65.46,148.83 65.6,148.69 67.6,148.69 76.41,157.5 94.9,157.5 95.16,157.24 99.42,157.24 99.52,157.34 100.21,157.34 101.68,156.66 102.24,156.66 102.51,156.93 103.71,156.93 103.91,156.73 103.91,156.4 104.09,156.21 105.11,156.21 v2(105.54,156.64)
  BOTTOM w0.102: v2(105.54,156.64) 105.83,156.93 U1.T28
  BOTTOM w0.14: JDIM02.109 63.25,144.57 62.9,144.93 62.9,146.58 v1(63.55,147.22)
M_B_CKE1: length 56.6
  IN3 w0.102: v2(104.88,156.7) 104.15,157.15 102.4,157.15 102.22,156.97 101.93,156.97 100.35,157.59 100.32,157.6 100.21,157.64 99.39,157.64 99.29,157.55 95.5,157.55 95.12,157.93 76.26,157.93 67.92,149.59 65.11,149.59 63.63,148.1 59.81,148.1 58.3,147.5 v1(57.93,147.12)
  BOTTOM w0.102: U1.T29 v2(104.88,156.7)
  BOTTOM w0.14: v1(57.93,147.12) 58.44,146.62 58.44,145.28 57.48,144.32 JDIM02.110
M_B_CLKN0: length 62
  IN3 w0.079: 99.45,151.54 99.46,151.54 ; 102.58,150.74 102.59,150.74 105.45,150.74 105.51,150.8 v2(105.51,151.07)
  IN3 w0.089: 99.46,151.54 100.12,151.54 100.92,150.74 102.58,150.74 ; v1(62.82,136.85) 62.23,136.85 62.04,136.66 62.04,136.34 62.13,136.25 63.92,136.25 63.98,136.3 63.98,136.8 64.2,137.03 64.81,137.03 65.09,136.75 65.63,136.75 65.91,137.03 67.78,137.03 68.11,136.7 68.3,136.7 75.08,143.48 75.08,143.6 74.8,143.89 74.8,144.17 75.2,144.57 75.46,144.57 75.76,144.28 75.88,144.28 76.18,144.58 76.18,144.7 75.9,144.98 75.9,145.27 76.29,145.67 76.55,145.67 76.85,145.37 76.98,145.37 77.28,145.67 77.28,145.8 76.99,146.08 76.99,146.37 77.36,146.74 77.68,146.74 77.95,146.47 78.07,146.47 78.37,146.77 78.37,146.89 78.08,147.19 78.08,147.45 78.49,147.86 78.75,147.86 79.05,147.57 79.17,147.57 79.47,147.86 79.47,147.99 79.2,148.25 79.2,148.53 79.86,149.18 90.09,149.18 91.47,150.56 97.83,150.56 98.82,151.54 99.45,151.54
  BOTTOM w0.102: v2(105.51,151.07) 105.51,151.04 U1.AF28 ; JDIM02.139 64,137.07 63.79,137.29 63.16,137.29 62.61,137.84 62.46,137.84 62.36,137.73 62.36,136.95 62.46,136.85 v1(62.82,136.85)
M_B_CLKN1: length 61.3
  IN3 w0.079: 102.84,151.49 102.85,151.5 105.16,151.5 105.37,151.7 105.37,151.9 v2(105.55,152.08)
  IN3 w0.089: 102.84,151.49 101.07,151.49 99.92,152.64 99.2,152.64 98.86,152.3 98.86,152 97.9,151.04 91.29,151.04 90.03,149.78 79.56,149.78 73.64,143.86 73.64,143.73 73.93,143.44 73.93,143.17 73.53,142.77 73.25,142.77 73.01,143.01 72.86,143.01 72.59,142.74 72.59,142.58 72.83,142.35 72.83,142.07 68.38,137.62 61.47,137.62 60.78,136.93 60.78,136.82 59.9,135.94 59.14,135.94 58.78,136.3 58.78,136.62 58.67,136.72 v1(58.33,136.72)
  BOTTOM w0.102: JDIM02.140 57.55,136.82 57.96,137.23 58.62,137.23 58.86,137 58.86,136.84 58.74,136.72 v1(58.33,136.72) ; U1.AE28 105.55,151.91 v2(105.55,152.08)
M_B_CLKP0: length 62
  IN3 w0.079: v2(105.52,150.34) 105.28,150.58 102.58,150.58 102.57,150.58
  IN3 w0.089: 102.57,150.58 100.85,150.58 100.09,151.34 100.06,151.36 98.89,151.36 97.91,150.38 91.54,150.38 90.16,149 79.93,149 79.38,148.45 79.38,148.33 79.65,148.06 79.65,147.79 79.24,147.39 78.97,147.39 78.67,147.69 78.56,147.69 78.25,147.38 78.25,147.26 78.55,146.97 78.55,146.69 78.15,146.29 77.88,146.29 77.61,146.56 77.44,146.56 77.17,146.3 77.17,146.15 77.45,145.87 77.45,145.6 77.05,145.2 76.78,145.2 76.48,145.49 76.37,145.49 76.08,145.2 76.08,145.06 76.36,144.77 76.36,144.5 75.96,144.1 75.68,144.1 75.39,144.4 75.27,144.4 74.97,144.1 74.97,143.96 75.26,143.68 75.26,143.41 68.37,136.52 68.03,136.52 67.7,136.85 65.98,136.85 65.7,136.57 65.02,136.57 64.74,136.85 64.27,136.85 64.15,136.73 64.15,136.23 64,136.07 62.05,136.07 61.86,136.26 61.86,136.71 61.72,136.85 v1(61.55,136.85)
  BOTTOM w0.102: v1(61.55,136.85) 61.88,136.85 62.16,137.13 62.16,137.82 62.38,138.04 62.69,138.04 63.24,137.49 63.84,137.49 63.92,137.57 JDIM02.137 ; v2(105.52,150.34) 105.18,150.68 U1.AF29
M_B_CLKP1: length 61.3
  IN3 w0.079: v2(104.9,152.08) 105.11,152.08 105.21,151.98 105.21,151.76 105.1,151.66 102.86,151.66 102.85,151.66
  IN3 w0.089: 102.85,151.66 101.14,151.66 99.99,152.81 99.13,152.81 98.68,152.35 98.68,152.07 97.82,151.21 91.22,151.21 89.96,149.95 79.48,149.95 73.46,143.93 73.46,143.66 73.75,143.37 73.75,143.24 73.45,142.95 73.33,142.95 73.09,143.19 72.78,143.19 72.41,142.82 72.41,142.51 72.65,142.27 72.65,142.15 68.31,137.8 61.4,137.8 60.6,137 60.6,136.89 59.82,136.11 59.21,136.11 58.95,136.37 58.95,136.62 59.06,136.72 v1(59.6,136.72)
  BOTTOM w0.102: v2(104.9,152.08) 105.18,151.8 U1.AE29 ; JDIM02.138 57.77,137.32 57.88,137.43 58.71,137.43 59.06,137.08 59.06,136.93 59.27,136.72 v1(59.6,136.72)
M_B_CS#0: length 57.6
  IN3 w0.102: v2(97.85,147.74) 97.85,147.56 97,146.71 97,146.54 96.83,146.37 94.36,146.37 93.98,145.99 92.23,145.99 90.19,143.95 84.2,143.95 77.49,137.24 77.35,137.24 77.04,137.55 76.89,137.55 76.75,137.41 76.75,137.26 77.06,136.95 77.06,136.81 76.91,136.66 76.77,136.66 76.46,136.97 76.32,136.97 76.17,136.83 76.17,136.69 76.48,136.38 76.48,136.23 76.34,136.09 76.2,136.09 75.89,136.4 75.74,136.4 75.6,136.26 75.6,136.11 75.91,135.8 75.91,135.66 72.45,132.19 72.15,132.19 71.92,132.42 71.74,132.42 69.57,130.25 63.89,130.25 63.76,130.12 61.66,130.12 v1(61.2,129.66)
  BOTTOM w0.079: v2(97.85,147.74) 98.22,147.36 98.66,147.36 98.92,147.62 99.38,147.62 99.56,147.8 U1.AL37
  BOTTOM w0.14: JDIM02.149 63.69,132.57 63.3,132.97 61.8,132.97 60.63,131.8 60.63,130.24 v1(61.2,129.66)
M_B_CS#1: length 58.7
  IN3 w0.102: v2(96.02,147.74) 96.02,147.31 95.73,147.02 94.18,147.02 93.76,146.6 91.94,146.6 90.67,145.33 90.1,144.77 83.47,144.77 83.37,144.67 83.37,144.27 83.27,144.17 83.16,144.17 82.83,144.5 82.67,144.5 82.53,144.36 82.53,144.2 82.78,143.95 82.78,143.81 82.64,143.66 82.49,143.66 82.23,143.93 82.1,143.93 73.92,135.75 73.92,135.6 74.24,135.28 74.24,135.14 74.09,135 73.95,135 73.63,135.32 73.49,135.32 73.34,135.17 73.34,135.03 73.66,134.71 73.66,134.57 73.52,134.42 73.37,134.42 73.05,134.74 72.91,134.74 72.77,134.6 72.77,134.45 73.09,134.13 73.09,133.99 72.94,133.85 72.8,133.85 72.48,134.17 72.34,134.17 72.19,134.02 72.19,133.88 72.42,133.65 72.42,133.53 72.26,133.37 72.13,133.37 71.9,133.59 71.76,133.59 70.05,131.88 69.29,131.88 69.19,131.78 69.19,131.22 69.08,131.12 68.88,131.12 68.78,131.22 68.78,131.78 68.68,131.88 68.47,131.88 68.37,131.78 68.37,131.22 68.27,131.12 68.07,131.12 67.97,131.22 67.97,131.78 67.86,131.88 65.89,131.88 65.76,131.75 65.76,131.16 65.66,131.06 65.4,131.06 65.3,131.16 65.3,131.75 65.17,131.88 64.91,131.88 64.78,131.75 64.78,131.18 64.68,131.08 64.46,131.08 64.36,131.18 64.36,131.76 64.24,131.88 64.15,131.88 63.38,131.11 v1(63.13,131.11)
  BOTTOM w0.079: U1.AL35 101.21,147.48 100.66,147.48 100.34,147.38 99.61,147.38 99.52,147.29 99.03,147.29 98.78,147.04 97.32,147.04 97.02,147.33 96.42,147.33 v2(96.02,147.74)
  BOTTOM w0.14: JDIM02.157 63.67,130.57 v1(63.13,131.11)
M_B_DIM0_ODT0: length 59.1
  IN3 w0.102: v2(97.24,147.74) 97.24,147.49 96.5,146.75 94.23,146.75 93.75,146.27 92.04,146.27 90.13,144.36 84.03,144.36 82.93,143.25 82.15,143.25 82.15,143.25 82,143.25 80.8,142.05 80.8,141.91 81.12,141.59 81.12,141.44 80.97,141.3 80.83,141.3 80.51,141.62 80.37,141.62 80.22,141.48 80.22,141.33 80.54,141.01 80.54,140.87 80.4,140.73 80.25,140.73 79.93,141.04 79.79,141.04 79.65,140.9 79.65,140.76 79.97,140.44 79.97,140.29 79.82,140.15 79.68,140.15 79.36,140.47 79.21,140.47 79.07,140.33 79.07,140.18 79.39,139.86 79.39,139.72 79.25,139.58 79.1,139.58 78.78,139.89 78.64,139.89 78.5,139.75 78.5,139.61 78.82,139.29 78.82,139.14 78.67,139 78.53,139 78.21,139.32 78.06,139.32 77.92,139.18 77.92,139.03 78.24,138.71 78.24,138.57 78.1,138.42 77.95,138.42 77.63,138.74 77.49,138.74 77.35,138.6 77.35,138.46 77.67,138.14 77.67,137.99 77.52,137.85 77.38,137.85 77.06,138.17 76.91,138.17 74.67,135.93 74.67,135 72.44,132.77 72.15,132.77 71.96,132.96 71.71,132.96 69.4,130.65 63.71,130.65 63.58,130.53 62.02,130.53 61.81,130.74 v1(61.81,131.11)
  BOTTOM w0.079: v2(97.24,147.74) 97.78,147.2 98.71,147.2 98.97,147.46 99.45,147.46 99.54,147.55 100.32,147.55 100.63,147.65 100.73,147.65 U1.AL36
  BOTTOM w0.14: v1(61.81,131.11) 62.29,130.63 62.92,130.63 63.98,129.57 JDIM02.161
M_B_DIM0_ODT1: length 59.6
  IN3 w0.102: v2(98.45,147.79) 98.58,147.92 98.74,147.92 98.94,147.73 98.94,147.52 98.43,147.01 97.76,147.01 97.61,146.86 97.61,146.61 97.71,146.51 98.54,146.51 98.63,146.42 98.63,146.08 98.54,145.99 94.49,145.99 94.22,145.72 92.28,145.72 91.89,145.33 91.89,145.25 90.18,143.55 84.37,143.55 72.3,131.47 72.08,131.47 71.8,131.76 71.66,131.76 71.51,131.61 71.51,131.47 71.78,131.2 71.78,131.07 71.63,130.92 71.48,130.92 71.22,131.18 71.08,131.18 70.94,131.04 70.94,130.89 71.15,130.68 71.15,130.53 71.01,130.39 70.87,130.39 70.65,130.61 70.51,130.61 69.74,129.84 64.17,129.84 63.56,129.23 62.99,129.23 v1(62.55,129.66)
  BOTTOM w0.079: v2(98.45,147.79) 98.47,147.78 99.3,147.78 99.58,148.06 100.36,148.06 100.43,148.03 100.71,148.03 100.79,148.06 101.01,148.06 101.09,148.03 101.34,148.03 101.41,148.06 101.93,148.06 U1.AL34
  BOTTOM w0.14: JDIM02.155 63.92,131.07 63.27,131.72 61.6,131.72 61.27,131.39 61.27,130.78 61.75,130.3 61.92,130.3 v1(62.55,129.66)
M_B_DQ0: length 62.2
  IN3 w0.084: v2(108.97,160.64) 108.37,161.23 108.37,163.65 107.87,164.15 107.7,164.15 107.28,164.57 104.75,167.1 104.75,167.89 104.01,168.64 101.59,168.64 101.07,169.16 96.92,169.16 96.75,169.34 77.52,169.34 77.44,169.26 77.44,168.62 77.34,168.52 77.16,168.52 77.1,168.59 77.1,168.91 77.02,169 76.85,169 76.76,168.91 76.76,168.66 76.63,168.52 70.58,168.52 67.33,165.28 61.27,165.28 v1(60.77,165.77)
  BOTTOM w0.102: U1.J22 109.49,161.16 v2(108.97,160.64)
  BOTTOM w0.114: v1(60.77,165.77) 60.77,165.5 61.7,164.57 JDIM02.29
M_B_DQ1: length 64.7
  IN3 w0.084: v2(107.01,161.49) 106.63,161.86 106.63,162.28 105.79,163.13 105.79,163.3 103.92,165.17 102.11,165.17 100.69,166.59 100.69,167.02 100.06,167.65 96.85,167.65 96.61,167.4 95.11,167.4 95.01,167.31 95.01,167.01 94.94,166.94 94.71,166.94 94.63,167.02 94.63,167.34 94.54,167.42 94.37,167.42 94.29,167.34 94.29,167.02 94.2,166.94 94.03,166.94 93.95,167.02 93.95,167.34 93.87,167.42 93.7,167.42 93.61,167.34 93.61,167.02 93.53,166.94 93.36,166.94 93.27,167.02 93.27,167.34 93.19,167.42 93.02,167.42 92.94,167.34 92.94,167.02 92.85,166.94 92.54,166.94 92.47,167.01 92.47,167.34 92.39,167.42 92.17,167.42 92.07,167.32 92.07,166.79 91.97,166.69 91.72,166.69 91.64,166.77 91.64,167.34 91.56,167.42 91.39,167.42 91.3,167.34 91.3,166.77 91.22,166.69 91.05,166.69 90.96,166.77 90.96,167.34 90.88,167.42 90.71,167.42 90.63,167.34 90.63,166.77 90.54,166.69 88.28,166.69 88.19,166.77 88.19,167.34 88.11,167.42 87.94,167.42 87.86,167.34 87.86,166.77 87.77,166.69 71.46,166.69 67.92,163.14 66.27,163.14 65.93,162.8 65.7,162.8 65.64,162.86 65.64,163.06 65.56,163.14 65.3,163.14 65.23,163.07 65.23,162.84 65.14,162.75 64.96,162.75 64.89,162.82 64.89,163.07 64.81,163.14 64.6,163.14 64.51,163.06 64.51,162.38 64.45,162.31 64.28,162.31 64.17,162.42 64.17,163.06 64.09,163.14 63.92,163.14 63.84,163.06 63.84,162.38 63.77,162.31 63.55,162.31 63.5,162.37 63.5,163.06 63.42,163.14 62.62,163.14 62.33,162.85 v1(62.33,162.67)
  BOTTOM w0.102: v2(107.01,161.49) 107.35,161.84 U1.H25
  BOTTOM w0.114: v1(62.33,162.67) 62.82,163.16 63.36,163.16 63.94,162.57 JDIM02.37
M_B_DQ2: length 61.6
  IN3 w0.084: v1(58.13,165.76) 58.45,166.07 59.94,166.75 67.29,166.75 70.08,169.54 73.21,169.54 74.07,170.41 97.19,170.41 97.37,170.23 99.39,170.23 99.49,170.12 101.67,170.12 102.25,169.53 104.43,169.53 105.64,168.32 105.64,167.63 106.41,166.86 106.75,166.86 107.89,165.73 109.23,164.22 109.55,163.46 109.55,162.42 v2(108.94,161.81)
  BOTTOM w0.102: v2(108.94,161.81) 109.49,162.36 U1.G22
  BOTTOM w0.114: JDIM02.28 57.48,164.82 57.97,165.31 57.97,165.59 v1(58.13,165.76)
M_B_DQ3: length 61
  IN3 w0.084: v1(62.19,165.8) 67.35,165.8 70.41,168.86 74.1,168.86 74.19,168.95 74.19,169.12 74.27,169.2 74.44,169.2 74.52,169.12 74.52,168.95 74.61,168.86 74.78,168.86 74.86,168.95 74.86,169.6 74.95,169.69 75.12,169.69 75.2,169.6 75.2,168.95 75.28,168.86 75.52,168.86 75.6,168.95 75.6,169.61 75.69,169.7 75.86,169.7 75.94,169.61 75.94,168.95 76.02,168.86 76.19,168.86 76.28,168.95 76.28,169.61 76.36,169.7 96.89,169.7 97.07,169.52 101.14,169.52 101.74,168.92 104.15,168.92 105.06,168.02 105.06,167.12 107.8,164.38 107.96,164.38 108.56,163.78 108.56,161.63 108.95,161.24 v2(108.97,161.23)
  BOTTOM w0.102: U1.H22 109.49,161.75 v2(108.97,161.23)
  BOTTOM w0.114: v1(62.19,165.8) 62.42,165.57 JDIM02.25
M_B_DQ4: length 64.7
  IN3 w0.084: v2(106.97,162.74) 106.55,163.16 106.55,163.39 104.27,165.68 102.4,165.68 101.29,166.78 101.29,167.11 100.22,168.18 85.08,168.18 84.99,168.09 84.99,167.47 84.91,167.39 84.74,167.39 84.66,167.47 84.66,168.09 84.57,168.18 84.4,168.18 84.32,168.09 84.32,167.47 84.23,167.39 84.06,167.39 83.98,167.47 83.98,168.09 83.9,168.18 83.73,168.18 83.64,168.09 83.64,167.47 83.56,167.39 83.39,167.39 83.3,167.47 83.3,168.09 83.22,168.18 83.05,168.18 82.97,168.09 82.97,167.47 82.88,167.39 82.71,167.39 82.63,167.47 82.63,168.09 82.54,168.18 82.37,168.18 82.29,168.09 82.29,167.47 82.21,167.39 82.04,167.39 81.95,167.47 81.95,168.09 81.87,168.18 81.68,168.18 81.59,168.09 81.59,167.46 81.49,167.36 71.13,167.36 67.77,164 61.57,164 60.43,162.86 58.32,162.86 58.22,162.76 58.22,162.58 58.31,162.49 58.52,162.49 58.57,162.44 v1(58.57,162.08)
  BOTTOM w0.102: U1.F25 107.37,163.14 v2(106.97,162.74)
  BOTTOM w0.114: v1(58.57,162.08) 57.81,161.32 JDIM02.42
M_B_DQ5: length 63.2
  IN3 w0.084: v2(107,160.88) 106.47,161.41 106.47,162.21 106.21,162.47 106.15,162.47 103.7,164.91 101.98,164.91 100.33,166.56 100.33,167.02 99.92,167.43 97.06,167.43 96.72,167.09 95.76,167.09 95.27,166.6 92.45,166.6 92.2,166.35 71.65,166.35 68.11,162.8 66.84,162.8 66.74,162.7 66.74,162.48 66.82,162.4 67.37,162.4 67.48,162.29 67.48,162.17 67.28,161.98 67.06,161.98 67.02,161.94 67.02,161.71 66.93,161.62 66.72,161.62 66.64,161.71 66.64,162.08 66.58,162.14 66.29,162.14 66.23,162.07 66.23,161.75 66.14,161.67 65.97,161.67 65.89,161.75 65.89,162.36 65.81,162.44 65.62,162.44 65.55,162.37 65.55,161.48 65.49,161.42 65.28,161.42 65.21,161.48 65.21,162.33 65.13,162.41 64.96,162.41 64.87,162.33 64.87,161.49 64.8,161.42 64.6,161.42 64.54,161.48 64.54,161.89 64.45,161.98 61.2,161.98 61.09,162.08 v1(61.09,162.34)
  BOTTOM w0.102: U1.J25 107.3,161.19 v2(107,160.88)
  BOTTOM w0.114: JDIM02.41 61.86,161.57 v1(61.09,162.34)
M_B_DQ6: length 62.3
  IN3 w0.084: v1(59.84,162.11) 59.97,161.98 60.45,161.98 60.57,162.09 60.57,162.52 60.81,162.77 61.69,163.65 61.88,163.65 61.99,163.54 61.99,163.39 62.06,163.31 62.32,163.31 62.41,163.4 62.41,163.58 62.47,163.65 66.96,163.65 67.13,163.48 67.75,163.48 71.3,167.02 85.31,167.02 85.41,167.12 85.41,167.76 85.49,167.84 85.66,167.84 85.75,167.76 85.75,167.1 85.82,167.02 85.99,167.02 86.08,167.12 86.08,167.74 86.18,167.84 86.35,167.84 86.42,167.77 86.42,167.1 86.49,167.02 86.66,167.02 86.76,167.12 86.76,167.74 86.86,167.84 87.03,167.84 87.1,167.77 87.1,167.1 87.17,167.02 87.34,167.02 87.43,167.12 87.43,167.71 87.56,167.84 96.56,167.84 96.62,167.9 100.11,167.9 101.01,167.01 101.01,166.65 102.24,165.42 104.14,165.42 106.14,163.42 106.17,163.39 106.17,162.98 107.01,162.15 v2(107.01,162.1)
  BOTTOM w0.102: v2(107.01,162.1) 107.01,162.15 107.34,162.49 U1.G25
  BOTTOM w0.114: JDIM02.38 57.48,162.32 57.81,162.65 59.29,162.65 v1(59.84,162.11)
M_B_DQ7: length 61.2
  IN3 w0.084: v1(59.45,165.8) 59.45,165.87 59.97,166.39 62.49,166.39 62.74,166.14 67.19,166.14 70.25,169.2 73.74,169.2 74.05,169.51 74.05,169.69 74.4,170.05 97.04,170.05 97.22,169.87 101.29,169.87 101.97,169.19 104.31,169.19 105.36,168.14 105.36,167.36 106.06,166.66 106.61,166.66 107.58,165.7 107.58,165.41 107.85,165.13 109,163.98 109,163.47 109.32,163.14 109.32,162.77 v2(108.95,162.39)
  BOTTOM w0.102: v2(108.95,162.39) 109.49,162.94 U1.F22
  BOTTOM w0.114: v1(59.45,165.8) 58.66,166.6 58.06,166.6 57.68,166.22 57.68,166.04 57.47,165.82 JDIM02.24
M_B_DQ8: length 68
  IN3 w0.084: v1(63.48,172.23) 64.06,172.82 66.73,172.82 66.81,172.73 66.81,172.24 66.89,172.16 67.07,172.16 67.15,172.25 67.15,172.73 67.24,172.82 67.77,172.82 68.3,173.34 70.09,173.34 70.18,173.43 70.18,174.11 70.26,174.19 70.43,174.19 70.51,174.11 70.51,173.43 70.6,173.34 70.77,173.34 70.85,173.43 70.85,174.11 70.93,174.19 71.11,174.19 71.19,174.11 71.19,173.43 71.27,173.34 71.44,173.34 71.53,173.43 71.53,174.11 71.61,174.19 86.98,174.19 87.77,174.98 90.33,174.98 91.01,175.66 91.24,175.66 95.75,180.18 99.09,180.18 105.11,174.16 105.7,174.16 106.62,173.24 107.98,173.24 109.42,171.79 109.42,168.64 v2(108.98,168.2)
  BOTTOM w0.079: v2(108.98,168.2) 109.47,167.72 109.47,166.1 109.41,166.04 109.41,165.63 109.44,165.5 109.44,165.25 109.41,165.18 109.41,164.97 109.44,164.91 109.44,164.68 109.41,164.52 109.41,164.35 109.46,164.2 109.46,163.99 U1.D22
  BOTTOM w0.114: v1(63.48,172.23) 63.67,172.04 63.67,171.28 63.88,171.07 JDIM02.3
M_B_DQ9: length 68.3
  IN3 w0.084: v1(59.34,172.06) 60.04,171.37 67.33,171.37 68.6,172.64 71.92,172.64 72.79,173.51 87.26,173.51 88.05,174.3 90.61,174.3 91.26,174.95 91.53,174.95 96.05,179.47 98.85,179.47 104.83,173.48 105.42,173.48 106.34,172.56 107.62,172.56 108.51,171.67 v1(108.51,171.22)
  BOTTOM w0.079: U1.C22 110,164.76 110,165.4 110.09,165.57 110.09,168.08
  BOTTOM w0.102: 110.09,169.99 110.09,168.08
  BOTTOM w0.114: JDIM02.8 57.58,169.82 58.26,170.5 59.29,172 v1(59.34,172.06) ; 110.09,169.99 110.09,170.3 109.17,171.22 v1(108.51,171.22)
M_B_DQ10: length 67.8
  IN3 w0.084: v1(106.99,169.57) 106.84,169.41 106.18,169.41 105.77,169.82 104.98,169.82 104.63,170.18 103.36,170.18 102.29,171.24 97.72,171.24 97.23,171.73 95.58,171.73 94.91,172.4 93.61,172.4 93.34,172.67 92.06,172.67 91.51,172.12 89.03,172.12 88.72,171.81 88.72,171.51 88.55,171.34 73.69,171.34 72.82,170.47 69.65,170.47 66.89,167.71 60.48,167.71 60.36,167.84 60.36,168.68 60.48,168.8 60.48,169.15 60.34,169.29 60.09,169.29 60.02,169.21 60.02,167.86 59.92,167.76 59.79,167.76 59.67,167.89 59.67,169.11 59.54,169.24 58.32,169.24 58.21,169.13 58.21,168.89 58.27,168.82 59.15,168.82 59.24,168.73 v1(59.24,168.4)
  BOTTOM w0.079: 107.77,166.78 107.77,166 108.01,165.44 108.01,165.32 108.02,165.31 108.11,165.22 108.11,164.69 U1.C24
  BOTTOM w0.102: v1(106.99,169.57) 107.77,168.79 107.77,166.78
  BOTTOM w0.114: v1(59.24,168.4) 59.24,167.68 58.47,166.9 57.71,166.9 57.63,166.82 JDIM02.20
M_B_DQ11: length 67.7
  IN3 w0.084: v1(57.91,168.4) 58.94,167.36 67.04,167.36 69.81,170.13 72.96,170.13 73.83,171 88.97,171 89.06,171.08 89.06,171.67 89.13,171.75 89.3,171.75 89.39,171.66 89.39,171.08 89.48,171 89.65,171 89.73,171.08 89.73,171.67 89.81,171.75 89.98,171.75 90.07,171.66 90.07,171.08 90.15,171 90.32,171 90.41,171.08 90.41,171.67 90.49,171.75 90.66,171.75 90.74,171.66 90.74,171.08 90.83,171 91,171 91.08,171.08 91.08,171.67 91.16,171.75 91.33,171.75 91.42,171.66 91.42,171.08 91.5,171 91.75,171 91.83,171.08 91.83,171.97 92.17,172.3 93.2,172.3 93.46,172.04 94.76,172.04 95.43,171.37 97.09,171.37 97.62,170.84 99.42,170.84 99.91,170.35 101.95,170.35 102.46,169.84 104.53,169.84 104.83,169.54 105.59,169.54 106.12,169.01 107.04,169.01 107.6,168.45 107.6,168.35 v2(108.99,166.96)
  BOTTOM w0.079: v2(108.99,166.96) 109.3,166.64 109.3,166.17 109.24,166.11 109.24,165.61 109.27,165.48 109.27,165.28 109.24,165.21 109.24,164.93 109.28,164.87 109.28,164.73 109.24,164.53 109.24,164.33 109.3,164.17 109.3,163.99 109.09,163.79 U1.D24
  BOTTOM w0.114: JDIM02.16 57.89,167.82 58.01,167.95 58.01,168.29 v1(57.91,168.4)
M_B_DQ12: length 66.5
  IN3 w0.084: v1(58.02,172.05) 58.02,171.38 58.16,171.25 58.49,171.25 58.7,171.45 58.91,171.45 59,171.37 59,171.17 59.15,171.01 67.54,171.01 68.83,172.31 72.06,172.31 72.93,173.18 87.4,173.18 88.18,173.96 90.75,173.96 91.38,174.59 91.68,174.59 96.2,179.11 98.7,179.11 104.67,173.15 105.28,173.15 106.2,172.22 107.37,172.22 107.55,172.05 107.55,171.5 107.95,171.09 107.95,170.93 108.54,170.34 108.54,169.92 v2(108.98,169.47)
  BOTTOM w0.079: v2(108.98,169.47) 109.38,169.08 109.38,168.13 109.67,167.85 U1.A22
  BOTTOM w0.114: v1(58.02,172.05) 58.02,171.29 57.55,170.82 JDIM02.4
M_B_DQ13: length 67.5
  IN3 w0.084: v2(108.99,170.74) 108.99,171.72 107.82,172.9 106.48,172.9 105.56,173.82 104.97,173.82 98.97,179.82 95.9,179.82 91.38,175.3 91.14,175.3 90.47,174.64 87.91,174.64 87.12,173.85 72.65,173.85 71.78,172.98 68.44,172.98 67.18,171.73 66.57,171.73 66.46,171.84 66.46,172.12 66.38,172.2 66.19,172.2 66.1,172.12 66.1,171.8 66.03,171.73 65.81,171.73 65.73,171.81 65.73,172.26 65.64,172.34 65.47,172.34 65.38,172.25 65.38,171.8 65.31,171.73 65.14,171.73 65.04,171.82 65.04,172.39 64.96,172.48 64.79,172.48 64.7,172.39 64.7,171.8 64.63,171.73 62.41,171.73 v1(62.15,171.98)
  BOTTOM w0.079: U1.B22 109.83,165.25 109.83,165.44 109.92,165.61 109.92,167.81 109.55,168.19 109.55,170.18 v2(108.99,170.74)
  BOTTOM w0.114: v1(62.15,171.98) 62.51,171.63 62.51,171.3 63.73,170.07 JDIM02.7
M_B_DQ14: length 67.3
  IN3 w0.084: v2(107.9,169.59) 107.6,169.59 107.06,170.13 106.76,170.13 106.64,170.24 106.52,170.24 104.8,171.95 98.01,171.95 97.53,172.44 95.87,172.44 95.2,173.11 93.91,173.11 93.63,173.38 91.81,173.38 91.23,172.8 88.75,172.8 87.96,172.01 73.41,172.01 72.54,171.14 69.32,171.14 68.02,169.85 66.57,169.85 66.45,169.73 66.45,168.5 66.35,168.41 66.05,168.41 65.97,168.49 65.97,169.76 65.88,169.85 65.71,169.85 65.63,169.76 65.63,168.49 65.55,168.41 65.36,168.41 65.29,168.48 65.29,169.76 65.21,169.85 65.04,169.85 64.95,169.76 64.95,168.5 64.86,168.41 64.69,168.41 64.62,168.48 64.62,169.76 64.53,169.85 60.94,169.85 60.86,169.76 60.86,169.6 60.99,169.47 61.67,169.47 61.79,169.35 61.79,169.19 v1(62.02,168.96)
  BOTTOM w0.079: v2(107.9,169.59) 108.18,169.31 108.18,166.02 108.37,165.84 U1.A24
  BOTTOM w0.114: v1(62.02,168.96) 63.41,167.57 JDIM02.17
M_B_DQ15: length 68.1
  IN3 w0.084: v2(105.9,170.23) 105.77,170.1 105.13,170.1 104.73,170.51 103.63,170.51 102.54,171.6 97.87,171.6 97.38,172.08 95.73,172.08 95.05,172.75 93.76,172.75 93.49,173.03 91.94,173.03 91.37,172.46 88.89,172.46 88.1,171.67 73.55,171.67 72.68,170.81 69.48,170.81 66.75,168.07 64.28,168.07 64.19,168.15 64.19,169.09 64.1,169.19 63.93,169.19 63.86,169.11 63.86,168.15 63.77,168.07 63.6,168.07 63.52,168.15 63.52,169.44 63.45,169.51 63.24,169.51 63.18,169.45 63.18,168.15 63.1,168.07 62.93,168.07 62.84,168.15 62.84,169.41 62.74,169.51 62.57,169.51 62.51,169.44 62.51,168.15 62.42,168.07 61.13,168.07 v1(60.78,168.43)
  BOTTOM w0.079: 107.45,169.69 107.45,169.5 107.98,168.97 107.98,165.93 108.18,165.48 108.37,165.29 U1.B24
  BOTTOM w0.114: v2(105.9,170.23) 106.91,170.23 107.45,169.69 ; v1(60.78,168.43) 60.78,167.39 60.98,167.19 62.3,167.19 62.91,166.57 JDIM02.21
M_B_DQ16: length 54.3
  IN3 w0.084: v2(103.64,163.05) 103.25,163.43 102.7,163.43 102.11,164.02 101.63,164.02 100.36,165.29 92.94,165.29 92.72,165.08 72.23,165.08 70.85,163.7 70.85,163.59 71.37,163.07 71.37,162.95 71.25,162.83 71.13,162.83 70.61,163.35 70.5,163.35 70.38,163.23 70.38,163.11 70.92,162.57 70.92,162.46 69.88,161.43 68.55,161.43 67.07,159.94 63.97,159.94 63.29,160.63 60.98,160.63 60.83,160.47 60.83,160.18 60.9,160.1 v1(61.14,160.1)
  BOTTOM w0.102: U1.G31 103.88,162.8 v2(103.64,163.05)
  BOTTOM w0.114: JDIM02.49 63.88,159.57 63.77,159.47 61.78,159.47 v1(61.14,160.1)
M_B_DQ17: length 56.3
  IN3 w0.084: v2(102.96,163.03) 102.72,163.03 102.11,163.64 101.6,163.64 100.31,164.94 93.1,164.94 92.91,164.74 73.67,164.74 73.24,164.31 73.12,164.31 72.68,164.74 72.6,164.74 72.45,164.59 72.45,164.5 72.88,164.07 72.88,163.95 72.76,163.83 72.64,163.83 72.11,164.36 71.99,164.36 71.87,164.24 71.87,164.12 72.4,163.59 72.4,163.47 72.28,163.35 72.16,163.35 71.63,163.88 71.52,163.88 71.39,163.76 71.39,163.64 71.92,163.11 71.92,162.99 70.02,161.09 68.69,161.09 67.19,159.59 62.84,159.59 62.48,159.23 60.45,159.23 60.37,159.3 60.37,159.58 60.47,159.67 62.3,159.67 62.46,159.83 v1(62.46,160.11)
  BOTTOM w0.102: U1.G32 103.23,162.75 v2(102.96,163.03)
  BOTTOM w0.114: JDIM02.45 62.93,160.57 v1(62.46,160.11)
M_B_DQ18: length 55.2
  IN3 w0.084: v1(62.86,156.49) 62.86,156.5 63.35,156.99 63.94,156.99 64.02,156.91 64.02,156.49 64.13,156.37 64.4,156.37 64.47,156.45 64.47,156.92 64.56,157 64.73,157 64.81,156.92 64.81,156.39 64.88,156.32 65.12,156.32 65.25,156.45 65.25,157.34 65.49,157.58 65.59,157.58 65.69,157.48 65.69,156.67 65.78,156.57 65.98,156.57 66.12,156.71 66.12,157.49 66.2,157.57 66.42,157.57 66.51,157.48 66.51,156.67 66.6,156.57 66.86,156.57 66.92,156.63 66.92,157.47 67.03,157.58 67.21,157.58 67.27,157.53 67.27,156.96 67.35,156.88 67.5,156.88 67.61,156.98 67.61,157.48 67.7,157.58 68.4,157.58 69.7,158.88 70.41,158.88 70.63,159.1 74.36,162.83 93.03,162.83 93.03,162.83 98.32,162.83 98.98,162.17 100.79,162.17 101.09,161.87 102.11,161.87 102.44,161.53 104.47,161.53 v2(104.79,161.21)
  BOTTOM w0.102: v2(104.79,161.21) 105.18,161.6 U1.H29
  BOTTOM w0.114: JDIM02.59 63.41,157.07 62.86,156.52 v1(62.86,156.49)
M_B_DQ19: length 55.6
  IN3 w0.084: v1(59.91,156.93) 59.63,156.64 59.63,155.76 59.73,155.66 61.52,155.66 61.84,155.98 65.74,155.98 66,156.24 67.53,156.24 69.84,158.54 70.55,158.54 70.77,158.76 71.01,159 74.5,162.49 93.37,162.49 93.48,162.6 98.2,162.6 98.86,161.94 100.64,161.94 100.97,161.61 102.03,161.61 102.28,161.37 103.95,161.37 104.02,161.3 104.13,161.19 104.36,160.97 104.54,160.97 104.7,160.81 105.13,160.81 v2(105.51,161.2)
  BOTTOM w0.102: v2(105.51,161.2) 105.83,161.51 U1.H28
  BOTTOM w0.114: JDIM02.58 57.69,157.32 57.8,157.44 58.26,157.44 58.57,157.76 59.38,157.76 59.91,157.22 v1(59.91,156.93)
M_B_DQ20: length 54.3
  IN3 w0.084: v1(58.59,159.85) 60.12,161.38 63.53,161.38 64.09,160.82 66.97,160.82 71.9,165.76 92.44,165.76 92.69,166.01 95.52,166.01 96.05,166.53 99.9,166.53 101.78,164.66 103.38,164.66 v2(105,163.04)
  BOTTOM w0.102: v2(105,163.04) 105.31,163.04 105.79,162.56 U1.G28
  BOTTOM w0.114: v1(58.59,159.85) 58.12,160.32 JDIM02.46
M_B_DQ21: length 55.7
  IN3 w0.084: v1(59.91,159.78) 59.91,160.03 60.84,160.96 63.45,160.96 64.12,160.3 66.94,160.3 68.63,161.99 68.75,161.99 68.98,161.76 69.09,161.76 69.21,161.89 69.21,162 68.99,162.23 68.99,162.35 69.11,162.47 69.23,162.47 69.63,162.07 69.74,162.07 69.86,162.19 69.86,162.32 69.47,162.71 69.47,162.82 72.06,165.42 92.58,165.42 92.81,165.65 95.73,165.65 96.31,166.23 99.85,166.23 101.65,164.43 102.95,164.43 v2(104.37,163.02)
  BOTTOM w0.102: v2(104.37,163.02) 104.49,163.02 104.95,162.56 U1.G29
  BOTTOM w0.114: v1(59.91,159.78) 59.45,159.32 JDIM02.50
M_B_DQ22: length 55.6
  IN3 w0.084: v2(103.64,162.1) 103.25,161.72 102.53,161.72 102.13,162.12 101.22,162.12 100.31,163.03 98.58,163.03 98.55,163.06 93.28,163.06 93.12,163.22 74.28,163.22 70.27,159.22 69.81,159.22 69.44,159.59 69.31,159.59 69.07,159.35 69.07,159.23 69.26,159.04 69.26,158.92 69.14,158.8 69.02,158.8 68.83,158.99 68.71,158.99 68.54,158.82 68.54,158.74 68.7,158.58 68.7,158.42 68.58,158.3 68.43,158.3 68.29,158.45 68.17,158.45 67.64,157.92 65.35,157.92 64.77,157.34 63.22,157.34 62.86,156.98 60.54,156.98 60.37,156.81 60.37,156.52 60.25,156.4 60.03,156.4 59.97,156.34 59.97,156.08 60.05,156 60.65,156 60.75,156.1 60.75,156.57 60.81,156.63 61.18,156.63 v1(61.26,156.55)
  BOTTOM w0.102: v2(103.64,162.1) 103.73,162.01 103.73,161.8 U1.H31
  BOTTOM w0.114: JDIM02.63 61.6,156.07 61.26,156.42 v1(61.26,156.55)
M_B_DQ23: length 56.6
  IN3 w0.084: v1(58.59,156.92) 58.85,156.66 58.85,156.34 58.76,156.26 58.18,156.26 58.09,156.17 58.09,155.6 57.97,155.48 57.53,155.48 57.45,155.56 57.45,157.16 57.64,157.35 62.75,157.35 63.08,157.68 64.63,157.68 65.23,158.27 67.52,158.27 69.17,159.92 70.5,159.92 70.85,160.28 70.85,160.28 74.15,163.58 93.23,163.58 93.52,163.29 99,163.29 99.61,163.9 99.95,163.9 101.47,162.37 102.21,162.37 102.48,162.11 v2(102.98,162.11)
  BOTTOM w0.102: v2(102.98,162.11) 103.08,162.01 103.08,161.8 U1.H32
  BOTTOM w0.114: v1(58.59,156.92) 58.59,156.77 58.14,156.32 JDIM02.62
M_B_DQ24: length 56.4
  IN3 w0.084: v1(59.52,154.5) 59.52,153.69 59.45,153.62 58.5,153.62 58.41,153.53 58.41,153.23 58.48,153.15 61.01,153.15 61.4,153.55 62.16,153.55 62.29,153.67 62.29,154.38 62.63,154.71 67.8,154.71 70.36,157.28 71.13,157.28 75.04,161.19 93.48,161.19 93.55,161.26 98.65,161.26 99.31,160.6 99.95,160.6 100.21,160.86 103.65,160.86 104.22,160.28 v2(104.26,160.28)
  BOTTOM w0.102: U1.L31 103.88,159.91 v2(104.26,160.28)
  BOTTOM w0.114: JDIM02.66 58.7,155.32 v1(59.52,154.5)
M_B_DQ25: length 57.4
  IN3 w0.084: v2(103.59,160.29) 103.24,160.64 102.49,160.64 102.49,160.64 100.37,160.64 100.08,160.34 98.67,160.34 98.52,160.49 98.52,160.77 98.27,161.03 93.77,161.03 93.58,160.84 75.19,160.84 71.29,156.94 71.13,156.94 71.01,156.82 71.01,156.66 70.92,156.57 70.8,156.57 70.54,156.84 70.4,156.84 70.28,156.72 70.28,156.61 70.57,156.33 70.57,156.21 70.45,156.09 70.33,156.09 70.05,156.36 69.93,156.36 69.81,156.24 69.81,156.13 70.09,155.85 70.09,155.73 69.97,155.61 69.85,155.61 69.57,155.89 69.46,155.89 69.34,155.77 69.34,155.65 69.61,155.37 69.61,155.25 69.49,155.13 69.37,155.13 69.09,155.41 68.98,155.41 68.84,155.28 68.84,155.18 69.13,154.89 69.13,154.78 68.95,154.59 68.85,154.59 68.55,154.89 68.46,154.89 68.28,154.72 68.28,154.64 68.42,154.5 68.42,154.39 68.32,154.29 66.38,154.29 66.29,154.37 65.68,154.37 65.61,154.3 65.61,154.18 65.51,154.08 65.36,154.08 65.27,154.17 65.27,154.33 65.22,154.37 64.93,154.37 64.86,154.3 64.86,153.99 65.06,153.79 65.06,153.63 64.82,153.38 64.54,153.38 64.46,153.47 64.46,154.29 64.37,154.38 63.97,154.38 63.88,154.29 63.88,154.08 64.06,153.89 64.06,153.48 63.97,153.38 63.61,153.38 63.55,153.44 63.55,153.78 63.47,153.86 63.3,153.86 63.21,153.78 63.21,153.44 63.15,153.38 62.85,153.38 62.78,153.45 v1(62.78,154.26)
  BOTTOM w0.102: v2(103.59,160.29) 103.23,159.93 U1.L32
  BOTTOM w0.114: JDIM02.71 63.84,154.07 63.32,153.56 62.87,153.56 62.78,153.65 v1(62.78,154.26)
M_B_DQ26: length 55.5
  IN3 w0.084: v1(61.53,151.18) 61.37,151.02 61.37,150.25 61.49,150.14 62.09,150.14 62.18,150.22 62.18,150.67 62.26,150.76 62.43,150.76 62.51,150.67 62.51,150.22 62.6,150.14 64.33,150.14 64.72,150.53 65.34,150.53 66.02,151.21 66.24,151.21 66.53,151.5 67,151.5 67.29,151.21 67.29,150.97 67.17,150.85 67.17,150.7 67.34,150.53 67.53,150.53 68.72,151.72 75.92,158.91 94.83,158.91 95.18,158.56 101.26,158.56 101.51,158.31 102.35,158.31 102.61,158.06 104.53,158.06 v2(104.9,158.43)
  BOTTOM w0.102: U1.N29 105.18,158.71 v2(104.9,158.43)
  BOTTOM w0.114: v1(61.53,151.18) 61.53,151.46 62.15,152.07 JDIM02.79
M_B_DQ27: length 54.9
  IN3 w0.084: v1(58.59,151.13) 58.59,150.52 59.31,149.8 64.47,149.8 64.86,150.19 67.67,150.19 76.04,158.55 94.84,158.55 95.04,158.35 100.93,158.35 101,158.28 101.38,157.89 105.02,157.89 v2(105.56,158.43)
  BOTTOM w0.102: v2(105.56,158.43) 105.83,158.7 U1.N28
  BOTTOM w0.114: JDIM02.84 57.56,150.82 57.79,150.59 58.05,150.59 v1(58.59,151.13)
M_B_DQ28: length 53.3
  IN3 w0.084: v1(60.8,154.42) 62.16,155.39 66.5,155.39 66.76,155.64 67.78,155.64 70.08,157.95 70.8,157.95 74.75,161.9 92.61,161.9 92.8,161.71 100.48,161.71 100.84,161.36 101.98,161.36 102.14,161.2 103.82,161.2 103.87,161.15 104.21,160.8 104.47,160.8 104.63,160.65 105.18,160.65 v2(105.55,160.28)
  BOTTOM w0.102: v2(105.55,160.28) 105.83,159.99 U1.L28
  BOTTOM w0.114: v1(60.8,154.42) 61.45,155.07 JDIM02.67
M_B_DQ29: length 54
  IN3 w0.084: v2(104.87,160.26) 104.78,160.26 104.4,160.63 104.14,160.63 103.75,161.03 102,161.03 101.92,161.1 100.71,161.1 100.33,161.48 92.37,161.48 92.3,161.55 74.9,161.55 70.96,157.61 70.22,157.61 67.66,155.05 62.47,155.05 61.96,154.54 61.96,154.08 61.78,153.9 60.56,153.9 60.18,154.28 60.18,154.85 60,155.03 58.43,155.03 58.2,154.81 58.2,154.54 v1(58.15,154.49)
  BOTTOM w0.102: U1.L29 105.18,159.95 v2(104.87,160.26)
  BOTTOM w0.114: JDIM02.70 57.99,154.32 v1(58.15,154.49)
M_B_DQ30: length 55.8
  IN3 w0.084: v2(103.52,159.32) 103.12,158.92 102.46,158.92 102.32,158.77 95.42,158.77 94.93,159.26 75.77,159.26 69.25,152.75 69.06,152.75 68.86,152.55 68.86,152.36 68.58,152.07 68.06,152.07 68,152 68,151.47 67.89,151.36 67.63,151.36 67.53,151.46 67.53,151.97 67.43,152.07 67.09,152.07 67.01,151.99 67.01,151.92 66.92,151.84 66.75,151.84 66.67,151.92 66.67,151.99 66.59,152.07 66.17,152.07 66.07,151.97 66.07,151.65 66,151.57 65.78,151.57 65.69,151.67 65.69,151.77 65.62,151.84 65.27,151.84 65.14,151.71 65.14,150.97 65.04,150.87 64.9,150.87 64.8,150.97 64.8,151.8 64.72,151.88 64.55,151.88 64.47,151.8 64.47,150.75 64.19,150.47 63.82,150.47 63.74,150.56 63.74,150.73 64.13,151.12 64.13,151.79 64.03,151.88 63.68,151.88 63.6,151.8 63.6,151.69 63.51,151.61 63.34,151.61 63.26,151.69 63.26,151.8 63.18,151.88 62.5,151.88 62.43,151.81 62.43,151.6 62.48,151.54 62.7,151.54 62.85,151.39 v1(62.85,151.19)
  BOTTOM w0.102: U1.N31 103.88,158.96 v2(103.52,159.32)
  BOTTOM w0.114: JDIM02.83 64,151.07 63.57,150.64 63.19,150.64 62.85,150.98 v1(62.85,151.19)
M_B_DQ31: length 56.9
  IN3 w0.084: v1(59.97,151.01) 59.97,150.72 59.86,150.61 59.28,150.61 59.21,150.53 59.21,150.38 59.45,150.14 60.85,150.14 61.03,150.32 61.03,151.33 61.93,152.22 65.31,152.22 65.52,152.43 66.91,152.43 66.99,152.51 66.99,153.04 67.08,153.12 67.25,153.12 67.33,153.04 67.33,152.51 67.41,152.43 67.58,152.43 67.67,152.51 67.67,153.04 67.75,153.12 67.92,153.12 68.01,153.04 68.01,152.51 68.09,152.43 68.43,152.43 68.53,152.53 68.53,153 68.61,153.08 69.09,153.08 75.62,159.62 95.33,159.62 95.42,159.71 97.74,159.71 98.38,159.07 102.11,159.07 102.35,159.31 v2(102.67,159.31)
  BOTTOM w0.102: v2(102.67,159.31) 103.06,158.91 U1.N32
  BOTTOM w0.114: v1(59.97,151.01) 59.97,151.2 59.35,151.82 JDIM02.80
M_B_DQ32: length 61.7
  IN3 w0.084: v1(62.86,126.89) 63.28,127.32 63.85,127.32 63.96,127.2 63.96,126.92 64.05,126.84 64.27,126.84 64.35,126.92 64.35,127.37 64.56,127.58 67.64,127.58 67.85,127.37 68.11,127.37 68.17,127.43 68.17,127.97 68.28,128.08 68.46,128.08 68.55,127.98 68.55,127.42 68.64,127.34 68.86,127.34 68.94,127.42 68.94,128.16 69.01,128.23 69.22,128.23 69.3,128.14 69.3,127.4 69.38,127.32 69.55,127.32 69.64,127.4 69.64,128.14 69.72,128.23 69.89,128.23 69.98,128.14 69.98,127.4 70.06,127.32 70.23,127.32 70.31,127.4 70.31,128.14 70.4,128.23 71.41,128.23 85.06,141.88 90.38,141.88 92.14,143.64 94.75,143.64 95.01,143.9 95.01,144.06 95.14,144.19 99.02,144.19 99.86,145.03 99.86,146.23 102.39,148.76 103.31,148.76 103.36,148.81 104.97,148.81 v2(105.51,149.34)
  BOTTOM w0.102: U1.AJ29 105.18,149.02 v2(105.51,149.34)
  BOTTOM w0.114: JDIM02.173 63.91,126.57 63.71,126.38 63.1,126.38 62.86,126.62 v1(62.86,126.89)
