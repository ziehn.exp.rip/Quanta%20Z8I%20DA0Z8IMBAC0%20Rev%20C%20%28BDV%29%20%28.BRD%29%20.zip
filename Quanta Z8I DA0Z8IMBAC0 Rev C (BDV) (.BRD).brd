# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N24679794: length 5.3
  TOP w0.508: R213.1 112.32,116.07 L3.1 112.69,115.1 C243.2 112.7,114.94 113.18,114.46 113.32,114.46 v1(113.57,114.2) 113.75,114.03 113.75,113.21 113.47,112.93 R212.1
N24742096: length 3.1
  BOTTOM w0.508: PR9075.2 103.29,187.87 103.25,187.91 PD9001.2 101.42,189.22 PQ9011.3
N24742104: length 11.4
  BOTTOM w0.508: PQ9009.2 97.97,188.57 97.97,189.96 98.99,190.98 v1(98.99,191.13) 99.07,191.22 PQ9011.2 100.15,190.7 100.4,190.44 101.91,190.44 102.82,189.53 PQ9010.3 103.45,190.5 103.46,190.5 PR9077.1 PR9074.2
N24742107:
  vias: v1(95.69,186.04) v1(95.94,185.42) v1(96.47,185.87)
N24742118: length 2.2
  BOTTOM w0.114: PR9078.2 104.48,183.08 v1(104.35,182.95) 103.68,183.62 PU9003.3
N24742123: length 2.8
  BOTTOM w0.508: PQ9009.3 96.9,190.67 96.9,191.77 v1(96.98,191.84) 96.83,192 PR9073.2
N24742126: length 21.4
  BOTTOM w0.114: PU9003.4 101.04,183.62 101.2,183.46 101.2,183.21 101.1,183.11 99.85,183.11 99.73,182.98 99.73,182.59 PC9073.1 99.08,181.16 PR9079.2 98.91,181.28 98.61,181.58 98.61,182.65 98.2,183.05 v1(98.2,183.38) 98.2,185.28 98.68,185.76 98.68,189.71 99.04,190.07 99.55,190.07 99.64,189.98 101.72,189.98 102.69,189.01 103.81,189.01 PQ9010.2
N24742146: length 1
  BOTTOM w0.508: PR9080.2 PC9071.1
N24742173: length 4
  TOP w0.114: PR9069.2 89.83,184.65 91.11,184.65 91.5,184.26 PC9059.1 PU9002.4
N24742207: length 1.4
  TOP w0.114: PC9063.1 96.2,183.77 PU9002.10
N24742208: length 3.9
  TOP w0.114: PC9062.1 97.81,184.09 97.74,184.16 97.02,184.16 v1(96.7,184.48) 96.45,184.48 96.13,184.16 95.84,184.16 95.43,184.57 PU9002.12
N24742222: length 4.6
  TOP w0.114: PU9002.5 92.01,183.77 91.5,183.27 PC9060.1 91.49,183.16 91,182.66 90.03,182.66 v1(89.92,182.55) 89.79,182.55 PR9070.1
N24742230: length 4.6
  TOP w0.114: PR9072.2 89.36,185.19 89.82,185.65 91.36,185.65 91.5,185.51 PC9064.1 92.12,184.57 PU9002.3
N24995566: length 7.1
  BOTTOM w0.114: PR3020.2 128.67,113.81 129.13,113.81 129.2,113.88 PC6228.1 129.67,114.21 129.55,114.32 129.55,114.78 129.91,115.13 130.72,115.13 PU3002.5 132.21,114.93 132.74,115.47 132.74,116.76 v1(132.9,116.91)
N24995570: length 2.4
  BOTTOM w0.114: v1(133.71,115.9) 133.63,115.82 PU3002.1 134.31,114.93 134.43,115.05 PR3021.1
N24995581: length 1.8
  BOTTOM w0.114: PU3002.3 134.32,113.03 134.54,112.81 134.54,112.63 134.29,112.38 PR3022.1
N25235355: length 3.1
  TOP w0.114: PQ8005.2 37.55,99.47 37.93,99.85 37.93,100.5 38.15,100.72 PR8017.2 39.46,100.72 PR8015.1
N25257440: length 6.8
  TOP w0.114: PQ8005.3 37.65,100.5 37.65,100.87 PR9277.1 v1(37.82,101.7) ; PR8007.2 34.42,101.62 34.68,101.36 v1(34.87,101.36)
  IN2 w0.102: v1(37.82,101.7) 35.21,101.7 v1(34.87,101.36)
N25257697: length 5.6
  TOP w0.114: PQ8005.5 35.29,99.47 34.92,99.1 34.92,98.14 35.17,97.89 PR8016.1 35.01,97.72 34.19,96.9 PR8006.2 34.01,96.8 v1(33.23,96.8) 33.12,96.91 PR8014.2
N25318825: length 1.5
  TOP w0.254: PR8005.1 52.3,199.03 52.23,198.95 PQ8000.3
N25318883: length 7.4
  TOP w0.254: PR8011.2 52.13,197.35 PR8010.2 51.45,197.96 PQ8000.2 48.96,199.9 v1(48.57,200.3) 48.31,200.05 PR8012.1
N25318964: length 3.4
  TOP w0.254: v1(47.48,198.68) 47.51,198.64 ; 47.51,198.64 47.51,198.5 PR8013.2 49.21,197.72 PQ8000.1 ; 47.51,198.64 48.29,198.64 PR8012.2
N25319146: length 6.9
  TOP w0.114: v4(53.85,200.81) 53.72,200.68 52.61,200.68 52.38,200.46 PR8001.2
  TOP w0.254: PR8001.2 52.38,200.12 52.39,200.11 52.39,199.88 52.56,199.71 53.55,199.71 54.3,198.97 PQ8003.2 53.48,198.06 PR8005.2
N25365001: length 51.6
  TOP w0.254: v1(161.79,169.34) 161.79,169.42 161.14,170.08 159.64,170.08 v1(159.49,169.92) 159.4,169.83 PQ9084.3 ; PR9103.2 165.33,209.28 v1(165.33,208.43)
  IN1 w0.254: v1(165.33,208.43) 165.45,208.43 166.53,207.35 166.53,191.01 167.85,189.69 167.85,169.56 167.36,169.07 166.21,169.07 165.91,168.77 162.36,168.77 v1(161.79,169.34)
N25369936: length 2.7
  TOP w0.114: v1(125.76,100.05) 125.99,100.05 126.66,100.72 R560.1 127.04,100.88 127.28,101.13 Q27.1
N25369945: length 2.8
  TOP w0.114: v1(132.16,100.32) R558.1 130.74,100.32 130.25,99.83 Q27.4
N25430953: length 11.1
  TOP w0.508: PQ14.3 132.52,113.7 132.52,114.66 132.13,115.05 v1(132.13,116.49) 130.93,117.7 130.93,118.5 131.51,119.08 131.58,119.08 v1(133.54,121.05)
  BOTTOM w0.508: v1(133.54,121.05) 132.77,121.82 PR111.2
N25430988: length 7.2
  TOP w0.508: PQ12.3 101.27,104.94 v1(101.27,104.85) 99.44,103.02 PR106.2
N25430994:
  vias: v1(14,146.22)
N25431520: length 3.3
  TOP w0.114: v1(35.64,123.82) 35.64,123.47 35.78,123.32 PQ9050.3
  TOP w0.508: PQ9050.3 36.5,124.15 36,124.65 PR9227.2
N25804343: length 1
  TOP w0.254: PR9027.2 PR9030.2
N25817818: length 3.5
  TOP w0.508: PQ9085.3 164.28,167.51 164.51,167.28 PR9099.2 165.86,167.28 166.58,167.99 v1(166.7,167.99)
N25817820: length 8
  TOP w0.508: v1(162.41,165.22) 162.46,165.27 162.46,168.07 162.07,168.46 PQ9085.2 160.9,168.46 160.8,168.55 PR9100.2 160.49,168.06 160.48,168.05 PR9101.1 159.86,167.49 159.53,167.82 PQ9086.3
N25821251: length 3.3
  TOP w0.114: PR9092.2 163.3,158.29 v1(163.45,158.14)
  TOP w0.203: PR9092.2 162.44,158.34 162.45,158.34
  TOP w0.508: PC9088.1 162.65,157 162.65,158.14 162.45,158.34
N27752748: length 10.9
  TOP w0.254: R736.2 22.96,26.5 22.54,26.93 22.54,27.37 v1(22.28,27.63) 21.57,27.63 20.81,28.39 18.67,28.39 17.63,27.35 17.63,24.91 v1(17.45,24.73)
  BOTTOM w0.254: v1(17.45,24.73) 17.66,24.94 R450.2
N28053888: length 49.5
  IN1 w0.203: v1(168.71,134.7) 168.22,135.18 167.22,135.18 166.14,136.27 160.44,136.27 158.48,138.23 158.48,142.68 157.71,143.46 157.71,145.03 153.63,149.11 141.57,149.11 139.55,151.13 139.55,156.94 139.27,157.22 139.27,157.43 v1(139.08,157.62)
  BOTTOM w0.203: PR7006.1 169.35,135.74 v1(169.35,134.9) 169.15,134.7 v1(168.71,134.7) ; PR7007.1 140.44,158.19 139.64,158.19 v1(139.08,157.62)
N28054550: length 10.9
  TOP w0.114: v1(152.58,143.26) 152.58,143.25 v1(153.27,143.25)
  IN1 w0.203: v1(152.58,143.26) 154.5,143.26 154.96,143.71 156.79,143.71 157.72,142.77 v1(157.72,141)
  BOTTOM w0.203: PU7001.5 v1(152.58,143.26) ; v1(157.72,141) 158.08,141 158.57,141.5 PR7077.2
N28088374: length 1
  TOP w0.203: PC7004.1 167.33,143.43 PR7008.2
N28089786: length 2.2
  TOP w0.203: PR7035.1 168.29,138.03 v1(168.94,138.68) 169.04,138.58 PR7040.1
N28089833: length 1
  TOP w0.203: PR7036.2 166.07,136.11 PR7041.2
N28092561: length 14
  BOTTOM w0.079: U1.W4 121.1,154.97 121.41,154.66 121.75,154.66 121.77,154.68 122.01,154.68 122.03,154.66 122.22,154.66 122.43,154.45 124.85,154.45 125.9,155.51 125.9,156.61 126.59,157.3 126.87,157.3 127.1,157.53 127.1,157.83 127.53,158.26
  BOTTOM w0.102: 127.53,158.26 127.72,158.45
  BOTTOM w0.114: v1(131.06,158.95) 130.52,159.49 R83.2 130.02,159.49 129.79,159.71 128.9,159.71 128.84,159.65 128.4,159.65 127.91,159.17 127.91,158.64 127.72,158.45
N28107941: length 1.3
  BOTTOM w0.508: PR7095.1 140.46,159.95 PC7096.2
N28108994: length 50.6
  TOP w0.114: v1(137.71,165.38) 137.74,165.4 v1(138.41,165.4)
  TOP w0.203: PR7098.1 v1(163.87,149.53)
  IN3 w0.203: v1(137.71,165.38) 137.34,165.75 137.34,167.85 138.14,168.66 139.06,168.66 139.32,168.4 153.3,168.4 155.1,166.61 155.1,165.23 156.55,163.77 156.55,162.3 156.75,162.1 156.75,158.17 157.41,157.51 159.43,157.51 159.89,157.05 159.89,152.32 158.68,151.11 158.68,150.1 159.88,148.91 161.01,148.91 162.11,150.01 163.4,150.01 v1(163.87,149.53)
  BOTTOM w0.203: PR7096.2 v1(137.71,165.38)
N28123718: length 1
  BOTTOM w0.203: PR7033.1 160.97,135.57 160.77,135.77 PR7030.2
N28123995: length 2.2
  TOP w0.114: v1(156.21,146.66) 156.49,146.38 PR7034.1
  TOP w0.203: PR7031.2 157.58,145.87 PR7034.1
N28124269: length 1
  TOP w0.203: PR7010.2 159.02,146.65 PR7017.1
N28124298: length 1.2
  BOTTOM w0.203: PR7016.1 159.81,135.7 160,135.51 PR7009.2
N28129355: length 1.4
  TOP w0.203: PR7022.1 167.09,136.7 PR7027.1
N28129385: length 1
  TOP w0.203: PR7028.1 165.07,136.11 PR7023.1
N28129414: length 1
  TOP w0.203: PR7024.1 164.1,136.43 163.9,136.63 PR7029.1
N28159674: length 27.5
  TOP w0.114: v1(159.9,132.38) 159.9,132.58 v1(160.26,132.94)
  TOP w0.203: v1(170.97,147.55) 170.72,147.3 170.62,147.3 PR7092.1 170.41,147.09 PR7091.1
  IN3 w0.203: v1(170.97,147.55) 169.16,147.55 168.87,147.84 167.45,147.84 166.26,146.65 166.26,145.06 166.64,144.68 166.64,138.67 165.63,137.66 165.63,136.57 164.03,134.96 164.03,134.54 163.1,133.61 163.1,133.27 161.91,132.09 160.78,132.09 160.26,132.61 v1(160.26,132.94)
  BOTTOM w0.203: v1(160.26,132.94) 159.48,132.94 PR7093.1
N28160119: length 2.3
  TOP w0.508: v1(158.83,130.81) 159.06,130.57 PC7078.2 158.19,129.94 PR7087.1
N28160139: length 28.1
  TOP w0.114: v2(167.1,145.5) 167.01,145.59 v1(167.01,146.15)
  TOP w0.203: v2(167.1,145.5) 167.17,145.43 PR7090.2
  IN3 w0.203: v1(155.23,129.38) 155.44,129.17 157.32,129.17 158.9,130.75 158.9,131.43 159.26,131.78 160.08,131.78 160.49,131.37 162.2,131.37 163.81,132.98 163.81,133.31 164.74,134.24 164.74,134.67 166.4,136.33 166.4,137.42 167.35,138.37 167.35,145.25 v2(167.1,145.5)
  BOTTOM w0.203: PR7088.2 155.87,128.84 155.32,129.38 v1(155.23,129.38)
N28379472: length 5.7
  TOP w0.254: v2(98.28,195.96) 97.48,195.96 96.97,196.46 PR9023.1 96.95,196.57 PR9024.1 96.02,196.83 95.32,197.53 PC9025.1
  BOTTOM w0.254: PR9021.2 97.78,196.57 v1(98.45,196.57) 98.45,196.34 98.28,196.16 v2(98.28,195.96)
N28379477: length 1.4
  BOTTOM w0.61: PR9019.1 105.9,196.12 PC9024.1
N28380796: length 1.5
  TOP w0.203: TP9000.1 96.84,197.98 97.76,197.98 97.87,197.84 PR9017.1
N28380828: length 4
  TOP w0.254: PR9002.2 97.17,193.38 96.66,193.38 96.02,192.75 PR9000.2 95.59,193.05 PC9004.1
N28414264: length 17.1
  TOP w0.254: PU9000.13 102,193.7 102.77,192.94 PR9033.1 102.63,192.78 v1(101.86,192.78)
  IN1 w0.254: v1(101.86,192.78) 101.86,193.46 103.97,195.57 103.97,196.01 103.34,196.65 103.34,197.2 105.16,199.03 v1(106.36,199.03)
  BOTTOM w0.254: PR9274.1 106.84,202.82 105.05,201.03 105.05,200.33 105.26,200.12 105.89,200.12 v1(105.92,200.1) 106.36,199.66 v1(106.36,199.03)
N28607521: length 2.7
  TOP w0.254: v2(103.38,198.35) 103.2,198.17 103.2,198.06 PU9000.22
  BOTTOM w0.203: PR9034.1 103.59,197.67 v1(103.74,197.81) 103.74,197.99 v2(103.38,198.35)
N29093947: length 5.6
  TOP w0.114: Q16.3 113.04,188.47 111.92,187.35 v1(111.84,187.35) 111.52,187.67 111.06,187.67 110.87,187.47 Q14.2 110.87,186.35 111.39,185.83 R386.1
N30319351: length 2
  BOTTOM w0.508: PC9079.2 164.3,158.33 165.38,159.41 PR9089.1
N30442035:
  vias: v1(36.73,161.01)
N30442060: length 4.3
  TOP w0.114: PR6023.2 35.62,167.65 35.62,166.39 PC6051.1 34.98,165.75 PU6002.4
N30442062: length 1.6
  TOP w0.114: PU6002.12 35.38,161.78 35.54,161.61 PC6056.1
N30442063: length 1.6
  TOP w0.114: PC6057.1 34.47,161.67 34.58,161.77 PU6002.10
N30442080: length 4.2
  TOP w0.114: PR6028.1 34.6,167.44 34.6,166.38 PC6053.1 34.58,165.39 PU6002.5
N30442084: length 4.7
  TOP w0.114: PR6027.2 v4(36.78,167.54) 36.75,167.54 36.62,167.41 36.62,166.37 PC6052.1 35.38,165.13 PU6002.3
N30568314: length 4.8
  BOTTOM w0.203: PC6024.2 173.18,135.46 PR6010.1 174.36,134.45 175.12,133.69 PR6014.2 175.19,132.84 v1(175.21,132.81) 175.21,132.81 PU6000.12
N30568326: length 2.4
  BOTTOM w0.114: PR6011.1 172.14,133.86 v1(172.14,133.3)
  BOTTOM w0.203: PR6011.1 172.45,134.46 172.29,134.61 PC6024.1
N30568424: length 4.7
  BOTTOM w0.203: PU6003.9 57.15,183.3 57.25,183.21 57.48,183.21 57.89,182.8 PR6031.2 58.69,182.62 59.14,182.17 59.14,182.16 59.56,181.74 PR6030.1 60.48,181.74 PC6059.2
N30568429: length 1.9
  BOTTOM w0.114: PR6029.1 v1(61.33,179.96)
  BOTTOM w0.203: PC6059.1 PR6029.1
N30568472:
  vias: v1(56.59,180.97)
N30568498: length 1.9
  BOTTOM w0.114: v1(57.41,184.98) PR6021.1
  BOTTOM w0.203: PQ6001.3 57.99,185.65 PR6021.1
N30568535: length 4.4
  TOP w0.203: PR6003.2 173.48,129.85 v1(173.56,129.77) 174.13,129.77 v1(174.38,130.02) 175,130.02 PR6007.1
  BOTTOM w0.203: v1(174.38,130.02) 173.57,130.02 173.44,129.89 PR6005.1 PR6004.2
N31069510:
  vias: v1(202.7,127.63)
N31161958: length 6
  TOP w0.114: PR6013.2 201.4,129.54 v1(201.4,128.67) 201.12,128.67 200.63,129.17 200.09,129.17 PC6025.1 199.35,129.35 198.92,128.93 v1(198.2,128.93)
  BOTTOM w0.114: PU6001.4 v1(198.2,128.93)
N31161974: length 6.6
  BOTTOM w0.114: PC6028.1 207.38,127.45 207.17,127.25 205.7,127.25 v1(205.44,127.5) 205.04,127.9 203.36,127.9 202.74,128.53 PU6001.12
N31161976: length 3.2
  BOTTOM w0.114: PC6029.1 203.76,128.37 v1(203.64,128.49) 203.15,128.49 202.32,129.33 PU6001.10
N31162017: length 3.9
  TOP w0.114: v1(198.7,129.39) 198.35,129.39 v1(198.07,129.66) 198.33,129.92 198.73,129.92 PC6027.1 198.93,130.12 PR6016.1
  BOTTOM w0.114: v1(198.7,129.39) 198.76,129.33 PU6001.5
N31162025: length 4.4
  TOP w0.114: PR6015.2 199.5,127.53 199.25,127.78 PC6026.1 198.92,128.02 198.63,127.73 v1(198.05,127.73) 198.05,128.14 198.37,128.46 v1(198.67,128.46)
  BOTTOM w0.114: PU6001.3 198.74,128.53 v1(198.67,128.46)
N32484985: length 2.7
  TOP w0.254: PR8018.2 56.1,195.7 PR8021.1 56.6,194.7 PQ8008.2
N32484987: length 3.7
  TOP w0.114: PR8021.2 57.4,194.17 57.45,194.22 PR8027.1 58.21,193.88 58.21,193.87 PR8025.2 58.83,193.82 59.13,194.13 v4(59.13,194.43)
N32485009: length 5.6
  TOP w0.381: PQ8008.3 53.59,192.7 v1(52.91,192.02) 52.84,192.1 51.95,192.1 51.44,191.59 PR8028.1 51.09,192.14 PQ8011.2
N32485013: length 5.3
  TOP w0.254: PQ8011.1 52.01,194.7 PQ8008.1 53.59,194.98 53.4,195.16 PR8020.1 53.94,195.37 54.79,195.37 55.13,195.71 PR8019.2
N32485017: length 8.4
  TOP w0.254: PR8026.1 57.81,193.22 PR8029.1 56.02,194.03 53.93,194.03 53.8,193.9 v1(52.4,193.9) 52.38,193.87 PQ8011.3
N32485347: length 2.5
  TOP w0.254: PQ8004.2 34.18,101.38 33.97,101.59 PR8007.1 PR8003.1
N33618596: length 1.9
  BOTTOM w0.114: R653.2 22.04,90.08 v1(22.33,89.79) 22.82,89.3 Q34.3
N33652665: length 2
  BOTTOM w0.114: v1(197.36,105.41) 197.26,105.51 EC12.1 197.28,106.35 R655.2
N33712295: length 3.3
  BOTTOM w0.079: 125.88,163.62 123.95,163.62
  BOTTOM w0.089: U1.E1 122.87,163.51 123.84,163.51 123.95,163.62
  BOTTOM w0.102: R85.2 125.88,163.62
N33761123: length 4.7
  TOP w0.114: R645.1 22.84,73.3 22.97,73.17 23.17,73.17 23.41,73.41 R2660.1 23.8,73.34 v1(23.8,72.39) 23.8,72.26 24.09,71.97 v1(24.09,71.64)
  BOTTOM w0.114: v1(24.09,71.64) 24.23,71.64 24.6,72.01 CN16.38
N33761125: length 6.7
  TOP w0.114: R648.1 24.56,73.52 v1(25.19,74.15) 25.23,74.19 v1(25.91,74.19)
  BOTTOM w0.114: v1(25.19,74.15) 25.19,74.06 24.99,73.86 21.77,73.86 21.6,73.69 CN16.50
N33761127: length 5
  BOTTOM w0.114: CN16.68 17.1,70.73 17.18,70.65 17.18,69.87 16.82,69.52 16.31,69.52 15.83,70 TP81.1
N33764822: length 1.9
  TOP w0.102: R216.2 128.61,157.13 129.26,157.78 TP26.1
N33764826: length 1.4
  TOP w0.102: TP32.1 128.3,161.74 127.6,162.43 R217.2
N34044006: length 2
  BOTTOM w0.114: v1(157.03,167.56) 156.21,167.56 PR7109.2
  BOTTOM w0.254: PU7003.5 155.91,166.78 156.17,167.04 PR7109.2
N34044116: length 2.2
  TOP w0.114: v1(154.82,166.11) 153.75,166.11 PC7101.2
  TOP w0.508: v1(153.62,167.15) 153.73,167.05 PC7101.2
N34044137:
  vias: v1(152.45,166.44)
N34045443: length 2.4
  TOP w0.254: v1(162.41,132.51) 162.57,132.67 PR7113.2 163.6,132.36 PU7004.5
N34045547:
  vias: v1(167.95,132.56)
N34045574: length 4
  BOTTOM w0.508: PR7114.1 165.52,129.99 165.52,131.14 v1(166.12,131.75) v3(167.97,131.75)
N34047546: length 3.3
  BOTTOM w0.114: PR7105.2 151.29,159.78 150.75,160.32 v1(150.35,160.32)
  BOTTOM w0.305: PU7002.5 151.74,159.04 PR7105.2
N34047656: length 1.6
  TOP w0.114: v1(155.17,157.71) v1(155.17,158.44)
  TOP w0.508: v1(155.17,158.44) 155.25,158.52 PC7105.2
N35244209: length 5.1
  TOP w0.114: R25623.1 141.17,210.07 141.17,210.85 R25624.2
  TOP w0.254: R25624.2 140.71,212.2 141.8,213.29 U6515.1
N35444059: length 3.9
  TOP w0.079: U6516.B3 154.36,213.89 154.36,213 154.04,212.68 154.04,212.62
  TOP w0.114: 154.04,212.62 154.04,211.51 v1(154.08,211.48) 154.08,211.02 153.95,210.89 C20140.2
N35539245: length 2.4
  TOP w0.079: U6516.D5 155.61,215.64
  TOP w0.114: TP9073.1 155.61,217.01 155.61,215.64
N35539258: length 3.9
  TOP w0.079: U6516.D3 155.36,213.89 155.74,213.89 156.24,213.39
  TOP w0.114: TP9074.1 157.29,211.74 157.29,212.34 156.24,213.39
N35539657: length 3
  TOP w0.079: 153.5,212.62 153.5,213.03 U6516.A1
  TOP w0.114: 153.5,212.62 153.5,211.96 152.81,211.28 TP9067.1
N35539676: length 6.1
  TOP w0.114: TP9068.1 156.26,208.64 156.26,209.99 156.34,210.07 156.34,211.82 156,212.15 155.48,212.15 155.13,212.5 155.13,213.12 U6516.D1
N35539679: length 5
  TOP w0.079: U6516.B1 153.78,212.81 153.78,212.62
  TOP w0.114: 153.78,212.62 153.78,211.86 153.28,211.37 153.28,208.54 TP9071.1
N35539682: length 6.7
  TOP w0.079: U6516.E1 155.74,213.14 156.24,212.64
  TOP w0.114: 156.24,212.64 156.76,212.12 156.76,210.11 156.53,209.88 156.53,209.08 157.69,207.92 TP9072.1
N36446693: length 4.2
  TOP w0.114: R512.2 C639.2 29.78,170.59 29.78,169.94 29.99,169.73 30.44,169.73 30.75,170.04 Y4.3
N36977514: length 4.1
  BOTTOM w0.114: v1(215.29,120.16) 215.29,121.1 Q30.2 214.45,121.37 214.13,121.69 R579.2 213.68,121.09 213.67,121.08 Q31.3
N37162665: length 1.6
  BOTTOM w0.508: L28.1 12.5,37.04 R449.1
N37162929: length 1.2
  BOTTOM w0.114: R454.1 23.68,38.38 TP9023.1
N37164070: length 5.5
  BOTTOM w0.114: R25371.1 25.83,28.06 26.12,28.35 R734.2 26.19,28.57 v1(26.77,28.57) 26.77,28.96 C844.2 25.35,29.38 C846.2
N37164724: length 1.9
  BOTTOM w0.114: R735.2 26.03,24.54 25.83,24.74 R25371.2 26.69,25.05 v1(26.7,25.04)
N37349239: length 1.8
  TOP w0.508: PR7072.1 150.21,154.35 150.35,154.48 PC7046.2
N37349425: length 2.7
  TOP w0.114: PR7081.1 148.81,137.68 v1(148.77,137.72)
  TOP w0.508: PR7081.1 150.58,137.68 PC7064.2
N37352433: length 2.1
  BOTTOM w0.61: 105.53,202.49 104.9,201.91 v1(104.7,201.71) 104.7,201.51 104.47,201.27 104.47,200.89 PC9012.1
N37598035: length 1.9
  TOP w0.114: U23.4 23.42,145.63 R507.1
N38674948: length 22.8
  TOP w0.114: v1(146.99,137.06) v1(146.99,137.88)
  IN3 w0.203: v1(161.58,134.08) 161.28,134.08 159.87,135.49 158.29,135.49 155.93,133.13 149.34,133.13 148.5,133.97 147.68,133.97 146.87,134.78 146.87,137.75 v1(146.99,137.88)
  BOTTOM w0.203: v1(161.58,134.08) 161.94,134.45 PR7084.1 ; PR7082.2 v1(146.99,137.88)
N38680880: length 6.3
  BOTTOM w0.114: v1(163.43,121.31) 164.04,121.31 164.42,121.69 164.42,122.15 163.92,122.64 ; 163.92,122.64 Q6523.2 ; 163.92,122.64 164.9,122.64 165.33,123.07 165.33,124.07 165.46,124.2 166.23,124.2 R576.1
N38756671: length 4
  TOP w0.114: U37.66 167.78,97.54 167.98,97.34 167.98,96.79 168.13,96.63 C6568.2 168.18,96.14 R25318.1 167.36,95.4 v1(167.31,95.35)
N38756738: length 2.8
  TOP w0.114: U37.82 168.78,103.94 C1208.2 168.88,104.42 168.79,104.51 R960.1
N38756787: length 5.4
  TOP w0.114: R895.1 168.89,113.38 v1(168.23,113.38) 167.58,112.74 C6580.2 167.26,112.54 167.03,112.32 165.36,112.32 164.96,111.92 U37.98
N38756834: length 7.4
  BOTTOM w0.114: SW2.3 SW2.4 10.81,154.1 R25321.2 v1(11.72,156.46) 12.11,156.46 Q81.3
N38757336: length 4.2
  TOP w0.114: R25308.1 150.57,111.5 C6563.1 150.79,111.01 151.35,110.45 152.72,110.45 152.96,110.69 U37.128
N38757406: length 84.9
  IN4 w0.089: v1(42.62,158.92) 41.98,159.57 41.98,171.08 45.16,174.26 55.82,174.26 59.28,177.72 59.28,177.97 60.1,178.79 60.35,178.79 63.73,182.18 63.73,184.72 63.76,184.75 63.77,184.75 v1(64.61,185.59)
  BOTTOM w0.114: Q81.2 14.77,158.35 15.29,158.87 v1(15.68,158.87) 16.18,158.37 C1044.1 19.65,157.85 21.87,155.63 27.64,155.63 27.94,155.33 33.97,155.33 36.27,157.63 41.33,157.63 v1(42.62,158.92) ; R25310.2 67.31,179.74 SW4.4 SW4.3 65.38,186.1 64.87,185.59 v1(64.61,185.59)
N38758998: length 1.3
  TOP w0.114: R402.1 147.01,104.77 C6562.2
N38759178: length 1.8
  TOP w0.114: C1190.1 150.24,105.18 150.28,105.14 U37.12
N39017089: length 1.5
  BOTTOM w0.114: TP13173.1 56.35,189.79 56.35,189.97 R67415.1
N39017091: length 1.4
  BOTTOM w0.114: TP13172.1 56.61,189.84 56.61,190.05 R67414.1
N39782161: length 9
  BOTTOM w0.079: 95.01,127.68 95.53,127.16 97.65,127.16 100.32,129.83 100.82,129.83 U1.BW35
  BOTTOM w0.114: TP9044.1 94.39,128.29 95,127.68 95.01,127.68
N39782179: length 9.8
  BOTTOM w0.079: U1.BW34 102.21,130.16 102.21,129.57 101.88,129.23 99.96,129.23 97.72,126.99 96.36,126.99 96.24,126.87 95.26,126.87 95.01,127.12
  BOTTOM w0.114: TP9042.1 95.01,127.12
N39782191: length 6
  BOTTOM w0.079: TP9043.1 96,126.39 96.43,126.82 97.79,126.82 99.93,128.97 U1.CA37
N40437801: length 10
  BOTTOM w0.114: U8.V7 124.24,196.04 123.7,196.04 123.47,195.81 123.47,194.56 123.27,194.36 119.27,194.36 118.49,193.58 TP9033.1
N40437812: length 9.3
  BOTTOM w0.114: U8.W7 124.22,196.83 123.58,196.83 123.39,196.64 123.39,196.28 123.13,196.02 119.91,196.02 118.79,194.91 TP9032.1
N40437815: length 7.7
  BOTTOM w0.114: TP9031.1 117.14,196.75 119.47,196.75 119.6,196.88 123.23,196.88 123.61,197.27 U8.W6
N40437818: length 9.2
  BOTTOM w0.114: TP9030.1 117.85,197.04 119.07,197.04 119.74,197.71 123.46,197.71 U8.Y6
N40911013: length 4.9
  BOTTOM w0.127: VRAM1.J13 158.9,182.62 158.52,183 158.52,183.47 157.77,184.21 v1(157.77,185.82) 157.77,186.18 R405.2
N40911015: length 4.5
  BOTTOM w0.102: VRAM2.J13 158.5,195.62 158.5,194.18
  BOTTOM w0.114: 158.5,194.18 158.5,192.8 v1(158.28,192.58) R406.2
N43686188: length 2.4
  TOP w0.254: PQ17.3 161.76,120.69 162.08,120.37 v1(162.41,120.37) 162.44,120.37 162.79,120.72 PR9275.1
N43700942: length 10.7
  TOP w0.114: v1(68.21,194.05) 69.26,193 69.26,191.91 68.88,191.52 68.88,189.31 v1(68.45,188.88) 68.12,188.88 67.87,189.13 65.88,189.13 R25521.2
  BOTTOM w0.114: CN29.24 67.65,193.79 67.91,194.05 v1(68.21,194.05)
N44885066: length 4.4
  TOP w0.254: PD9002.3 154.5,121.91 v1(154.36,122.04) v1(154.36,122.71)
  BOTTOM w0.254: PR16.2 154.13,123.62 154.36,123.38 v1(154.36,122.71)
N44984144: length 5.4
  TOP w0.114: R779.2 17.63,121.01 18.51,121.88 19.26,121.88 20.42,123.04 20.42,123.44 20.78,123.81 U30.27
N44984193: length 2.7
  TOP w0.114: C808.2 29,130.1 v1(28.35,130.1) 28.14,130.1 27.92,130.31 27.69,130.31 27.42,130.04 U30.1
N44994019: length 2.4
  TOP w0.114: U67.9 31.68,155.36 31.81,155.49 31.99,155.49 32.08,155.39 v1(32.52,155.39) 32.54,155.42 R25526.1
N44994033: length 1.6
  TOP w0.114: U67.10 31.28,156.01 R25527.1
N44994150: length 4.7
  TOP w0.114: U67.11 30.88,157.52 30.54,157.85 30.54,158.64 TP2.1
N44994160: length 3.4
  TOP w0.114: U67.12 30.48,155.63 30.61,155.76 30.61,157.3 TP9046.1
N44994181: length 1.9
  TOP w0.114: U67.13 30.08,156.56 TP9064.1
N44999557: length 4.2
  TOP w0.114: C20064.1 22.48,65.47 v1(22.48,65.55) 22.48,65.58 22.28,65.78 22.28,66.11 22.08,66.32 22.08,66.98 22.28,67.18 22.28,67.46 22.15,67.58 U12.1
N44999826: length 1.8
  TOP w0.114: U12.29 16.52,66.61 16.2,66.29 R25571.2
N45003416: length 2.3
  BOTTOM w0.114: TP88.1 21.95,44.98 21.52,45.41 U6511.26
N45003467: length 2.7
  BOTTOM w0.114: U6511.33 16.85,48.05 C20083.1 16.78,47.98 v1(15.98,47.98)
N45003503: length 3.5
  BOTTOM w0.114: TP89.1 21.39,55.3 21.39,53.66 21.52,53.53 U6511.5
N45003505: length 1.7
  BOTTOM w0.114: TP90.1 22.02,53.9 U6511.6
N45003796: length 1.7
  BOTTOM w0.114: U6511.14 25.41,50.05 25.59,50.23 TP93.1
N45003808: length 2
  BOTTOM w0.114: TP92.1 23.22,45.23 23.68,45.23 24.02,45.58 U6511.21
N45004159: length 3.2
  BOTTOM w0.114: U6511.13 25.83,50.55 26.26,50.98 R205.1 C20085.2 R206.1
N45124268:
  vias: v1(27.94,177.03)
N45124292:
  vias: v1(27.03,174.47)
N45124296:
  vias: v1(34.19,175.69)
N45244883: length 7.5
  TOP w0.508: Q28.2 4.35,13.39 4.6,13.14 4.6,12.23 5.61,11.22 v1(5.97,11.22) 6.55,11.8 6.65,11.8 R67362.1 6.65,12.47 6.96,12.79 8.17,12.79 8.44,12.52 R67361.2
N45302727: length 7.2
  BOTTOM w0.114: Q21.3 33.98,32.03 v1(33.98,31.54) 33.98,27.68 33.45,27.15 D12.1
N45365737: length 3.5
  BOTTOM w0.305: U2.1 92.64,187.51 93.11,187.99 C96269.1 93.51,188.35 v1(93.2,188.67) 93.8,188.67 R67855.2
N45365860: length 3.3
  BOTTOM w0.114: v1(95.08,185.19) 94.47,185.79 R67418.2 93.19,185.79 92.96,185.56 U2.4
N45366087:
  vias: v1(201.93,124.99)
N45366166: length 1.7
  BOTTOM w0.114: C96272.1 200.54,124.96 200.31,125.19 U6517.2
N45366191: length 4.8
  BOTTOM w0.114: C96272.2 200.56,124.51 200.54,124.54 U6517.3 198.43,124.54 197.82,123.92 v1(197.82,122.68)
N45366210: length 2.3
  BOTTOM w0.114: U6517.4 200.42,123.89 200.59,123.72 R67422.2 200.82,122.93 v1(200.74,122.86)
N45500595: length 2.9
  TOP w0.114: PR8033.2 PC8005.1 22,116.37 PU8000.1
N45500603: length 8.9
  TOP w0.114: PU8000.3 22.61,118.65 PC8007.1 23.24,118.91 PR8040.2 PR8035.2 23.78,118.31 24.02,118.55 24.5,118.55 24.64,118.41 24.64,117.94 25.04,117.55 v1(26.11,117.55) 27.78,117.55 PQ8015.3
N45500619: length 8.3
  TOP w0.114: PD8003.1 PD8002.1 26.99,115.05 v1(27.64,115.69) 27.82,115.88 27.82,116.57 27.49,116.91 25.41,116.91 25.16,117.15 PR8033.1 24.23,117.28 PR8035.1
N45500625: length 3.4
  TOP w0.114: PR8045.1 25.25,112.54 PR8047.1 25.28,113.11 25.44,113.27 PR8042.1 25.44,113.93 25.33,114.05 24.74,114.05 24.58,113.89 PQ8016.6
N45500627: length 1.9
  TOP w0.114: v1(23.37,112.49) 23.42,112.54 PR8045.2 24.09,112.85 23.93,113 PQ8016.5
N45500633: length 2.2
  TOP w0.114: PR8048.1 PR8046.1 25.16,115.67 24.98,115.86 24.69,115.86 24.58,115.75 PQ8016.1
N45500637: length 5.3
  TOP w0.114: PR8047.2 26.02,112.57 26.47,113.02 26.47,113.83 25.99,114.31 24.13,114.31 23.93,114.51 PQ8016.2
N45500667: length 6.6
  TOP w0.114: PQ8014.3 20.17,114.09 19.59,114.66 18.46,114.66 18.07,114.27 PR8037.1 16.87,114.27 PR8034.1 16.34,114.29 v1(15.27,115.36)
N45500689: length 3.9
  TOP w0.114: PU8000.4 18.33,118.65 17.88,118.2 PR8039.1 16.95,118.2 PR8036.1 15.87,117.73 v1(15.6,118.01)
N45500733: length 8.6
  TOP w0.114: PR8041.2 30.63,115.55 30.86,115.78 30.86,116.55 31.09,116.78 PR8038.2 PR8043.1 30.58,117.35 30.24,117.01 PQ8015.2 30.18,116.14 29.67,116.65 29.67,116.81 28.2,118.28 v1(27.54,118.28)
N45509729: length 3.4
  TOP w0.114: PU8001.1 35.85,112.73 36.13,113 PC8008.2 PR8052.2 36.05,114.43 v1(36.05,115.21)
N45509733: length 9.4
  TOP w0.114: PD8007.1 31.74,112.88 31.76,112.91 PD8006.1 32.35,114.2 PR8054.1 33.15,116.41 33.54,116.8 v1(34.28,116.8) 35.35,115.73 PR8052.1
N45509737: length 4.1
  TOP w0.114: PU8001.4 33.95,109.11 32.94,108.1 PR8055.1 32.14,108.1 v1(31.8,108.43) 31.8,109.37 PR8053.2
N45509757: length 18.3
  TOP w0.114: PQ8019.3 v1(22.52,111.58) ; PU8001.3 33.95,112.91 PC8011.1 34.14,113.62 PR8057.1 PR8054.2 33.6,114.52 v1(34.04,114.96) 34.04,115.15 v1(33.67,115.52)
  BOTTOM w0.114: v1(33.67,115.52) 32.05,115.52 31.59,115.05 27.73,115.05 26.54,113.86 24.79,113.86 v1(22.52,111.58)
N45509773: length 5.3
  TOP w0.114: v1(22.23,113.31) 20.69,111.77 PQ8019.2 19.97,111.22 PR8064.1 PR8058.2 18.65,111.76 PR8060.2
N45509797: length 5.3
  TOP w0.114: v1(23.7,110.92) 23.86,110.76 PR8062.1 PR8056.1 24.82,111.33 24.96,111.19 25.31,111.19 25.44,111.31 PQ8018.6 25.44,111.85 25.72,112.13 26.06,112.13 26.27,112.33 27.14,112.33 27.28,112.2 PR8061.1
N45509799: length 2
  TOP w0.114: PR8061.2 27.33,111.75 27.01,112.07 26.38,112.07 26.09,111.78 PQ8018.5
N45509807: length 2.3
  TOP w0.114: PQ8018.2 26.09,110.32 25.91,110.5 24.98,110.5 24.79,110.31 PR8062.2
N45509836: length 3.5
  TOP w0.114: PQ8018.1 25.44,109.33 25.26,109.15 24.94,109.15 PR8063.1 24.56,109.29 24.31,109.04 23.8,109.04 23.3,109.55 v1(23.3,109.6)
N45509840: length 1.8
  TOP w0.508: PR8051.1 31.29,107.42 31.29,107.98 30.7,108.57 PQ8017.1
N45515909: length 2
  TOP w0.114: PR8049.2 29.1,106.04 PD8005.2 30.1,106.28 PR8050.1
N45782696: length 3.5
  BOTTOM w0.203: R450.1 18.44,26.27 18.44,27.99 19.01,28.56 U20.20
N45870434: length 4.4
  TOP w0.114: R821.2 110.03,111.36 109.43,111.36 R825.2 108.95,110.72 108.6,110.37 108.6,110.25 v1(108.28,109.93) 108.13,109.77 107.73,109.77 Q85.1
N45870491: length 1.3
  TOP w0.114: Q86.2 111.61,111.31 R821.1
N45873726: length 11.3
  BOTTOM w0.079: 93.98,168.05 95.27,166.76 95.27,165.59 95.56,165.3 97.25,165.3 98.2,166.25 100.64,166.25 101.01,165.87 101.01,165.41 101.2,165.23 101.2,164.77 U1.C35
  BOTTOM w0.114: TP1.1 93.98,168.05
N45952789: length 1.9
  BOTTOM w0.114: R160.1 19.94,58.57 20.35,58.98 v1(20.45,58.98) 20.54,58.88 U6510.3
N46166544: length 3.5
  TOP w0.114: v1(125.38,98.65) 125.38,98.27 v1(125.67,97.98) 125.67,97.1 R572.1
  BOTTOM w0.114: CN33.8 125.6,98.58 125.67,98.51 v1(125.67,97.98)
N46167434: length 4.1
  BOTTOM w0.114: R25471.1 132.79,106.19 133.24,106.64 R25473.2 133.85,106.17 Q29.3 134.43,106.96 134.37,107.01 R573.2
N46207407: length 3.9
  TOP w0.114: R25558.2 R25554.1 222.59,95.02 222.02,95.58 U6509.7
N46207590: length 3.7
  TOP w0.114: R25555.2 210.89,95.71 C20040.1 211.35,95.71 v1(211.76,95.3) 212.13,94.93 U6509.23
N46207592: length 4.8
  TOP w0.114: R25557.1 210.89,93.71 R25556.2 211.34,94.73 211.63,94.44 211.63,93.44 v1(211.71,93.36) 212.09,92.98 U6509.26
N46213996: length 1.5
  TOP w0.114: R593.2 83.98,99.72 84.38,99.32 U33.18
N46213998: length 5.4
  TOP w0.114: U33.29 87.94,94.82 87.59,94.47 84.52,94.47 v1(84.23,94.76) R592.2
N46214095: length 1.1
  TOP w0.114: R600.1 92.1,98.19 91.88,98.42 D22.2
N46222285: length 3.4
  BOTTOM w0.114: Q32.2 107.42,110.74 107.88,111.21 C750.2 108.26,110.36 R609.2 108.04,109.8 v1(107.75,109.8)
N47271970:
  vias: v1(120.52,177.54)
N48434117: length 6
  TOP w0.102: v1(129.46,186.66) C386.2
  TOP w0.381: C380.2 130.46,188.61 130.46,188.15 130.67,187.94 L4.2 130.2,187.73 130.11,187.63 C386.2 128.89,187.63 128.82,187.57 C375.2 128.27,187.09 v2(128.42,186.94)
  BOTTOM w0.381: U8.F11 128.42,186.87 v2(128.42,186.94)
N48587681: length 2.2
  TOP w0.102: v1(124.18,193.47) 124.18,192.61 R329.2
  TOP w0.254: v2(123.46,192.7) 123.56,192.6 R329.2
  BOTTOM w0.254: v2(123.46,192.7) 123.85,192.31 U8.N6
N48650493: length 6.2
  BOTTOM w0.114: Q15.2 105.19,180.64 105.67,180.16 106.35,180.16 v1(107.12,179.4) 107.62,179.4 R384.2 107.94,178.17 R382.1
N49263752: length 6.9
  BOTTOM w0.203: R339.2 R343.2 133.13,178.03 132.49,177.39 v1(132.16,177.39) 132.16,177.59 131.53,178.23 R341.2 131.35,177.9 131.15,177.7 129.29,177.7 128.79,178.19 R342.2
N156051040: length 4.6
  TOP w0.079: U6516.E2 156.24,213.01
  TOP w0.114: 156.24,213.01 157.03,212.23 157.03,209.66 TP9066.1
N156051160: length 3.2
  TOP w0.079: U6516.A4 153.44,214.82 153.14,214.82
  TOP w0.114: 153.14,214.82 153.07,214.82 152.64,215.25 152.64,216.58 TP9070.1
N156052720: length 4.4
  TOP w0.079: 156.24,213.83 156.16,213.91 156.02,213.91 155.79,214.14 U6516.E3
  TOP w0.114: 156.24,213.83 157.45,212.62 159.05,212.62 TP9069.1
N159797420: length 2.9
  TOP w0.114: v1(58.56,129.59) 58.56,129.1 T1.1
  BOTTOM w0.114: v1(58.56,129.59) 58.29,129.32 JDIM02.162
N159810220: length 5.6
  TOP w0.114: v1(60.55,129.62) 60.55,129.28 T2.1
  BOTTOM w0.114: v1(60.55,129.62) 61.59,128.57 JDIM02.165
N168487945: length 2.7
  BOTTOM w0.114: C96331.2 4.35,46.75 4.35,48.44 4.05,48.75 U6523.7

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 95.95,183.39 96.03,183.31 96.12,183.27 96.14,183.26 96.55,182.85 96.55,182.34 96.4,182.02 96.55,181.71 96.55,181.3 96.35,181.1 94.75,181.1 94.49,181.35 94.49,182.3 94.49,182.31 94.52,182.45 94.49,182.59 94.49,182.6 94.49,182.79 94.51,182.84 94.52,182.88 94.52,183.07 95.26,183.07 95.26,183.27 94.52,183.27 94.52,183.41 95.94,183.41
1V8_AON_S on BOTTOM (solid shape): 95.95,183.98 95.95,181.64 95.71,181.4 95.43,181.4 95.4,181.43 95,181.83 95,183 94.97,183.17 94.88,183.31 94.54,183.64 94.54,183.94 94.7,184.11 95.82,184.11
+1.2VSUS on TOP (solid shape): outline of 25414 points within 43.03,109.55 103.87,177.58
+1.2VSUS on BOTTOM (solid shape): 89.87,192.86 89.87,192.2 90.07,192 92.71,192 93.17,191.54 93.17,190.16 91.68,188.68 90.29,188.68 90.2,188.77 90.16,188.85 90.11,188.91 90.08,188.98 90.11,189.05 90.19,189.18 90.22,189.33 90.1,189.62 89.81,189.74 89.78,189.74 89.7,189.77 89.67,189.84 89.67,190.22 89.11,190.78 88.99,190.78 88.94,190.83 88.65,190.83 88.45,191.03 88.45,192.94 88.83,193.32 89.41,193.32
+1.2VSUS on BOTTOM (solid shape): outline of 126 points within 52.6,138.63 56.91,144.58
+1.2VSUS on BOTTOM (solid shape): outline of 162 points within 64.53,128.86 67.94,144.23
+1.2VSUS on BOTTOM (solid shape): outline of 346 points within 52.6,128.58 56.91,138.44
+1.2VSUS on IN4 (solid shape): outline of 1216 points within 83.65,176.53 97.4,189.29
+1.5V on BOTTOM (solid shape): 12.39,40.86 12.39,39.97 12.77,39.58 12.77,38.9 12.74,38.87 11.95,38.87 11.66,38.57 11.66,37.22 11.6,37.13 11.5,37.14 11.37,37.21 11.24,37.23 11.03,37.17 10.88,37.01 10.86,36.98 10.39,36.98 10.16,37.21 10.16,41.16 10.41,41.41 11.84,41.41
+1.05V_DEEP_SUS on TOP (solid shape): outline of 101 points within 126.43,119.84 136.04,131.11
+1.05V_DEEP_SUS on BOTTOM (solid shape): 113.36,129.23 113.51,129.23 113.51,129.03 113.06,128.57 112.8,128.57 112.65,128.72 112.34,128.72 112.17,128.54 112.01,128.54 111.84,128.72 111.4,128.72 111.23,128.54 111.02,128.54 110.59,128.98 110.59,129.13 110.74,129.28 111.66,129.28 111.89,129.05 112.19,129.05 112.32,129.18 112.35,129.22 112.78,129.64 112.95,129.64
+1.05V_DEEP_SUS on BOTTOM (solid shape): 114.19,131.86 114.2,131.85 114.24,131.78 114.3,131.73 114.3,130.96 114.19,130.86 111.61,130.86 111.18,130.42 110.97,130.42 110.39,129.84 110.26,129.84 109.75,130.35 109.75,131.75 109.84,131.84 109.88,131.85 109.92,131.84 110.13,131.62 110.5,131.62 110.52,131.6 110.53,131.59 110.76,131.43 111,131.59 111.01,131.6 111.03,131.62 111.32,131.62 111.35,131.61 111.37,131.58 111.61,131.43 111.84,131.59 111.87,131.62 112.16,131.62 112.19,131.61 112.21,131.59 112.22,131.57 112.45,131.43 112.67,131.57 112.68,131.58 112.71,131.62 113.02,131.62 113.04,131.6 113.05,131.59 113.2,131.44 113.41,131.46 113.42,131.47 113.45,131.47 113.53,131.49 113.6,131.53 113.69,131.62 113.82,131.62 113.91,131.71 113.92,131.72 114,131.77 114.05,131.85 114.06,131.86 114.08,131.87 114.17,131.87
+1.05V_DEEP_SUS on BOTTOM (solid shape): outline of 202 points within 128.55,115.44 132.37,125.65
+1.05V_DEEP_SUS on SVCC (solid shape): outline of 105 points within 109.78,118.64 131.88,131.85
+1.05V_LAN on TOP (solid shape): 17.89,162.46 16.52,161.09 16.52,160.53 16.39,160.39 14.96,160.39 14.9,160.46 14.87,160.48 14.84,160.5 14.82,160.53 14.83,160.57 14.9,160.72 14.92,160.88 14.9,161.04 14.83,161.18 14.81,161.22 15.28,161.69 15.64,161.69 16.04,161.86 16.2,162.26 16.2,162.44 16.24,162.51 16.32,162.54 16.38,162.53 16.44,162.52 16.84,162.69 17,163.09 17,163.25 17.04,163.27 17.18,163.32 17.3,163.41 17.89,163.41
+1.05V_LAN on BOTTOM (solid shape): outline of 92 points within 13.9,159.7 20.83,164.16
+1.05V_LAN on IN2 (solid shape): outline of 410 points within 14.94,161.79 25.66,174.16
+1.05V_LAN_REGOUT on TOP (solid shape): 25.17,167.01 25.71,167.01 25.76,166.96 25.76,166.5 25.68,166.42 25.25,166.42 24.73,165.9 23.92,165.9 23.79,166.03 23.79,166.28 24.12,166.61 24.66,167.15 25.03,167.15
+1.05V_LAN_REGOUT on BOTTOM (solid shape): 12.19,162.76 12.28,162.71 12.27,162.6 12.22,162.49 12.2,162.37 12.61,161.96 13.01,162.37 13,162.49 12.94,162.6 12.93,162.71 13.02,162.76 13.36,162.76 13.63,162.49 13.6,162.46 13.51,162.33 13.48,162.18 13.55,161.95 13.72,161.8 13.75,161.79 13.75,159.84 13.47,159.56 11.89,159.56 11.81,159.6 11.79,159.68 11.79,159.73 11.79,160.03 11.72,160.2 11.54,160.28 11.43,160.28 10.93,160.78 10.41,160.78 10.09,161.11 10.09,161.72 10.2,161.83 10.85,161.83 11.28,162.27 11.28,162.76
+1.05V_LAN_REGOUT on IN2 (solid shape): outline of 907 points within 9.86,156.23 25.4,167.17
+1.8V_DEEP_SUS on TOP (solid shape): 123.78,114.68 123.78,113.01 122.99,113.01 122.99,114.09 122.76,114.33 122.76,114.63 122.86,114.73 123.73,114.73
+1.8V_DEEP_SUS on BOTTOM (solid shape): 123.49,117.19 123.49,115.16 123.73,114.92 123.73,114.86 123.98,114.61 123.98,114.2 123.88,114.1 122.82,114.1 122.76,114.15 122.76,114.92 122.71,114.98 122.71,115.61 122.91,115.95 122.71,116.28 122.71,116.52 122.71,116.52 122.71,117.14 122.83,117.27 123.42,117.27
+1.8V_S5 on TOP (solid shape): 38.62,131.49 38.62,130.55 38.32,130.25 38.32,128.51 38.26,128.45 37.5,128.45 37.42,128.53 37.42,128.83 37.3,128.94 36.73,128.94 35.73,129.94 34.8,129.94 34.72,130.03 34.72,131.47 34.82,131.57 38.54,131.57
+1.8V_S5 on TOP (solid shape): 123.78,112.04 123.8,111.9 123.88,111.78 124.1,111.56 124.1,111.01 124.04,110.94 123.47,110.94 122.96,111.45 122.96,111.8 122.99,111.88 123,111.96 123,112.58 123.09,112.67 123.78,112.67
+1.8V_S5 on TOP (solid shape): 93.12,186.28 93.12,186.23 93.16,186.13 93.25,186.08 93.3,186.07 93.3,185.48 93.3,185.27 92.55,185.27 92.55,185.07 93.3,185.07 93.3,184.93 93.25,184.88 92.92,184.88 92.91,184.88 92.51,184.88 91.8,185.59 91.8,185.6 91.77,185.67 91.72,185.73 91.59,185.87 91.48,185.94 91.36,185.96 90.2,185.96 90.06,186.1 90.06,186.41 90.19,186.53 92.12,186.53 92.28,186.69 92.72,186.69
+1.8V_S5 on TOP (solid shape): outline of 172 points within 91.14,178.3 94.1,183.47
+1.8V_S5 on SVCC (solid shape): 93.78,185.15 93.59,185.01 93.52,184.79 93.59,184.56 93.78,184.42 93.78,184.4 93.7,184.27 93.67,184.13 93.7,183.98 93.78,183.86 93.78,182.64 93.74,182.55 93.73,182.45 93.74,182.35 93.78,182.26 93.78,180.31 93.66,180.18 93.62,180 93.66,179.83 93.78,179.69 93.78,179.48 93.52,179.37 93.41,179.1 93.52,178.84 93.78,178.72 93.78,173.5 61.47,173.5 60.73,173.77 59.98,173.5 49.48,173.5 48.73,173.77 47.98,173.5 47.24,173.5 47.14,173.49 47.06,173.43 45.2,171.57 43.12,171.57 42.98,171.72 42.98,176.9 43.39,177.31 57.73,177.31 57.86,177.22 58.02,177.19 58.17,177.22 58.3,177.31 72.02,177.31 72.16,177.15 72.37,177.09 72.57,177.15 72.71,177.31 74.15,177.31 74.26,177.05 74.53,176.94 74.79,177.05 74.91,177.31 83.62,177.31 83.72,177.33 83.8,177.39 86.28,179.87 86.4,179.8 86.54,179.78 86.85,179.9 86.97,180.21 86.95,180.35 86.88,180.47 87.04,180.63 87.16,180.56 87.3,180.54 87.61,180.67 87.74,180.97 87.71,181.11 87.65,181.23 88.63,182.21 88.68,182.3 88.7,182.39 88.7,186.61 89.57,187.47 93.78,187.47
+1.8V_S5 on IN2 (solid shape): outline of 3283 points within 33.56,97.01 116.46,175.11
+1.8V_S5 on IN3 (solid shape): outline of 104 points within 115.15,106.66 124.79,111.89
+1.8V_SM on TOP (solid shape): 214.15,100.28 214.15,100.03 214.08,99.96 212.43,99.96 212.38,99.91 212.38,99.69 212.42,99.65 214.1,99.65 214.12,99.63 214.12,99.37 214.06,99.3 212.42,99.3 212.38,99.26 212.38,99.06 212.43,99.01 214.07,99.01 214.12,98.96 214.12,98.69 214.08,98.66 210.72,98.66 210.61,98.77 210.61,100.24 210.7,100.33 214.1,100.33
+1.35V_GFX on TOP (solid shape): outline of 13376 points within 129.52,168.58 167.97,207.4
+1.35V_GFX on BOTTOM (solid shape): 164.42,174.94 164.47,174.95 164.53,174.95 164.59,174.89 164.58,174.82 164.68,174.6 164.9,174.51 164.92,174.51 165,174.48 165.03,174.41 165.08,174.27 165.19,174.18 165.19,174.17 165.39,173.98 165.39,173.94 165.38,173.9 165.34,173.88 165.3,173.88 165.12,173.81 165.03,173.64 165,173.57 164.92,173.54 164.83,173.54 164.77,173.6 164.77,173.62 164.69,173.8 164.51,173.88 164.44,173.92 164.42,173.99 164.42,174.02 164.34,174.24 164.14,174.34 164.12,174.34 164,174.46 164.06,174.51 164.1,174.51 164.33,174.6 164.42,174.82 164.42,174.86 164.41,174.89
+1.35V_GFX on BOTTOM (solid shape): outline of 226 points within 128.88,185.81 137.44,197.61
+1.35V_GFX on BOTTOM (solid shape): outline of 7779 points within 144.43,167.9 167.97,209.9
+1.35V_GFX on IN1 (solid shape): outline of 1347 points within 129.51,185.75 142.07,197.93
+1.35V_GFX on IN1 (solid shape): outline of 3532 points within 154.08,169.94 167.08,207.41
+1.35V_GFX on IN3 (solid shape): outline of 274 points within 152.55,194.36 157.25,198.64
+1.35V_GFX on IN3 (solid shape): outline of 5537 points within 129.79,170.27 167.97,210.19
+1.35V_GFX on IN4 (solid shape): outline of 1998 points within 149.79,169.06 167.97,179.18
+1V8_AON on TOP (solid shape): 127.23,187.88 127.23,187.55 127.33,187.45 127.74,187.45 127.82,187.36 127.82,186.91 127.91,186.82 127.91,186.81 127.53,186.43 126.64,186.43 126.52,186.3 125.76,186.3 125.63,186.43 125.63,187.47 125.63,187.7 125.88,187.96 127.16,187.96
+1V8_AON on TOP (solid shape): 113.41,182.05 113.41,181.23 113.4,181.19 113.36,181.18 113.34,181.18 113.06,181.18 112.88,181.1 112.81,180.92 112.81,180.62 112.81,180.59 112.82,180.53 112.29,180 111.82,180 111.81,180.04 111.72,180.18 111.57,180.23 111.29,180.23 110.81,180.72 110.81,181.28 111.52,181.99 112.58,181.99 112.73,182.14 113.32,182.14
+1V8_AON on BOTTOM (solid shape): 97.79,183.92 97.79,183.03 97.76,183.01 97.6,182.86 97.54,182.65 97.54,182.61 97.54,182.58 97.6,182.39 97.74,182.24 97.74,181.81 97.64,181.71 96.72,181.71 96.5,181.94 96.5,184.1 96.55,184.15 97.57,184.15
+1V8_AON on BOTTOM (solid shape): 118.52,178.18 118.52,177.79 118.77,177.54 119.74,177.54 120.98,176.29 121.03,176.25 122.49,176.25 122.55,176.31 123.33,176.31 123.47,176.17 123.47,175.68 123.28,175.5 123.11,175.5 121.98,174.37 120.81,174.37 120.64,174.53 120.64,174.78 120.5,174.93 120.47,174.96 118.98,176.45 118.41,176.45 118.06,176.8 118.07,176.83 118.09,176.91 118.09,176.98 118.09,177.2 117.96,177.52 117.65,177.65 117.5,177.62 117.37,177.55 117.34,177.52 117.22,177.65 116.86,177.65 116.8,177.71 116.8,178.23 116.88,178.3 118.39,178.3
+1V8_AON on BOTTOM (solid shape): 113.56,187.12 113.56,180.39 113.41,180.23 113.41,179.37 113.56,179.22 113.56,178.56 113.69,178.43 114.07,178.43 114.22,178.28 114.3,178.18 114.4,178.1 114.45,178.05 114.91,178.05 115.09,178.23 115.09,178.49 115.31,178.71 115.6,178.71 115.67,178.63 115.67,178.07 115.8,177.95 115.8,177.95 115.8,177.26 115.57,177.03 109.27,177.03 109.01,177.29 109.01,177.64 109.03,177.67 109.06,177.69 109.16,177.69 109.42,177.74 109.65,177.89 110.8,179.04 110.95,179.27 111.01,179.53 111.01,180.38 112.95,182.32 112.95,186.14 113.1,186.29 113.1,187.23 113.14,187.28 113.41,187.28
+1V8_AON on SVCC (solid shape): outline of 99 points within 94.29,171.73 135.94,188.74
+1V8_GFX_MAIN on TOP (solid shape): 127.67,199.77 129.42,199.77 129.58,199.61 129.58,199.32 129.46,199.2 128.88,199.2 128.75,199.06 128.75,198.49 128.54,198.28 128,198.28 127.79,198.5 126.13,198.5 126.02,198.6 126.02,198.96 126.09,199.03 126.2,199.03 126.94,199.77 127.57,199.77
+1V8_GFX_MAIN on TOP (solid shape): outline of 164 points within 112.65,187.45 125.37,193.03
+1V8_GFX_MAIN on TOP (solid shape): outline of 317 points within 137.06,200.66 144.4,208.08
+1V8_GFX_MAIN on BOTTOM (solid shape): 146.08,207.39 146.08,204.97 145.95,204.85 143.54,204.85 143.15,205.23 143.15,207.26 143.41,207.51 145.95,207.51
+1V8_GFX_MAIN on BOTTOM (solid shape): 98.37,187.42 98.37,185.89 98.23,185.75 98.04,185.75 97.89,185.9 97.89,186.26 96.44,186.26 96.35,186.35 96.35,187.56 96.48,187.69 98.1,187.69
+1V8_GFX_MAIN on BOTTOM (solid shape): 126.64,187.96 126.64,187.34 126.51,187.2 126.46,187.15 126.43,187.09 126.41,187.07 126.38,187.07 125.5,187.07 124.87,187.7 124.74,187.7 124.36,188.08 124.36,188.46 124.49,188.59 126.01,188.59
+1V8_GFX_MAIN on IN1 (solid shape): outline of 1730 points within 122.46,187.27 145.35,205.73
+1V8_GFX_MAIN on SVCC (solid shape): 123.11,190.29 123.11,190.25 123.21,189.99 123.46,189.89 123.51,189.89 126.04,187.37 126.04,185.29 125.68,184.93 117.76,184.93 113.52,189.18 113.44,189.23 113.34,189.25 109.78,189.25 109.68,189.23 109.6,189.18 105.61,185.19 94.29,185.19 94.29,192.45 99.73,197.89 115.52,197.89
+1V8_GFX_MAIN on IN3 (solid shape): outline of 1601 points within 124.33,187.14 145.46,206.21
+1V_SUS on TOP (solid shape): 138.81,134.89 138.81,134.07 138.65,133.91 138.65,130.55 138.83,130.37 139.38,130.37 139.57,130.18 139.57,129.39 139.45,129.28 137.36,129.28 137.27,129.37 137.27,130.22 137.45,130.4 137.45,132.17 137.67,132.53 137.45,132.9 137.45,134.72 137.8,135.07 138.63,135.07
+2.5V_SUS on TOP (solid shape): 65.29,105.25 65.29,104.27 65.25,104.23 63.93,104.23 63.76,104.06 63.67,104.07 63.64,104.07 63.35,103.95 63.23,103.66 63.23,103.63 62.92,103.32 62.7,103.32 62.33,103.69 62.33,104.39 62.46,104.52 62.8,104.52 63.07,104.79 63.07,105.36 63.13,105.42 65.12,105.42
+2.5V_SUS on TOP (solid shape): 51.33,106.51 50.98,106.17 50.98,105.78 51.24,105.52 51.69,105.52 51.71,105.51 51.71,103.48 51.43,103.21 49.63,103.21 49.54,103.26 49.54,103.36 49.64,103.96 49.34,104.49 49.34,104.95 49.38,105.03 49.47,105.05 49.53,105.03 49.59,105.03 50,105.44 49.59,105.84 49.56,105.84 49.49,105.86 49.45,105.92 49.41,106.03 49.34,106.12 49.34,106.39 49.52,106.57 51.27,106.57
+2.5V_SUS on BOTTOM (solid shape): 84.75,187.17 84.75,186.61 84.78,186.48 84.84,186.38 84.84,185.24 83.18,185.24 83.01,185.41 83.01,185.76 83.11,185.86 83.51,185.86 83.51,187.25 84.67,187.25
+2.5V_SUS on BOTTOM (solid shape): 66.51,178.88 66.55,178.85 66.6,178.85 67.53,178.85 68.48,177.9 68.48,177.31 68.47,177.21 68.46,177.12 68.46,175.49 68,175.03 66.88,175.03 66.2,175.71 66.2,178.66 66.42,178.89 66.5,178.89
+2.5V_SUS on BOTTOM (solid shape): 51.38,105.65 51.46,105.65 51.53,105.65 51.62,105.69 53.65,105.69 53.68,105.66 53.68,105.45 51.95,105.45 51.95,105.2 53.66,105.2 53.66,104.96 53.06,104.35 51.44,104.35 50.64,105.16 50.64,105.54 50.78,105.69 51.29,105.69
+2.5V_SUS on BOTTOM (solid shape): outline of 158 points within 62.08,102.67 68.44,105.69
+2.5V_SUS on IN2 (solid shape): outline of 357 points within 50.45,101.57 64.11,105.54
+2.5V_SUS on IN3 (solid shape): outline of 688 points within 66.35,176.75 84.79,186.32
+3.3V_TYPEC_MUX1 on TOP (solid shape): outline of 97 points within 14.31,60.71 26.48,67.67
+3.3V_TYPEC_MUX1 on BOTTOM (solid shape): 22.03,70.13 22.1,70.13 23.82,70.13 23.88,70.1 24.05,69.77 24.32,69.66 24.36,69.66 24.43,69.67 24.74,69.36 24.74,68.88 24.64,68.74 24.6,68.57 24.63,68.4 24.73,68.27 24.74,68.26 24.74,68.19 24.73,68.18 24.65,68.05 24.62,67.91 24.74,67.62 25.08,67.5 25.14,67.51 25.16,67.52 25.25,67.43 25.25,67.32 24.87,66.94 24.17,66.94 23.63,67.49 23.63,68.86 23.5,68.98 22.58,68.98 22.38,68.78 22.38,68.02 22.22,67.86 21.15,67.86 21.12,67.89 21.11,67.93 21.09,68.04 21.04,68.14 21.04,68.75 21.09,68.85 21.11,68.95 21.11,68.97 21.16,69.02 21.7,69.02 21.82,69.15 21.82,69.19 21.87,69.24 21.87,70.08 21.94,70.15
+3.3V_TYPEC_MUX1 on IN4 (solid shape): 15.27,73.9 15.61,73.65 15.95,73.9 15.96,73.94 17.08,73.94 18.26,72.77 22.13,72.77 24.08,70.81 24.08,70.33 23.97,70.07 24.08,69.8 24.08,68.7 24.71,68.07 24.7,68.04 24.68,67.97 24.67,67.91 24.78,67.65 25.03,67.55 25.04,67.55 25.12,67.52 25.15,67.45 25.15,67.21 24.92,66.98 22.89,66.98 22.2,67.66 22.2,70.08 21.67,70.61 16.79,70.61 16.13,71.28 16.13,71.87 16.1,71.98 16.04,72.08 15.28,72.83 15.19,72.9 15.07,72.92 14.48,72.92 14.42,72.98 14.42,73.62 14.68,73.88 14.69,73.88 14.84,73.9 15,73.94 15.26,73.94
+3V on TOP (solid shape): 64.03,106.91 64.03,105.99 63.71,105.67 63.13,105.67 63.05,105.75 63.05,106.21 62.89,106.38 62.89,106.82 63.04,106.97 63.97,106.97
+3V on TOP (solid shape): 235.46,120.16 235.46,118.44 235.33,118.3 234.38,118.3 233.94,118.74 233.94,120.06 234.24,120.37 235.26,120.37
+3V on TOP (solid shape): 74.02,196.31 74.02,193.87 73.71,193.57 71.25,193.57 71.15,193.67 71.15,195.42 72.09,196.36 73.08,196.36 73.08,196.36 73.97,196.36
+3V on TOP (solid shape): 24.05,139.44 24.05,138.65 24.25,138.45 25.35,138.45 25.42,138.52 25.42,138.88 25.6,139.07 26.54,139.07 26.76,138.85 26.76,137.25 26.68,137.17 24.39,137.17 23.79,137.77 23.79,139.46 23.82,139.49 24.01,139.49
+3V on TOP (solid shape): 38.6,148.69 38.6,146.23 38.1,145.73 37.42,145.73 37.04,146.1 36.68,146.1 36.49,146.29 36.35,146.29 36.09,146.54 36.09,147.37 36.18,147.46 37.23,147.46 37.55,147.77 37.55,148.78 37.64,148.87 38.42,148.87
+3V on TOP (solid shape): 53.1,106.55 53.1,106.09 52.96,105.96 52.73,105.96 52.56,105.78 52.56,105.31 52.37,105.11 52.37,104.07 51.96,104.07 51.96,104.07 51.96,105.62 51.8,105.78 51.34,105.78 51.24,105.88 51.24,106.07 51.82,106.65 53,106.65
+3V on TOP (solid shape): 106.34,110.79 106.59,110.79 106.62,110.82 107.75,110.82 107.95,110.61 107.95,110.17 107.68,110.17 107.51,110 106.84,110 106.73,109.9 106.73,109.55 106.58,109.39 106.23,109.39 106.07,109.55 106.07,109.65 106.21,109.79 106.21,110.75 106.28,110.82 106.31,110.82
+3V on TOP (solid shape): 22.06,139.47 22.06,138.66 22.08,138.66 22.08,137.8 21.96,137.68 21.9,137.6 21.87,137.51 21.87,137.49 21.66,137.28 19.24,137.28 18.69,136.74 18.25,136.74 18.13,136.86 18.13,139.18 18.29,139.34 19,139.34 19.18,139.16 19.19,139.16 19.35,138.99 19.43,138.94 19.52,138.91 19.54,138.91 20.04,138.41 21.65,138.41 21.79,138.55 21.79,139.44 21.83,139.48 22.05,139.48
+3V on TOP (solid shape): 34.8,128.87 34.91,128.83 35.03,128.81 35.24,128.81 35.37,128.68 35.37,127.13 35.28,127.03 35.16,127.03 35.15,127.04 35.05,127.08 34.95,127.09 34.84,127.08 34.74,127.03 33.63,127.03 33.51,127.15 33.51,128.35 33.55,128.39 34.36,128.39 34.46,128.44 34.51,128.55 34.51,128.63 34.76,128.89
+3V on TOP (solid shape): 121.14,115.83 121.14,115.38 120.72,114.95 120.66,114.95 120.65,114.97 120.43,115.06 120.2,114.97 120.19,114.95 120.14,114.95 120.09,115.01 119.94,115.01 119.82,115.09 119.68,115.12 119.53,115.09 119.41,115.01 119.32,115.01 119.09,114.78 118.74,114.78 118.6,114.92 118.6,115.48 118.77,115.65 119.97,115.65 120.09,115.57 120.22,115.55 120.43,115.61 120.56,115.79 120.56,115.8 120.67,115.91 121.05,115.91
+3V on TOP (solid shape): 26.33,69.68 26.73,69.68 27.07,69.35 27.07,68.32 27.05,68.27 27.05,68.22 27.05,67.78 27.06,67.72 27.08,67.66 27.08,67.63 27.2,67.34 27.49,67.22 27.53,67.22 27.57,67.19 27.57,66.84 27.56,66.83 27.56,66.62 27.33,66.39 26.17,66.39 25.9,66.66 25.9,67.21 25.71,67.4 25.71,68.12 25.75,68.13 26.03,68.27 26.14,68.56 26.13,68.65 26.1,68.74 26.1,69.56 26.24,69.69
+3V on TOP (solid shape): 72.74,107.14 72.74,106.19 71.69,105.14 71.62,105.04 71.59,104.92 71.59,101.19 71.54,101.1 71.43,101.11 71.3,101.19 71.16,101.21 70.87,101.09 70.75,100.81 70.79,100.63 70.9,100.49 70.94,100.42 70.91,100.34 70.69,100.11 70.69,99.18 70.54,99.03 70.49,98.83 70.5,98.72 70.54,98.63 70.56,98.59 70.51,98.54 69.63,98.54 69.21,98.96 69.15,99.05 69.06,99.11 68.56,99.61 68.56,100.12 69.25,100.8 69.25,101.76 70.23,102.74 70.23,106.52 71.15,107.44 72.44,107.44
+3V on TOP (solid shape): outline of 102 points within 95.28,96.95 99.86,107.95
