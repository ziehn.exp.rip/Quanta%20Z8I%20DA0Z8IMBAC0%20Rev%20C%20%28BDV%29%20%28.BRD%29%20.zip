# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ13: length 36.8
  IN4 w0.127: v2(129.3,182.85) 129.71,182.45 130.53,182.45 131.29,183.2 133.83,183.2 133.91,183.28 137.67,183.28 137.82,183.13 139.27,183.13 139.43,183.29 143.07,183.29 144.23,184.45 146.54,184.45 147.7,185.62 156.69,185.62 158.9,183.4 158.9,182.32 159.6,181.62 160.51,181.62 v2(160.9,181.22)
  BOTTOM w0.165: VRAM1.F11 161.3,180.82 v2(160.9,181.22) ; U8.B13 129.68,183.23 v2(129.3,182.85)
VMA_DQ14: length 44.6
  IN4 w0.127: v2(130.14,185.25) 130.53,185.65 130.53,186.31 130.72,186.49 131.11,186.49 131.34,186.72 131.34,187.18 132.86,188.69 132.86,188.81 133.17,189.12 134.28,189.12 135.39,188.01 136.48,188.01 136.67,188.2 139.4,188.2 139.41,188.21 142.34,188.21 143.15,189.02 162.05,189.02 164.49,186.58 164.49,183.26 165,182.75 165,182.12 v2(164.9,182.02)
  BOTTOM w0.165: v2(130.14,185.25) 129.75,185.65 U8.E13 ; VRAM1.B13 164.51,182.42 v2(164.9,182.02)
VMA_DQ15: length 35.6
  IN4 w0.127: v2(130.14,184.45) 130.57,184.02 132.74,184.02 132.99,184.27 133.82,184.27 134.1,183.99 138.05,183.99 138.46,184.4 139.39,184.4 139.77,184.02 140.33,184.02 141.67,185.36 146.16,185.36 147.33,186.53 157.07,186.53 159.45,184.15 160.23,184.15 160.5,183.88 160.5,183.22 v2(160.9,182.82)
  BOTTOM w0.165: VRAM1.F13 161.3,182.42 v2(160.9,182.82) ; v2(130.14,184.45) 129.75,184.85 U8.D13
VMA_DQ16: length 31.6
  IN4 w0.127: v2(130.9,182.08) 130.84,182.08 130.2,181.45 130.2,180.46 132.16,178.51 133.95,178.51 134.76,177.69 149.09,177.69 150.57,179.18 154.67,179.18 155.09,179.6 155.09,180.18 v2(155.32,180.41)
  BOTTOM w0.165: U8.B15 131.33,183.25 130.9,182.81 v2(130.9,182.08) ; VRAM1.N11 155.7,180.79 v2(155.32,180.41)
VMA_DQ17: length 26.6
  IN4 w0.127: v2(131.85,181.86) 131.47,181.48 131.47,180.54 132.59,179.42 134.33,179.42 135.14,178.61 148.71,178.61 150.44,180.34 151.97,180.34 v2(152.07,180.43)
  BOTTOM w0.165: v2(152.07,180.43) 152.45,180.82 VRAM1.U11 ; U8.C16 131.76,183.65 131.76,181.95 v2(131.85,181.86)
VMA_DQ18: length 32.1
  IN4 w0.127: v2(156.11,180.42) 155.6,179.91 155.6,179.46 154.86,178.72 150.76,178.72 149.28,177.24 134.57,177.24 133.76,178.05 131.72,178.05 129.68,180.09 v2(129.68,181.73)
  BOTTOM w0.165: v2(156.11,180.42) 156.5,180.81 VRAM1.M11 ; v2(129.68,181.73) U8.A13
VMA_DQ19: length 26.9
  IN4 w0.127: v2(130.96,181.46) 130.66,181.15 130.66,180.69 132.38,178.96 134.14,178.96 134.95,178.15 148.9,178.15 150.63,179.88 152.37,179.88 v2(152.91,180.41)
  BOTTOM w0.165: v2(130.96,181.46) 131.39,181.88 131.39,182.42 U8.A15 ; VRAM1.T11 152.91,180.43 v2(152.91,180.41)
VMA_DQ20: length 23
  IN4 w0.127: v2(133.5,181.1) 133.65,180.95 134.96,180.95 135.77,180.13 148.08,180.13 150.31,182.37 v2(151.92,182.37)
  BOTTOM w0.102: v2(133.5,181.1) 133,181.6 133,181.97 133.5,182.46 133.5,182.74 133.84,183.09 U8.B18
  BOTTOM w0.165: VRAM1.U13 152.45,182.37 v2(151.92,182.37)
VMA_DQ21: length 23.3
  IN4 w0.127: v2(152.89,183.63) 150.93,183.63 147.89,180.59 135.96,180.59 135.15,181.4 133.96,181.4 v2(133.5,181.86)
  BOTTOM w0.165: U8.A18 133.84,182.2 v2(133.5,181.86) ; v2(152.89,183.63) 152.89,182.83 VRAM1.T13
VMA_DQ22: length 28.6
  IN4 w0.127: v2(134.52,181.86) 135.08,182.42 135.79,182.42 135.95,182.27 135.95,181.25 136.1,181.1 136.4,181.1 136.56,181.25 136.56,182.27 136.71,182.42 137.17,182.42 137.46,182.13 137.46,181.21 137.62,181.05 144.48,181.05 146.48,183.05 149.71,183.05 150.74,184.09 155.44,184.09 155.74,183.78 155.74,183.25 v2(155.32,182.82)
  BOTTOM w0.165: v2(155.32,182.82) 155.7,182.44 VRAM1.N13 ; v2(134.52,181.86) 134.52,182.33 U8.A19
VMA_DQ23: length 27.1
  IN4 w0.127: v2(134.26,182.85) 134.29,182.88 137.36,182.88 137.91,182.32 138.38,182.32 139.19,181.5 144.27,181.5 146.28,183.51 149.52,183.51 150.55,184.54 155.63,184.54 156.2,183.97 156.2,182.91 v2(156.11,182.82)
  BOTTOM w0.165: v2(134.26,182.85) 134.26,183.67 U8.C19 ; VRAM1.M13 156.5,182.42 v2(156.11,182.82)
VMA_DQ24: length 21.2
  BOTTOM w0.165: U8.B24 138.82,183.02 139.22,182.62 139.22,181.85
  BOTTOM w0.178: VRAM1.N4 155.3,175.62 155.3,176.2 155.03,176.46 155.03,176.59 154.5,177.12 152.83,177.12 148.38,181.57 140.69,181.57 140.65,181.61 139.47,181.61 139.22,181.85
VMA_DQ25: length 19.6
  BOTTOM w0.165: 138.45,181.23 138.45,183.57 U8.C23
  BOTTOM w0.178: VRAM1.U4 151.94,175.78 151.94,175.92 147.77,180.09 139.59,180.09 138.45,181.23
VMA_DQ26: length 20.8
  BOTTOM w0.165: U8.A25 139.62,182.2
  BOTTOM w0.178: 139.62,182.2 139.79,182.04 141.87,182.04 142.14,182.3 146.3,182.3 146.56,182.04 148.95,182.04 153.03,177.97 154.75,177.97 156.11,176.61 156.11,175.61 VRAM1.M4
VMA_DQ27: length 18.3
  BOTTOM w0.165: U8.A24 138.82,181.62
  BOTTOM w0.178: 138.82,181.62 139.27,181.17 139.55,181.17 139.89,180.83 148.08,180.83 152.51,176.4 152.73,176.4 152.91,176.22 152.91,175.61 VRAM1.T4
VMA_DQ28: length 27.7
  BOTTOM w0.165: 152.91,173.22 VRAM1.T2 ; U8.A21 136.32,182.09 136.47,181.94
  BOTTOM w0.178: 152.91,173.22 152.12,173.22 150.81,171.91 149.24,171.91 146.72,169.39 143.33,169.39 140.8,171.91 140.8,175.6 136.47,179.94 136.47,181.94
VMA_DQ29: length 21.8
  BOTTOM w0.165: U8.B21 136.73,182.84 136.73,182.24 136.86,182.11 136.86,180.61
  BOTTOM w0.178: VRAM1.U2 151.12,173.62 146.86,177.88 143.45,177.88 142.95,177.38 140.09,177.38 136.86,180.61
VMA_DQ30: length 36.3
  BOTTOM w0.165: VRAM1.M2 156.11,173.23 156.11,172.13 ; U8.C20 135.48,183.84 135.03,183.38 135.03,182.24 134.97,182.18 134.97,180.08
  BOTTOM w0.178: 134.97,180.08 134.97,179.35 139.33,174.99 139.33,171.3 142.72,167.91 147.33,167.91 149.86,170.44 154.42,170.44 156.11,172.13
VMA_DQ31: length 33.6
  BOTTOM w0.165: 155.3,172.54 155.3,173.21 VRAM1.N2 ; U8.C21 135.92,183.64 135.92,180.08
  BOTTOM w0.178: 155.3,172.54 153.93,171.18 149.55,171.18 147.02,168.65 143.03,168.65 140.07,171.61 140.07,175.29 135.92,179.45 135.92,180.08
VMA_DQ32: length 37.8
  IN4 w0.127: v2(165.7,198.02) 166.57,197.16 166.57,194.4 163.83,191.66 159.85,191.66 159.39,191.21 145.14,191.21 144.47,190.54 142.9,190.54 142.69,190.75 138.96,190.75 137.99,191.72 137.99,192.95 137.6,193.34 v2(137.6,193.57)
  BOTTOM w0.165: v2(137.6,193.57) U8.R22 ; VRAM2.U11 165.7,198.02 v2(165.7,198.02)
VMA_DQ33: length 28
  IN4 w0.127: v2(161.7,198.02) 162.2,198.53 162.2,199.26 161.75,199.72 153,199.72 148.93,195.65 142.44,195.65 141.17,194.38 139.24,194.38 v2(139.23,194.38)
  BOTTOM w0.165: v2(139.23,194.38) 138.85,193.99 U8.R24 ; VRAM2.N11 162.1,197.62 v2(161.7,198.02)
VMA_DQ34: length 33.8
  IN4 w0.127: v2(137.6,194.39) 138.01,193.98 138.01,193.29 138.19,193.12 138.67,193.12 138.84,192.96 138.84,192.53 139.02,192.34 139.4,192.34 139.61,192.12 139.61,191.54 139.85,191.3 143.45,191.3 144.27,192.12 159.02,192.12 159.47,192.58 163.52,192.58 165.13,194.18 165.13,195.05 v2(165.7,195.62)
  BOTTOM w0.165: v2(165.7,195.62) 165.31,196.02 VRAM2.U13
  BOTTOM w0.305: v2(137.6,194.39) 137.2,194.79 U8.T22
VMA_DQ35: length 25.6
  IN4 w0.127: v2(138.41,193.53) 138.81,193.92 139.58,193.92 139.65,193.99 140.23,193.99 140.27,193.95 141.39,193.95 142.66,195.22 149.47,195.22 151.88,197.63 160.51,197.63 v2(160.9,198.02)
  BOTTOM w0.165: v2(160.9,198.02) 161.3,197.62 VRAM2.M11 ; v2(138.41,193.53) 138.02,193.92 U8.R23
VMA_DQ36: length 25.1
  IN4 w0.127: v2(161.7,195.57) 160.81,196.46 152.21,196.46 150.54,194.79 142.88,194.79 142.05,193.97 v2(142.05,193.8)
  BOTTOM w0.127: v2(142.05,193.8) 142.05,193.46 141.61,193.02 141.1,193.02 140.87,192.78 140.39,192.78 139.92,192.31 U8.N25
  BOTTOM w0.165: VRAM2.N13 162.1,195.97 v2(161.7,195.57)
VMA_DQ37: length 22.9
  IN4 w0.127: v2(160.9,195.57) 160.47,196 152.47,196 150.82,194.36 143.1,194.36 v2(142.81,194.07)
  BOTTOM w0.127: U8.N26 140.64,192.53 140.94,192.53 141.2,192.79 141.71,192.79 142.81,193.88 v2(142.81,194.07)
  BOTTOM w0.165: v2(160.9,195.57) 161.3,195.97 VRAM2.M13
VMA_DQ38: length 34.6
  IN4 w0.127: v2(164.9,197.22) 166.13,195.99 166.13,194.58 163.68,192.12 159.66,192.12 159.2,191.66 144.7,191.66 144.09,191.05 139.26,191.05 138.8,191.51 138.8,192.1 138.41,192.49 v2(138.41,192.7)
  BOTTOM w0.165: VRAM2.T11 164.51,197.62 v2(164.9,197.22) ; v2(138.41,192.7) U8.N23
VMA_DQ39: length 29.9
  IN4 w0.127: v2(139.23,192.74) 139.95,192.74 140.42,192.27 140.42,191.8 140.67,191.56 143.05,191.56 144.07,192.58 158.83,192.58 159.28,193.04 163.34,193.04 164.62,194.32 164.62,195.34 v2(164.9,195.62)
  BOTTOM w0.165: VRAM2.T13 164.51,196.02 v2(164.9,195.62) ; v2(139.23,192.74) 138.82,192.33 U8.N24
VMA_DQ40: length 27.9
  IN4 w0.127: v2(137.51,196.87) 137.53,196.87 138.03,197.36 139.81,197.36 140.38,196.8 140.85,196.8 141.43,197.38 148.22,197.38 152.43,201.6 160.28,201.6 160.51,201.82 160.51,202.42 v2(160.9,202.81)
  BOTTOM w0.165: v2(137.51,196.87) 137.52,196.86 137.53,196.86 137.92,196.47 U8.V23 ; VRAM2.M4 161.3,203.22 160.9,202.82 v2(160.9,202.81)
VMA_DQ41: length 30.3
  IN4 w0.127: v2(137.53,196.04) 137.53,196.09 137.85,196.42 138.88,196.42 138.92,196.46 139.61,196.46 139.72,196.34 141.04,196.34 141.65,196.95 148.39,196.95 152.59,201.14 161.65,201.14 162.11,201.6 162.11,203.23 v2(162.5,203.62)
  BOTTOM w0.165: VRAM2.N4 162.1,203.22 v2(162.5,203.62) ; v2(137.53,196.04) 137.18,196.39 U8.V22
VMA_DQ42: length 31.9
  IN4 w0.127: v2(138.42,194.39) 138.85,194.81 140.89,194.81 142.16,196.08 148.75,196.08 152.89,200.22 163.1,200.22 v2(165.7,202.82)
  BOTTOM w0.165: v2(138.42,194.39) U8.T23 ; v2(165.7,202.82) 165.31,203.22 VRAM2.U4
VMA_DQ43: length 31.6
  IN4 w0.127: v2(164.9,202.82) 162.76,200.68 152.74,200.68 148.57,196.52 141.94,196.52 141.05,195.62 138.97,195.62 138.89,195.54 137.97,195.54 v2(137.65,195.21)
  BOTTOM w0.165: VRAM2.T4 164.51,203.22 v2(164.9,202.82) ; U8.U22 137.59,195.21 v2(137.65,195.21)
VMA_DQ44: length 30.5
  IN4 w0.127: v2(162.5,205.22) 162.1,205.62 162.1,206.22 161.91,206.42 158.73,206.42 158.14,207.01 151.75,207.01 147.12,202.37 145.76,202.37 144.98,201.59 141.87,201.59 140.45,200.17 140.45,199.19 140.18,198.93 138.73,198.93 v2(138.42,198.61)
  BOTTOM w0.165: U8.Y24 138.82,198.21 v2(138.42,198.61) ; v2(162.5,205.22) 162.1,204.82 VRAM2.N2
VMA_DQ45: length 32.3
  IN4 w0.127: v2(164.1,205.22) 164.1,205.35 164.57,205.82 164.57,206.16 163.86,206.87 159.16,206.87 158.57,207.46 151.56,207.46 146.93,202.83 144.95,202.83 144.17,202.05 141.68,202.05 139.39,199.76 138.91,199.76 138.49,199.35 v2(138.42,199.35)
  BOTTOM w0.165: v2(164.1,205.22) 164.1,205.22 VRAM2.T2 ; v2(138.42,199.35) U8.AA24
VMA_DQ46: length 29.7
  IN4 w0.127: v2(161.7,205.22) 161.19,205.74 158.9,205.74 158.76,205.59 157.52,205.59 156.62,206.5 151.89,206.5 145.53,200.13 141.84,200.13 141.47,199.76 141.47,199.6 140.36,198.5 139.07,198.5 138.79,198.22 138.21,198.22 v2(137.64,197.65)
  BOTTOM w0.165: VRAM2.M2 161.3,204.82 v2(161.7,205.22) ; v2(137.64,197.65) U8.Y22
VMA_DQ47: length 34.2
  IN4 w0.127: v2(137.57,199.35) 137.75,199.35 139.25,200.85 139.83,200.85 141.49,202.51 143.98,202.51 144.76,203.28 146.74,203.28 151.37,207.92 158.88,207.92 159.47,207.33 164.17,207.33 165.13,206.37 165.13,205.45 v2(164.9,205.22)
  BOTTOM w0.165: v2(164.9,205.22) 164.9,205.22 VRAM2.U2 ; v2(137.57,199.35) 137.97,198.95 U8.AA23
VMA_DQ48: length 19.8
  IN1 w0.127: v2(143.65,202.91) 147.07,202.91 151.64,207.48 155.14,207.48 156.18,206.44 156.18,205.3 v2(156.1,205.22)
  BOTTOM w0.165: v2(156.1,205.22) 156.1,205.22 VRAM2.F2 ; U8.AD27 141.66,201.45 141.76,201.54 142.51,201.54 142.9,201.94
  BOTTOM w0.178: 142.9,201.94 143.65,202.69 v2(143.65,202.91)
VMA_DQ49: length 18.8
  IN1 w0.127: v2(139.22,199.35) 139.22,199.52 139.73,200.02 140.11,200.02 142.01,201.93 147.3,201.93 151.87,206.49 152.24,206.49 152.9,205.84 v2(152.9,205.3)
  BOTTOM w0.165: VRAM2.B2 153.3,204.9 v2(152.9,205.3) ; v2(139.22,199.35) U8.AB25
VMA_DQ50: length 20.6
  IN1 w0.127: v2(142.41,202.94) 143,202.36 147.12,202.36 151.82,207.05 154.96,207.05 155.75,206.26 155.75,205.65 v2(155.32,205.22)
  BOTTOM w0.165: VRAM2.E2 155.7,204.84 v2(155.32,205.22) ; U8.AD26 140.83,201.86 141.62,201.86 141.76,202 142.09,202 142.41,202.33 v2(142.41,202.94)
VMA_DQ51: length 15.5
  IN1 w0.127: v2(142.52,201.04) 142.98,201.49 147.92,201.49 151.8,205.38 v2(151.94,205.38)
  BOTTOM w0.165: U8.AC25 140.07,200.15 140.52,200.15 140.85,200.48 142.09,200.48 142.52,200.91 v2(142.52,201.04) ; v2(151.94,205.38) VRAM2.A2
VMA_DQ52: length 14.4
  IN1 w0.127: v2(152.91,202.81) 152.39,203.33 151.97,203.33 148.75,200.11 142.27,200.11 142.01,199.85 v2(142.01,199.64)
  BOTTOM w0.165: v2(152.91,202.81) 152.91,202.83 VRAM2.B4 ; U8.AA27 141.91,199.64 v2(142.01,199.64)
VMA_DQ53: length 14.2
  IN1 w0.127: v2(152.07,202.81) 148.89,199.64 v2(143.26,199.64)
  BOTTOM w0.127: 141.64,198.86 141.37,198.59 141.05,198.59 140.69,198.95 U8.AA26
  BOTTOM w0.165: 142.9,199.17 142.6,198.86 141.64,198.86 ; VRAM2.A4 152.45,203.22 152.07,202.83 v2(152.07,202.81)
  BOTTOM w0.178: 142.9,199.17 143.26,199.52 v2(143.26,199.64)
VMA_DQ54: length 17.7
  IN1 w0.127: v2(155.28,202.82) 154.19,201.73 151.86,201.73 148.51,198.37 v2(142.98,198.37)
  BOTTOM w0.102: U8.W26 140.79,197.64 142.24,197.64 v2(142.98,198.37)
  BOTTOM w0.165: v2(155.28,202.82) 155.69,203.22 VRAM2.E4
VMA_DQ55: length 19.6
  IN1 w0.127: v2(141.71,198.37) 142.21,197.87 148.62,197.87 152.04,201.29 154.57,201.29 156.09,202.81 v2(156.1,202.81)
  BOTTOM w0.127: v2(141.71,198.37) 141.6,198.26 140.95,198.26 140.74,198.46 139.98,198.46 U8.Y25
  BOTTOM w0.165: v2(156.1,202.81) 156.1,202.82 VRAM2.F4
VMA_DQ56: length 13.7
  BOTTOM w0.165: 141.83,194.86 141.33,194.36 141.06,194.36 140.69,193.99 U8.R26
  BOTTOM w0.178: VRAM2.B13 152.91,195.62 152.14,195.62 151.49,194.97 143.96,194.97 143.85,194.86 141.83,194.86
VMA_DQ57: length 13.9
  BOTTOM w0.165: 141.72,195.16 140.97,195.16 140.79,194.98 140.79,194.63 140.55,194.39 140.02,194.39 U8.T25
  BOTTOM w0.178: VRAM2.A13 151.93,196.02 151.62,195.71 144.01,195.71 143.47,195.16 141.72,195.16
VMA_DQ58: length 18.3
  BOTTOM w0.127: U8.N27 141.37,192.45 142.7,192.45
  BOTTOM w0.178: 142.7,192.45 143.74,193.5 148.06,193.5 148.55,193.01 155.12,193.01 156.24,194.13 156.24,194.81 156.11,194.94 156.11,195.63 VRAM2.F13
VMA_DQ59: length 16.7
  BOTTOM w0.165: U8.R27 141.55,193.99 142.05,194.49
  BOTTOM w0.178: 142.05,194.49 143.05,194.49 143.3,194.24 148.51,194.24 149,193.75 154.7,193.75 155.07,194.12 155.07,194.67 155.3,194.89 155.3,195.61 VRAM2.E13
VMA_DQ60: length 13.3
  BOTTOM w0.165: 152.13,197.99 VRAM2.A11 ; U8.V26 140.61,196.47 141.08,196 141.91,196
  BOTTOM w0.178: 141.91,196 142.84,196 144.82,197.99 152.13,197.99
VMA_DQ61: length 13.9
  BOTTOM w0.178: VRAM2.B11 152.91,198.01 152.91,198.55 152.58,198.88 145.29,198.88 142.88,196.47 U8.V27
VMA_DQ62: length 18.9
  BOTTOM w0.165: U8.W27 142.49,197.27
  BOTTOM w0.178: 142.49,197.27 143.4,198.18 143.4,199.08 144.68,200.35 155.02,200.35 156.1,199.27 156.1,198.02 VRAM2.F11
VMA_DQ63: length 18.9
  BOTTOM w0.102: 154.97,198.94 154.97,198.83 155.26,198.54 155.26,198.06 VRAM2.E11
  BOTTOM w0.165: U8.W25 140,196.89
  BOTTOM w0.178: 140,196.89 142.7,196.89 143.91,198.1 143.91,198.55 144.98,199.61 154.46,199.61 154.97,199.1 154.97,198.94
VMA_WCK01: length 37.3
  IN3 w0.102: v2(133.4,183.61) 133.76,183.61 134.09,183.28 134.83,183.28 139.5,178.61 148.14,178.61 153.08,173.67 161.14,173.67 161.89,174.42 161.89,174.92 162.86,175.89 162.9,175.89 163.04,175.89 v2(163.3,175.62)
  BOTTOM w0.102: v2(163.3,175.62) 162.9,175.22 VRAM1.D4 ; U8.D18 133.5,184.5 133.5,183.7 v2(133.4,183.61)
VMA_WCK01#: length 37.2
  IN3 w0.102: v2(134.26,184.42) 133.91,184.07 133.91,183.73 134.17,183.47 134.91,183.47 139.58,178.8 148.22,178.8 153.16,173.86 161.07,173.86 161.7,174.49 161.7,175 162.78,176.08 162.86,176.08 162.95,176.08 163.04,176.08 163.3,176.35 v2(163.3,176.42)
  BOTTOM w0.102: v2(163.3,176.42) 162.9,176.02 VRAM1.D5 ; U8.C18 133.71,184.18 133.71,184.32 133.81,184.42 v2(134.26,184.42)
VMA_WCK23: length 27.2
  IN3 w0.102: v2(132.57,184.44) 132.75,184.63 133.75,184.63 133.99,184.87 134.44,184.87 134.93,184.38 134.93,184.28 136.71,182.51 137.84,182.51 140.85,179.5 149.19,179.5 152.67,176.02 154.11,176.02 v2(154.5,175.62)
  BOTTOM w0.102: v2(154.5,175.62) 154.5,175.61 VRAM1.P4 ; U8.D17 132.97,184.85 v2(132.57,184.44)
VMA_WCK23#: length 27.3
  IN3 w0.102: v2(154.5,176.42) 154.29,176.21 152.75,176.21 149.27,179.69 140.93,179.69 137.92,182.7 136.78,182.7 135.12,184.36 135.12,184.46 134.52,185.06 133.91,185.06 133.67,184.82 133,184.82 132.6,185.22 v2(132.6,185.23)
  BOTTOM w0.102: v2(154.5,176.42) 154.5,176.23 154.71,176.02 VRAM1.P5 ; U8.D16 132.23,184.85
  BOTTOM w0.127: 132.23,184.85 132.6,185.22 v2(132.6,185.23)
VMA_WCK45: length 35.5
  IN3 w0.089: v2(138.44,195.14) 138.44,195.39 138.38,195.45 138.21,195.45 138.04,195.62 137.91,195.75 137.91,196.24 137.89,196.27 137.89,197.09 138.18,197.38 138.72,197.38 138.92,197.58 139.53,197.58
  IN3 w0.102: v2(162.5,202.82) 162.28,202.6 162.16,202.6 161.98,202.78 161.98,204.28 161.42,204.83 159.02,204.83 158.5,205.36 157.71,205.36 156.39,206.68 151.77,206.68 151.16,206.07 151.16,205.26 143.39,197.48 140.56,197.48 140.37,197.29 139.82,197.29 139.53,197.58
  BOTTOM w0.102: U8.T24 138.82,195.08 138.71,195.2 138.49,195.2 v2(138.44,195.14) ; VRAM2.P4 162.9,203.22 v2(162.5,202.82)
VMA_WCK45#: length 35.6
  IN3 w0.089: 139.45,197.39 139.44,197.4 139,197.4 138.79,197.2 138.25,197.2 138.07,197.01 138.07,196.34 138.09,196.32 138.09,195.82 138.16,195.75 138.28,195.63 138.53,195.63 v2(139.24,195.21)
  IN3 w0.102: v2(162.5,202.02) 162.5,202.12 162.21,202.41 162.08,202.41 161.78,202.71 161.78,204.2 161.34,204.64 158.94,204.64 158.42,205.17 157.63,205.17 156.31,206.49 151.85,206.49 151.35,205.99 151.35,205.18 143.47,197.29 140.64,197.29 140.45,197.1 139.74,197.1 139.45,197.39
  BOTTOM w0.102: v2(139.24,195.21) 139.23,195.21 138.82,195.62 U8.U24 ; VRAM2.P5 162.9,202.42 v2(162.5,202.02)
VMA_WCK67: length 20
  IN3 w0.102: v2(154.5,203.63) 154.5,203.35 154.37,203.22 154.2,203.22 153.85,203.56 150.67,203.56 143.61,196.5 139.58,196.5 v2(139.22,196.87)
  BOTTOM w0.102: v2(154.5,203.63) 154.9,203.22 VRAM2.D4 ; U8.V24 v2(139.22,196.87)
VMA_WCK67#: length 19.9
  IN3 w0.102: v2(139.21,196.04) 139.49,196.31 143.68,196.31 150.75,203.37 153.77,203.37 154.12,203.03 154.26,203.03 v2(154.48,202.81)
  BOTTOM w0.102: v2(139.21,196.04) 139.21,196.37 139.31,196.47 U8.V25 ; VRAM2.D5 154.88,202.42 v2(154.48,202.81)
VQQD_VPPSNS: length 10.1
  TOP w0.203: PR5002.2 79.56,187.3 v1(79.05,187.8) 75.09,187.8 74.49,187.21 74.49,185.74 74.12,185.37 v1(73.41,185.37)
  BOTTOM w0.203: PU5000.12 v1(73.41,185.37)
VR_READY: length 5.5
  BOTTOM w0.203: PR7067.2 169.59,147.84 v1(169.4,147.65) 169.4,147.37 169.62,147.15 169.62,146.17 168.16,144.72 167.95,144.72 167.84,144.61 PU7000.38
VR_SVID_ALERT#_VCORE: length 54.1
  TOP w0.114: v1(166.93,150.16) 166.93,149.96 v1(167.32,149.58) 167.3,149.56 PR7002.2
  IN4 w0.089: v2(130.15,155.55) 130.69,155 135.51,155 136.45,155.94 137.06,155.94 137.56,155.44 138.53,155.44 139.3,154.67 139.3,150.08 140.11,149.26 140.11,148.23 140.8,147.54 150.48,147.54 150.58,147.63 156.08,147.63 156.59,147.12 156.96,147.12 159.79,144.29 160.41,144.29 160.85,144.73 160.85,145.24 161.62,146.02 163.65,146.02 164.2,146.57 164.2,147.69 165.94,149.43 165.94,149.73 166.13,149.93 166.97,149.93 v1(167.32,149.58)
  BOTTOM w0.114: R64.2 129.42,155.95 129.83,155.55 v2(130.15,155.55) 130.24,155.55 130.78,156.08 R63.1 ; v1(167.32,149.58) PR7020.2
VR_SVID_CLK_R: length 4.4
  BOTTOM w0.079: U1.AA1 125.07,153.84 125.99,154.77 R66.2
VRON: length 144.4
  TOP w0.114: v1(208.1,127.66) 207.66,127.66 207.2,127.2 207.2,127.08 v1(206.51,126.39) 206.12,126.01 202.62,126.01 200.85,124.23 200.85,119.91 200.18,119.24 200.18,116.87 200.18,112.44 200.84,111.78 200.84,109.75 199.7,108.61 199.7,106.87 200.35,106.22 200.35,104.39 199.13,103.16 199.13,98.32 196.11,95.31 174.91,95.31 173.64,96.59 172.02,96.59 171.51,97.09 170.32,97.09 170.21,97.21 R25311.1 169.07,97.21 168.8,97.48 168.8,97.69 167.95,98.54 167.95,98.57 167.78,98.74 U37.69
  IN3 w0.102: v1(208.1,127.66) 208.1,127.93 207.13,128.89 199.9,128.89 198.92,129.88 198.4,129.88 197.03,128.5 194.22,128.5 192.35,126.63 192.35,126.24 191.53,125.42 188.68,125.42 187.78,124.53 187.78,123.85 186.89,122.96 184.04,122.96 182.74,124.27 179.23,124.27 178.66,123.7 172.74,123.7 172.06,123.02 169.52,123.02 169.06,123.48 168.42,123.48 167.93,123.97 167.93,124.61 168.95,125.64 168.95,132.52 167.64,133.83 167.64,137.52 168.74,138.62 168.74,139.78 168.24,140.28 168.24,141.25 169.72,142.73 169.72,143.33 169.59,143.46 169.59,146.44 v1(168.67,147.36)
  BOTTOM w0.114: PR7025.2 168.96,147.07 v1(168.67,147.36)
VSEN_CORE: length 68.8
  TOP w0.114: v1(165.29,133.56) 166.92,133.56 168.91,135.56 169.36,135.56 170.23,136.43 v1(170.23,136.75) 170.23,137.66 169.95,137.95 v2(169.69,137.95) ; v1(141.38,158.52) 140.72,157.85 140.72,154.63 PR7044.2
  IN1 w0.089: v1(141.38,158.52) 141.76,158.9 149.33,158.9 151.45,161.02 152.37,161.02 153.33,160.06 153.33,158.66 154.13,157.86 155.79,157.86 156.71,156.94 156.71,156.37 157.24,155.85 157.24,154.58 156.71,154.06 156.71,149.07 159.1,146.68 159.1,144.67 160.58,143.19 160.96,143.19 161.15,143 161.15,140.77 161.89,140.03 164.86,140.03 165.12,139.78 165.12,138.45 166.2,137.37 167.53,137.37 168.16,136.74 168.48,136.74 v2(169.69,137.95)
  BOTTOM w0.114: PU7000.47 167.81,141.01 168.05,140.77 168.05,140.2 167.75,139.91 167.75,139.08 PC7008.2 168.31,138.52 PC7007.1 169.59,137.95 v2(169.69,137.95) ; PR7047.2 165.29,134.72 165.47,134.53 PC7010.1 165.47,133.75 v1(165.29,133.56)
VSEN_GT: length 53.7
  TOP w0.114: PC7013.1 162.91,145.86 PC7014.2 162.9,146.65 v1(162.79,146.76) 162.57,146.76 v1(162.22,147.1) ; v2(129.49,165.26) 129.08,165.26 PR7051.2
  IN4 w0.089: v1(162.22,147.1) 161.92,147.41 159.29,147.41 157.83,148.88 145.85,148.88 145.69,149.04 141.67,149.04 141.36,149.35 141.36,149.94 140.68,150.61 140.68,157.74 140.1,158.32 139.58,158.32 138.79,159.11 138.79,160.88 138.05,161.63 132.25,161.63 130.99,162.88 130.99,164.63 130.36,165.26 v2(129.49,165.26)
  BOTTOM w0.114: PU7000.27 162.7,146.63 v1(162.22,147.1) 161.88,147.44 PC7016.2 PR7054.2
VSEN_SA: length 36.1
  TOP w0.114: 169.78,141.82 169.78,141.52 v2(169.36,141.11) ; 169.78,141.82 169.65,141.69 PC7022.2 168.36,141.69 168.05,141.38 PC7019.1 ; 169.78,141.82 v1(169.78,141.83) ; PR7058.2 146.1,132.12 147.84,132.12 v1(148.28,132.56)
  IN4 w0.089: v1(148.28,132.56) 148.67,132.96 158.69,132.96 159.78,131.87 162.33,131.87 162.76,132.29 163.88,132.29 164.3,131.87 166.77,131.87 167.63,132.72 167.63,137.47 168.23,138.08 v2(168.23,139.54)
  BOTTOM w0.114: v2(168.23,139.54) 168.27,139.5 PR7059.2 169.03,139.51 PC7020.2 169.36,140.79 v2(169.36,141.11)
VSTBY_FSPI: length 12.1
  TOP w0.114: U37.106 161.76,112.07 162.06,112.37 162.23,112.37 162.45,112.59 163.58,112.59 163.87,112.89 163.87,113.42 164.61,114.16 166.06,114.16 166.79,114.89 167.96,114.89 v1(168.61,115.54) 168.9,115.83 R25330.2 R359.2
WIGIG_LED: length 3
  TOP w0.114: v1(190.08,122.99) 190.83,122.99 TP9029.1
  BOTTOM w0.114: v1(190.08,122.99) 190.67,122.4 CN17.6
WLAN_RST#: length 3.5
  BOTTOM w0.114: R2665.1 193.66,112.54 v4(193.28,112.16) 193.09,111.97 193.09,111.5 192.49,110.9 CN17.52
WRST#: length 15.4
  TOP w0.114: v1(145.35,103.09) 145.35,102.66 R25300.1 144.82,102.6 144.82,103.51 144.96,103.65 145.46,103.65 C6571.1 144.82,104.55 144.82,105.28 D63.2 ; v1(152.71,103.97) 152.33,104.34 U37.14
  IN3 w0.102: v1(152.71,103.97) 150.59,103.97 150.47,104.09 149.66,104.09 148.21,102.64 145.8,102.64 v1(145.35,103.09)
WRST#_8350: length 14.2
  TOP w0.079: 153.14,213.64 U6516.A2
  TOP w0.114: 153.14,213.64 152.81,213.64 152.41,213.24 v1(152.41,213.15)
  IN1 w0.089: v1(158.19,211.38) 157.76,211.38 155.5,213.65 152.9,213.65 v1(152.41,213.15)
  BOTTOM w0.114: v1(158.73,211.81) 158.62,211.81 v1(158.19,211.38) 157.72,211.38 R25633.2 157.26,212.1 156.81,212.56 C20142.1 156.44,213.21 155.26,213.21 D13093.2
XCLK_BIASREF: length 10.5
  BOTTOM w0.102: 124.86,122.22 124.75,122.22 124.32,122.64 124.32,124.29 123.82,124.79 123.1,124.79 U1.CJ1
  BOTTOM w0.114: 124.86,122.22 125.27,121.8 125.43,121.8 125.73,121.51 125.73,120.06 126.14,119.64 126.14,117.38 126.51,117.01 R145.1
XD_CD#: length 2
  BOTTOM w0.114: U40.7 32.04,62.61 32.5,63.08 TP99.1
XD_D7: length 3.4
  BOTTOM w0.114: TP96.1 24.27,62.46 25.46,62.46 25.81,62.11 U40.23
XDP_BPM0: length 11.2
  TOP w0.102: TP23.1 131,157.15 130.26,156.42 129.91,156.42 129.22,155.73 128.97,155.73 128.73,155.49 127.83,155.49 127.18,154.85 123.2,154.85 122.89,155.16 122.89,155.75 v2(123.39,156.25)
  BOTTOM w0.079: v2(123.39,156.25) 123.35,156.28 U1.U1
XDP_BPM1: length 8.4
  TOP w0.102: TP25.1 129.36,156.2 129.1,155.94 128.88,155.94 128.64,155.7 127.74,155.7 127.09,155.05 124.55,155.05 v2(124.1,155.49)
  BOTTOM w0.079: U1.U2 122.39,156.28 122.56,156.11 123.04,155.89 123.71,155.89 v2(124.1,155.49)
XDP_PRDY#_CPU: length 6.6
  BOTTOM w0.079: U1.W2 122.21,154.9 122.49,154.63 124.79,154.63 125.74,155.58 125.74,156.8 TP24.1
XDP_PREQ#_CPU: length 7.5
  BOTTOM w0.079: U1.W1 122.97,154.86 124.78,154.86 125.57,155.65 125.57,156.96 126.09,157.48 126.09,157.79 126.42,158.12 127.01,158.12 127.3,158.42
  BOTTOM w0.102: 127.3,158.42 127.48,158.59 TP22.1
XDP_TCK0: length 18.3
  TOP w0.102: v2(119.91,156.82) 120.27,156.46 120.74,156.46 120.85,156.34 122.44,156.34 122.95,156.86 125.77,156.86 125.99,156.63 127.25,156.63 127.68,157.06 127.68,157.64 127.35,157.98 126.82,157.98 126.47,158.33 126.47,159.28 126.81,159.63 127.21,159.63 127.3,159.53 127.85,159.53
  TOP w0.114: R7.2 130.87,159.73 TP52.1 130.1,159.02 129.8,159.32 R24.2 129.49,159.02 129.3,158.83 128.42,158.83 128.18,159.06 128.18,159.24 127.89,159.53 127.85,159.53
  BOTTOM w0.102: v2(119.91,156.82) 119.91,156.88 U1.T6
XDP_TDI_CPU: length 12.5
  TOP w0.102: R19.2 128.07,158.74 R3.2 128.12,158.19 128.12,157.21 127.34,156.43 125.91,156.43 125.69,156.65 123.13,156.65 122.55,156.07 120.84,156.07 120.65,156.25 119.64,156.25 v2(119.17,155.79)
  BOTTOM w0.102: U1.U6 119.52,156.11 119.22,155.82 119.2,155.82 v2(119.17,155.79)
XDP_TDO_CPU: length 12.9
  TOP w0.102: v2(120.4,155.01) 120.96,154.44 127.35,154.44 128,155.09 128.9,155.09 129.14,155.33 129.39,155.33 130.08,156.01 131,156.01 R4.2
  TOP w0.114: R4.2 131.49,156.11 131.6,156.22 R22.1
  BOTTOM w0.102: v2(120.4,155.01) 120.17,154.78 U1.Y5
XDP_TMS_CPU: length 15.7
  TOP w0.102: v2(120.5,156.84) 120.87,157.21 120.87,158.52 121.64,159.29 121.64,160.43 121.75,160.54 121.75,160.95 121.1,161.59 121.1,161.99 121.33,162.22 122.1,162.22 123.22,163.33 124.17,163.33 124.22,163.28 125.07,163.28
  TOP w0.114: 125.07,163.28 126.19,163.28 126.46,163.01 127.57,163.01 128.07,162.51 R5.2 128.3,162.34 128.73,161.91 R15.2
  BOTTOM w0.102: v2(120.5,156.84) 120.17,157.17 U1.T5
XDP_TRST#_CPU: length 13.3
  TOP w0.102: v2(120.36,154.04) 120.6,153.81 122.73,153.81 122.96,154.03 127.52,154.03 128.16,154.68 128.93,154.68 129.36,154.25 130.54,154.25 130.86,154.57 R25.2 131.11,154.71 131.35,154.94 R6.1
  BOTTOM w0.102: U1.Y6 119.98,154.04 v2(120.36,154.04)
XTAL1: length 6.2
  TOP w0.114: R511.1 27.85,169.06 v1(27.51,168.71) 25.43,168.71 23.72,167.01 U6521.9
XTAL2: length 6.8
  TOP w0.114: U6521.10 23.75,167.41 25.32,168.98 26.98,168.98 27.36,169.36 27.36,169.82 v1(27.61,170.08) R512.1
XTAL24_IN: length 8.5
  BOTTOM w0.079: U1.CK3 121.65,123.39 122,123.39 122.31,123.71 122.59,123.71 123.14,123.16 123.6,123.16 123.77,122.98 123.77,122.17
  BOTTOM w0.102: 124.35,119.04 124.35,120.76 123.77,121.34 123.77,122.17
  BOTTOM w0.114: R166.1 124.56,117.91 124.67,118.02 124.67,118.73 124.35,119.04
XTAL24_IN_C: length 4.1
  BOTTOM w0.114: Y2.1 124.92,114.55 125.25,114.88 125.25,115.01 C205.2 125.05,115.58 124.92,115.7 124.64,115.7 124.48,115.87 R167.1 124.86,116.56 124.86,117.01 124.74,117.13 R166.2
XTAL24_OUT: length 8.7
  BOTTOM w0.079: 124.49,121.06 123.97,121.57 123.97,123.59 123.56,124.01 123.35,124.01 123.07,124.3 122.55,124.3 122.12,123.87 U1.CK2
  BOTTOM w0.114: 124.49,121.06 124.74,120.8 124.74,119.56 125.32,118.98 R168.1
XTAL24_OUT_C: length 4.8
  BOTTOM w0.114: R168.2 125.32,116.24 R167.2 125.26,115.98 126,115.23 C208.2 125.63,114.84 125.63,113.7 126.12,113.2 Y2.3
XTAL_SSIN: length 5.2
  BOTTOM w0.102: U8.A10 127.2,182.35 126.87,182.02 126.87,181 125.95,180.08 125.52,180.08 124.81,179.38
  BOTTOM w0.114: 124.81,179.38 124.28,178.85 R331.1
N15767591: length 1
  TOP w0.508: R25614.2 55.68,121.03 C20130.2
N16244674: length 2.3
  TOP w0.114: R1616.2 29.95,148.82 v1(29.95,149.32) 30.08,149.45 U67.28
N16251939: length 4.4
  TOP w0.114: U6521.46 21.39,161.49 21.78,161.1 21.78,160.31 v1(21.36,159.89) 21.36,159.11 R67598.1
N16251941: length 2.4
  TOP w0.114: R67599.1 22.28,161.31 v1(22.03,161.57) 21.79,161.8 U6521.47
N16390345: length 2
  TOP w0.114: C266.2 45.04,119.15 v1(44.96,119.07)
  TOP w0.508: R244.2 46.02,119.99 45.06,119.99 C266.2
N16485113: length 4.2
  BOTTOM w0.114: C96328.2 3.1,53.71 R67583.2 4.05,51.82 U6523.11 3.17,50.93 v1(3.05,51.05)
N16485177: length 2.7
  BOTTOM w0.114: R67582.2 3.1,43.35 v1(3.48,42.97) 3.67,43.16 Q6562.3
N16485185: length 15.3
  IN1 w0.089: v1(3.92,44.87) 3.87,44.87 2.76,45.98 2.76,52.48 3.44,53.17 v1(4.81,53.17)
  BOTTOM w0.114: U6523.13 5.4,53.13 5.47,53.2 R67851.1 5.12,53.83 4.81,53.51 v1(4.81,53.17) ; R67582.1 3.47,44.87 v1(3.92,44.87) 3.97,44.83 v1(3.97,44.19)
N16485221: length 2.4
  BOTTOM w0.114: C96332.1 4.17,53.57 v1(4.17,52.85) 4.28,52.85 4.9,52.24 U6523.12
N16485697: length 1.7
  BOTTOM w0.114: v1(11.08,44.8) 11.08,45.49 R67593.1 R67594.2
N16502093: length 2.3
  BOTTOM w0.114: R67586.1 5.9,53.24 v1(5.9,52.85) U6523.14
N16722265: length 9.5
  BOTTOM w0.114: Q6566.3 22.47,42.05 22.23,42.3 17.52,42.3 v1(17.45,42.24) 17.43,42.21 R67601.1 16.44,41.84 16.08,41.48 R67600.1
N16821711: length 2
  TOP w0.203: PR5002.1 81.2,186.85 81.39,186.66 81.4,186.66 81.48,186.58 v1(81.48,186.08) v1(81.97,185.59)
N16826936: length 8.4
  BOTTOM w0.114: R323.2 R324.2 121.42,210.16 122.12,209.47 123.17,209.47 123.41,209.71 123.91,209.71 125.1,210.9 125.83,210.9 126.11,211.17 v1(126.47,211.17) 126.75,210.9 126.97,210.9 127.14,210.72 U11.2
N17011327: length 1.7
  BOTTOM w0.203: U20.39 18.21,36.11 18.01,36.31 18.01,36.97 C572.2
N17011330: length 3.1
  BOTTOM w0.102: C566.2 15.03,35.33 15.92,35.33 16.27,35.68 16.86,35.68 17.03,35.51 U20.37
N17011339: length 16.8
  IN1 w0.089: v1(15.45,34.32) 19.21,34.32 19.86,34.97 19.86,38.12 19.13,38.85 15.38,38.85 14.8,39.43 v1(14.8,39.61)
  BOTTOM w0.102: U20.34 15.87,33.81 15.45,34.22 v1(15.45,34.32)
  BOTTOM w0.114: C567.1 15.03,39.39 v1(14.8,39.61) 14.53,39.35 v1(14.53,39.01)
N17011340: length 3.3
  BOTTOM w0.203: 19.39,28.35 19.39,28.42 19.41,28.44 U20.19
  BOTTOM w0.254: 19.39,28.35 19.03,27.99 v1(19.03,27.23) 19.03,27.04 C573.1
N17011365: length 4.9
  BOTTOM w0.102: R454.2 24.37,37.1 v1(24.54,36.93) 24.54,36.42 24.04,35.91 22.47,35.91 22.29,36.09 21.97,36.09 21.81,35.93 U20.48
N17011431: length 6.3
  BOTTOM w0.114: C578.1 28.24,31.88 27.98,32.15 26.97,32.15 v1(26.85,32.03) 26.84,32.02 25.27,32.02 24.74,32.55 23.53,32.55 23.23,32.25 22.76,32.25 U20.7
N17011437: length 3.8
  BOTTOM w0.114: R738.2 25.62,29.92 23.88,29.92 23.19,30.61 U20.11
N17011447: length 3.5
  BOTTOM w0.102: U20.12 23.16,30.21 23.42,29.94
  BOTTOM w0.114: 23.42,29.94 24.11,29.26 24.11,28.88 v1(24.44,28.55) 24.56,28.67 C846.1
N17011480: length 2.4
  BOTTOM w0.102: C566.1 15.01,34.79 15.64,34.79 15.86,34.58 15.86,34.29 15.95,34.21 U20.35
N17061276: length 2.6
  BOTTOM w0.114: PR13.1 109.66,104.76 109.62,104.72 v1(109.62,104.47) PJ1.3
N17061293:
  vias: v1(75.47,201.11)
N17061294: length 1.9
  BOTTOM w0.152: PR5.1 156.59,116.4 156.59,116.58 156.73,116.72 157.29,116.72 157.49,116.93 PU1.20
N17061299: length 1.4
  BOTTOM w0.152: PR6.1 157.27,116.25 157.53,116.51 157.53,116.53 157.89,116.89 PU1.19
N17061317: length 2.8
  BOTTOM w0.114: PR14.1 105.78,105.34 v1(105.78,104.48) 105.62,104.32 PJ1.5
N17061319: length 3.2
  TOP w0.102: PR209.1 139.17,114.2 139.04,114.06
  TOP w0.114: PR210.1 139.25,111.88 139.04,112.1 139.04,114.06
  vias: v1(144.88,114.35) v3(139.54,118.16) v3(139.92,119.34) v3(140.21,118.52) v3(140.21,117.75) v3(140.68,119.34) v3(140.98,118.52) v3(140.98,117.75) v3(141.74,118.52) v3(141.74,117.75)
N17061327: length 160.3
  TOP w0.114: v1(161.98,124.99) 161.67,124.68 v1(161.67,124.39) ; 74.03,198.46 74.03,200 PQ9054.4 ; 74.03,198.46 v1(74.73,199.16) ; 74.03,198.46 PC2.2 ; v1(68.25,199.46) 68.73,199.94 PC1.2 68.95,199.9 PQ1.4
  IN3 w0.102: v1(68.25,199.46) 74.55,199.46 74.73,199.29 v1(74.73,199.16) 74.45,198.88 74.45,197.94 74.72,197.67 76.46,197.67 78.48,199.69 90.12,199.69 90.87,198.95 90.87,192.88 94.73,189.01 97.66,189.01 99.51,187.17 101.91,187.17 103.96,185.11 105.18,185.11 106.36,183.93 110.95,183.93 111.22,184.2 114.97,184.2 115.76,183.4 115.76,176.87 122.13,170.5 123.34,170.5 125.8,168.04 125.8,164.06 127.06,162.8 128.51,162.8 129.9,161.41 129.9,159.38 131.67,157.62 131.67,156.3 132.81,155.16 135.88,155.16 136.36,155.64 137.38,155.64 139.55,153.46 139.55,149.54 140.42,148.67 140.42,132.66 141.67,131.42 146.26,131.42 147.81,129.87 147.81,129.12 149.89,127.04 149.89,125.27 151.14,124.02 156.74,124.02 157.16,123.6 160.87,123.6 v1(161.67,124.39)
  BOTTOM w0.114: v1(161.67,124.39) 161.79,124.28 161.79,123.29 PR29.1
N17061416: length 3.1
  BOTTOM w0.508: PC19.1 152.82,113.89 v1(151.72,113.89) 150.75,113.89 150.37,113.51 PR33.2
N17061438: length 2.8
  TOP w0.114: v1(153.14,118.41) 152.84,118.71 PR11.2
  TOP w0.508: PR11.2 152.84,120.19 152.69,120.34 PC15.2
N17061451: length 2.6
  BOTTOM w0.114: PJ1.4 107.62,104.52 v1(107.6,104.54) 107.6,104.57 107.62,104.59 PR12.1
N17061494: length 4
  TOP w0.508: PQ2.4 149.19,120.33 v1(150.02,119.5) 150.02,119.12 149.66,118.77 PR4.1 148.62,118.48 PC17.2
N17070212: length 3
  BOTTOM w0.114: PQ7.2 134.58,130.89 134.82,131.13 PR9258.2 PR9272.1 136.36,131.79 v1(136.3,131.85)
N17072870:
  vias: v1(164.21,162.05) v3(164.23,165.82) v3(164.23,165.06) v3(164.23,164.3) v3(164.23,163.53) v3(164.23,162.77) v3(165,165.82) v3(165,165.06) v3(165,164.3) v3(165,163.53) v3(165,162.77) v3(165,162.01)
N17073105: length 21.2
  TOP w0.203: v2(167.21,166.09) 167.52,166.39 167.52,167.1 167.39,167.22 PR9263.2
  IN1 w0.203: v2(167.21,166.09) 166.53,165.41 166.53,160.42 168.1,158.86 168.1,156.85 168.83,156.12 168.83,155.59 169.89,154.54 169.89,153.72 171.32,152.29 v2(171.32,151.61)
  BOTTOM w0.203: PC9089.2 PR9094.1 171.26,150.91 v1(171.3,150.87) 171.32,150.89 v2(171.32,151.61)
N17074882:
  vias: v1(97.49,193.93)
N17074965: length 2.8
  TOP w0.114: v1(39.12,132.23) 38.37,132.98 PJ9005.2
N17184837: length 4.3
  BOTTOM w0.114: R735.1 24.54,25.14 D11.1 23.96,25.14 23.52,24.71 v1(23.35,24.71) 23.04,24.71 22.87,24.54 D6543.1
N17326408: length 167.2
  TOP w0.114: v1(55.49,204.22) 55.7,204.43 PR230.1 PR235.2 ; PR9276.2 159.69,123.03 158.01,123.03 v1(157.79,122.81) 157.27,122.81 v1(156.82,122.36)
  TOP w0.254: PR9276.2 159.84,122.53 160.06,122.31 PQ17.2
  IN3 w0.102: v1(156.82,122.36) 155.39,123.79 151.05,123.79 149.66,125.18 149.66,126.94 147.76,128.85 146.39,128.85 145.64,129.6 145.64,129.98 145.44,130.17 143.05,130.17 142.72,130.5 142.72,130.9 142.44,131.19 141.57,131.19 140.19,132.57 140.19,144.29 139.35,145.13 137.89,145.13 130.52,152.51 130.52,153.94 126.31,158.14 126.31,162.58 124.37,164.52 124.37,165.33 122.14,167.56 122.14,169.52 113.39,178.27 113.39,179.67 112.25,180.81 111.23,180.81 109.04,183.01 107.52,183.01 106.95,182.44 105.66,182.44 101.62,186.48 99.22,186.48 98.53,187.17 96.58,187.17 96.41,187 94.36,187 94.08,187.27 94.08,189.34 90.64,192.78 90.64,197.64 88.94,199.34 78.46,199.34 76.56,197.44 74.62,197.44 73.11,198.95 62.15,198.95 60.71,197.51 57.13,197.51 55.49,199.15 v1(55.49,204.22)
N17412621: length 5.3
  TOP w0.152: PR30.2 160.53,121.52 160.89,121.88 v1(160.89,122.3)
  BOTTOM w0.152: v1(160.89,122.3) 160.53,122.3 160.46,122.24 159.12,122.24 158.69,121.81 PU1.5
N17419587: length 16.8
  TOP w0.254: v1(54.48,199.73) 54.81,200.06 PQ8003.3 55.54,199.77 55.54,197.33 PR8008.1 PR8002.2 ; v1(61.53,197.2) 61.75,197.2 v1(62.11,197.56) 62.11,197.84 62,197.95 PC8003.2 61.9,198.72 PQ8001.4
  IN3 w0.254: v1(61.53,197.2) 57.01,197.2 v1(54.48,199.73)
N17419880: length 8.5
  TOP w0.254: v1(30.89,102.06) v1(30.89,101.39) 30.89,101.15 PQ8004.3
  IN2 w0.254: v1(30.89,102.06) 32.41,102.06 33.98,103.62 v1(33.98,104.18)
N17421868: length 2.5
  TOP w0.114: PR8022.1 25.72,102.81 26.23,102.29 PQ8012.3
N17421870: length 17.2
  TOP w0.114: PQ8006.4 36.92,114.41 36.59,114.08 36.59,112.97 36.45,112.83 36.45,108.72 36.16,108.44 35.53,108.44 35.22,108.13 34.16,108.13 33.14,107.11 32.47,107.11 31.23,105.87 31.23,104.65 v1(30.86,104.29) 30.86,103.79 PR8000.2 30.4,103.59 PQ8012.6
N17421874: length 2.9
  TOP w0.114: PQ8012.5 PQ8012.2 26.58,102.94 PR8031.1
N17421890: length 186
  TOP w0.114: PQ8010.2 80.03,190.44 79.96,190.37 PD8001.2 80.21,189.08 v1(81.16,188.13) 81.97,187.32 PR8023.2 ; v1(28.38,100.63) 28.38,100.46 27.78,99.87 27.24,99.87 26.99,99.62 26.99,98.59 v1(27.13,98.45) 27.23,98.35 PQ8009.2
  IN4 w0.089: v1(81.16,188.13) 81.16,188.41 82.13,189.38 86.2,189.38 89.68,192.86 89.68,198.22 87.3,200.59 72,200.59 69.9,198.5 66.4,198.5 62.13,194.23 61.2,194.23 59.4,192.43 57.75,192.43 55.84,190.52 50.94,190.52 47.24,186.82 44.24,186.82 41.65,184.23 41.65,180.77 40.14,179.26 30.76,179.26 27.92,176.42 27.92,169.61 26.32,168.02 26.32,165.02 24.22,162.92 24.22,158.68 22.66,157.12 22.66,153.95 23.68,152.93 23.68,149.69 25.28,148.09 25.28,147.35 24.76,146.84 24.76,142.26 27.54,139.48 27.54,135.25 25.91,133.61 25.91,131.42 26.81,130.52 26.81,129.63 27.83,128.61 27.83,124.67 26.1,122.94 26.1,118.68 25.49,118.08 25.49,114.52 27.44,112.57 27.44,111.07 28.15,110.36 28.15,109.79 25.71,107.35 25.71,104.72 28.38,102.06 v1(28.38,100.63)
N17421892: length 1.8
  TOP w0.114: PQ8013.3 87.21,190.07 v1(87.48,190.34) 87.62,190.49 PR8024.1
N17421946: length 2.9
  TOP w0.114: PQ8013.5 PQ8013.2 87.63,188.95 88.18,189.5 PR8032.1
N17421950: length 24.5
  TOP w0.114: PQ8007.4 68.04,200.09 v1(68.18,200.23) ; v1(80.58,191.67) 80.84,191.41 80.84,190.5 81.21,190.13 81.21,189.87 81.47,189.6 81.86,189.6 82.02,189.75 83.07,189.75 PR8030.2 83.84,189.32 84.47,189.32 84.64,189.15 84.64,188.97 85.31,188.3 PQ8013.6
  IN2 w0.102: v1(68.18,200.23) 68.37,200.23 71.91,196.69 73.63,196.69 79.09,191.23 80.14,191.23 v1(80.58,191.67)
N17421954: length 3.7
  TOP w0.114: PQ8013.1 86.56,188.3 86.15,187.89 85.08,187.89 84.92,188.05 84.92,188.31 84.39,188.85 PR9278.1
N17421956: length 5.1
  TOP w0.114: PQ8013.4 84.52,189.6 v1(84.33,189.79) 84.1,189.79 83.7,190.19 83.7,190.98 83.25,191.44 82.43,191.44 PQ8010.1
N17422036: length 6.7
  TOP w0.114: PQ8012.4 29.33,102.09 31.37,100.05 31.51,100.05 32.02,99.55 32.02,98.99 v1(31.3,98.27) 31.22,98.35 PQ8009.1
N17423044: length 8.2
  TOP w0.114: PR9277.2 39.26,102.11 39.03,102.34 37.67,102.34 37.34,102.01 37.34,100.75 37.19,100.61 36.83,100.61 36.55,100.33 36.55,99.03 36.34,98.82 35.9,98.82 ; 35.9,98.82 36.55,98.17 v1(36.55,97.91) ; 35.9,98.82 PQ8005.6
N17423573: length 1.8
  TOP w0.114: PR9279.2 28.9,104.33 28.16,103.59 PQ8012.1
N17424509: length 22
  TOP w0.114: v1(79.91,191.7) 80.98,192.77 PQ8010.3 80.98,193.82 v1(80.9,193.9) ; PR9280.1 v1(68.91,203.98)
  IN2 w0.102: v1(68.91,203.98) 70.58,202.32 70.58,198.35 72,196.92 73.73,196.92 78.94,191.7 v1(79.91,191.7)
N17424572: length 3.7
  TOP w0.114: PR9281.1 26.34,101.91 27.74,101.91 v1(28.3,101.34) 28.32,101.34 29.2,100.47 PQ8009.3
N17424918: length 3
  BOTTOM w0.152: PU1.11 161.12,119.35 162.23,118.24 162.23,118.07 PR19.2
N17424920: length 3.4
  BOTTOM w0.152: PR17.2 162.52,117.22 161.98,117.76 161.98,118.13 161.16,118.95 PU1.12
N17424921: length 2.5
  BOTTOM w0.152: PR32.2 162,121.32 v1(161.31,121.32) 161.28,121.35 PU1.7
N17424925: length 2.4
  BOTTOM w0.152: PU1.9 162.2,120.15 PR25.2
N17424950: length 2.5
  BOTTOM w0.152: PU1.15 160.14,117.35 160.6,116.89 PR205.2 161.14,116.89 161.33,117.09 PR8.2
N17661815: length 1.7
  BOTTOM w0.152: PR26.2 161.66,120.6 161.62,120.55 PU1.8
N17699210: length 7.3
  TOP w0.508: HE1.2 149.25,212.42 149.69,211.98 150.93,211.98 C842.1 v1(151.92,211.94) 151.92,210.65 D13092.2 R25519.2
N18453595: length 14.3
  TOP w0.114: v1(221.22,107.57) 221.41,107.57 v1(222.1,106.88) 221.23,106.88 R67866.1
  BOTTOM w0.114: CN11.13 230.64,104.01 226.42,108.23 222.76,108.23 222.11,107.57 v1(221.22,107.57)
N18723876:
  vias: v1(24.3,190.58) v1(24.96,190.62) v1(25.43,184.83)
N18867651:
  vias: v1(203.15,130.07)
N18867812:
  vias: v1(33.48,160.93)
N18922914: length 1.2
  BOTTOM w0.381: U8.AA9 126.39,199.01 v2(126,199.39) U8.AA8
  vias: v1(123.29,197.79)
N19138106: length 1.5
  TOP w0.102: v2(136.82,186.08) 136.76,186.08 136.21,186.63 R321.2
  BOTTOM w0.102: U8.F22 137.12,186.37 v2(136.82,186.08)
N19138109: length 2.2
  TOP w0.102: R322.2 136.32,189.2 136.5,189.02 136.96,189.02 137.37,188.61 v2(137.6,188.61)
  BOTTOM w0.102: v2(137.6,188.61) U8.J22
N19509659: length 1
  TOP w0.254: R25378.2 109.05,115.19 R25381.1
N19510593: length 1.3
  TOP w0.254: R25382.1 110.02,113.4 110.37,113.05 R25379.2
N19521323: length 3.1
  BOTTOM w0.203: PQ6000.3 170.9,129.05 171.35,128.6 172.47,128.6 v1(172.49,128.62) 172.55,128.67 PR6006.1
N19521733: length 3.9
  BOTTOM w0.114: PR6012.1 170.91,132.77 v1(170.51,133.17)
  BOTTOM w0.254: PQ6000.2 169.19,131.27 PR9269.2 PR9268.2 170.64,132.03 PR6012.1
N19549602: length 6.8
  BOTTOM w0.114: v1(60.56,188.16) 60.44,188.04 PQ6001.2
  BOTTOM w0.203: PR9270.2 59.74,183.62 PR6024.1 59.74,186.35 59.9,186.52 59.9,186.59 60.36,187.05 PQ6001.2 61.38,187.05 PR9271.2
N19634328: length 23.5
  TOP w0.114: U37.83 167.82,104.34 v1(168.23,104.75) ; v1(183.35,102.05) 183.25,102.15 v1(182.68,102.15) 182.45,101.92 182.45,101.72 181.87,101.14 181.87,100.83 182.12,100.58 R67886.1 182.51,100.92 182.65,101.06 183.84,101.06 R67885.1
  IN1 w0.089: v1(168.23,104.75) 168.71,104.26 169.33,104.26 170.62,102.97 170.62,102.29 170.76,102.15 183.25,102.15 v1(183.35,102.05)
N20380930: length 1.4
  TOP w0.102: v2(106.84,132.08) 107.04,131.88 R44.2
  BOTTOM w0.079: v2(106.84,132.08) 106.79,132.08 106.48,132.39 U1.BT27
N20513971: length 0.9
  BOTTOM w0.114: TP54.1 118.35,98.55 R220.2
N20681162: length 21.2
  TOP w0.079: 100.74,130.15 102.07,130.15 102.6,129.62 103.09,129.62 v2(103.4,129.31)
  TOP w0.114: R25494.2 86.32,124.98 v1(86.49,125.14) 87.58,125.14 88.53,126.09 91.42,126.09 92.32,126.99 93.48,126.99 93.99,127.5 95.67,127.5 98.58,130.42 100.47,130.42 100.74,130.15
  BOTTOM w0.079: U1.BY31 103.85,129.75 v2(103.4,129.31)
N20910893: length 5.8
  BOTTOM w0.114: R67539.1 29.13,55.53 29.26,55.39 30.23,55.39 30.48,55.14 30.48,52.85 Q6565.2 30.98,52.74 31.07,52.83 R67865.2
N20911229: length 2.8
  BOTTOM w0.114: Q6570.2 32.84,55.92 32.02,55.11 R67887.1 R67888.2
N21094013: length 2
  BOTTOM w0.114: R67891.2 20.22,53.76 20.22,53.46 20.52,53.16 U6511.3
N21094016: length 2.1
  BOTTOM w0.114: U6511.4 21.02,53.04 20.49,53.57 20.49,53.72 R67892.2
N21094286: length 1.7
  BOTTOM w0.114: U6511.28 20.52,45.12 R67893.2
N21094358: length 1.5
  BOTTOM w0.114: R67894.2 19.94,45.41 20.02,45.49 U6511.29
N21263014: length 18.6
  TOP w0.102: v2(126.79,185.28) 126.79,185.15 126.41,184.76 126.41,183.99 125.63,183.21 123.68,183.21
  TOP w0.114: TP65.1 113.23,179.22 114.27,180.25 114.66,180.25 115.29,179.63 115.58,179.63 116.81,180.85 120.47,180.85 122.83,183.21 123.68,183.21
  BOTTOM w0.102: U8.E10 127.17,185.65 v2(126.79,185.28)
N21263017: length 21.4
  TOP w0.102: 125.76,182.94 123.94,182.94
  TOP w0.114: 123.94,182.94 122.94,182.94 120.58,180.59 116.92,180.59 115.67,179.33 114.61,179.33 114.1,178.83 113.31,178.83 113.01,178.52 111.46,178.52 TP66.1 ; 125.76,182.94 126.04,183.22 126.4,183.22 127.26,184.08 127.26,185.56 v2(126.77,186.05)
  BOTTOM w0.102: U8.F10 127.2,186.48 v2(126.77,186.05)
N22233972: length 4.9
  TOP w0.114: PR7001.1 165.42,148.05 v1(165.41,148.05)
  TOP w0.381: PR7001.1 167.3,148.05 PR7002.1 167.32,148.04 PR7003.1 168.29,148.04 169.22,148.04 PC7001.1 169.27,148.1 PR7102.1
N22317721:
  vias: v1(32.62,45.51) v1(33.49,44.9) v1(33.49,44.24) v1(33.78,45.52)
N22358547: length 3.4
  TOP w0.114: v1(218.21,102.74) 217.16,102.74 F2.2
  TOP w0.508: F2.2 217.1,102.02 v1(216.85,101.77)
  BOTTOM w0.254: v1(216.85,101.77) 217.4,101.22 CN53.10
N22430724: length 18.2
  TOP w0.508: v1(138.33,128.54) 139.97,128.54 141.1,127.42 142.91,127.42 v1(143.37,126.95) PQ25.2
  BOTTOM w0.508: PQ10.2 133.39,131.32 133.39,130.54 132.88,130.03 PQ7.3 135.28,129.81 135.74,129.36 136.77,129.36 PR80.1 137.6,130.19 PR79.2 139.04,129.25 v1(138.33,128.54)
N22430737: length 2.9
  TOP w0.508: PR105.2 v1(135.58,132.62)
  BOTTOM w0.114: v1(136.12,133.12) 136.08,133.12 v1(135.58,132.62)
  BOTTOM w0.508: v1(135.58,132.62) 135.32,132.89 PQ10.3
N22430755:
  vias: v1(135.54,117.09) v3(135.57,118.58) v3(135.57,117.81) v3(136.33,118.58) v3(136.33,117.81) v3(137.1,118.58) v3(137.1,117.81) v3(137.86,118.58) v3(137.86,117.81) v3(138.62,118.58) v3(138.62,117.81)
N22430839: length 21.8
  TOP w0.203: PR9259.2 136.29,127.72 v1(136.93,128.35)
  IN2 w0.203: v1(150.07,123.28) 149.71,123.28 149.37,123.61 148.45,123.61 147.89,124.17 147.89,124.93 145.17,127.65 140.7,127.65 139.2,129.15 137.72,129.15 v1(136.93,128.35)
  BOTTOM w0.114: v1(136.25,128.34) 136.91,128.34 v1(136.93,128.35)
  BOTTOM w0.203: v1(150.07,123.28) 149.75,123.28 149.36,123.67 PC225.2 PR269.1
N22430843: length 1.4
  BOTTOM w0.508: PR99.2 PC82.1
N22430851: length 2.5
  BOTTOM w0.508: PC235.2 140.79,129.05 PR277.1 141.8,129.7 v1(141.46,130.04)
N22573697: length 8.7
  BOTTOM w0.079: U1.CP6 119.77,121.61 120.24,121.13 120.24,120.7 120.27,120.67 120.27,119.83 120.53,119.57
  BOTTOM w0.102: 120.53,119.57 120.69,119.41 120.69,118.41
  BOTTOM w0.114: R25448.1 120.6,114.65 120.72,114.78 v1(120.73,114.78) 120.69,114.82 120.69,118.41
N22767382: length 13.6
  TOP w0.114: R84.2 89.39,130.2 v1(89.49,130.3) 89.51,130.32 92.45,130.32 92.77,130.64 94.71,130.64 95.5,131.42 v1(95.5,131.95)
  BOTTOM w0.079: v1(95.5,131.95) 96.8,131.95 98.21,133.35 U1.BP36
N22907784: length 2.5
  TOP w0.114: CN62.1 33.64,34.68 v1(33.07,35.25)
  BOTTOM w0.114: R67895.2 32.99,35.33 v1(33.07,35.25)
N22907880: length 2.5
  TOP w0.114: v1(33.19,37.59) 33.6,37.18 CN62.2
  BOTTOM w0.114: v1(33.19,37.59) 33.16,37.61 R67896.2
N22907920: length 2
  TOP w0.114: v1(33.48,50.92) 33.48,51 33.66,51.18 CN62.8
  BOTTOM w0.114: R67897.2 33.46,50.51 33.46,50.87 33.48,50.9 v1(33.48,50.92)
N22907953: length 2.5
  TOP w0.114: v1(33.45,52.6) 33.52,52.68 CN62.9
  BOTTOM w0.114: R67898.2 32.75,51.91 v1(33.45,52.6)
N22907986: length 2.4
  TOP w0.114: v1(33.07,40.03) 33.43,39.68 CN62.3
  BOTTOM w0.114: R67899.2 v1(33.07,40.03)
N24359231: length 1.8
  TOP w0.114: v1(156.98,142.64) 156.29,142.64 v1(156.26,142.67)
  TOP w0.508: v1(156.26,142.67) 155.78,143.15 PC7056.2
N24359390: length 1.1
  BOTTOM w0.114: PR7078.1 157.4,143.33 v1(158.27,143.33)
N24444747: length 32.7
  TOP w0.203: v1(158.24,149.26) PR7018.1 158.24,148.6 PR7017.2 158.24,147.14 158.05,146.95 PR7031.1
  IN1 w0.203: v1(158.24,149.26) 158.44,149.46 158.44,150.13 160.13,151.82 160.13,157.18 159.45,157.86 157.55,157.86 156.86,158.55 156.86,163.6 155.66,164.8 155.66,166.57 154.62,167.62 v1(151.49,167.62)
  BOTTOM w0.203: PR7021.2 148.71,168.29 149.26,168.83 151.26,168.83 v1(151.69,168.4) 151.69,167.83 v1(151.49,167.62)
N24444757: length 2.3
  BOTTOM w0.114: v1(172.19,136.75) 171.6,136.75 PC7023.1
  BOTTOM w0.203: PC7023.1 171.05,137.03 PR7063.2
N24445360: length 2.8
  BOTTOM w0.203: PR7025.1 168.51,146.33 168.61,146.22 PC7005.1 168.61,145.69 168.52,145.6 168.52,145.58 168.23,145.29 167.87,145.29 167.59,145.01 PU7000.37
N24445593: length 4.7
  BOTTOM w0.203: PU7000.8 163.5,139.03 163.11,138.65 163.11,138.01 PR7066.2 163.74,137.43 164.25,136.91 164.25,135.75 PR7069.2
N24445614: length 24.1
  TOP w0.114: v1(161.47,136.78) 161.47,137.27 v1(161.27,137.46)
  IN3 w0.203: v1(156.75,154.66) 156.6,154.51 156.6,149.49 159.13,146.95 159.13,145.31 160.13,144.32 160.27,144.32 161.01,143.57 161.01,140.34 161.59,139.76 161.59,138.59 161.27,138.27 v1(161.27,137.46)
  BOTTOM w0.203: v1(156.75,154.66) 156.7,154.66 PR7032.2 ; v1(161.27,137.46) 160.77,136.96 PR7030.1 PR7016.2 159.81,137.28 160.19,137.67 PR7026.1
N24446268: length 2
  TOP w0.114: v1(162.03,135.63) 162.46,135.63 PR7038.1
  TOP w0.203: PR7038.1 162.93,136.11 PR7037.2
N24459302: length 35.7
  TOP w0.203: v2(161.76,138.08) 161.76,139.08 PR7076.1
  IN3 w0.203: v1(144.5,154.84) 144.67,154.67 145.1,154.67 145.53,154.24 145.53,151.19 149.12,147.6 155.52,147.6 158.08,145.03 158.08,144.19 159.38,142.89 159.38,139.67 158.86,139.15 158.86,138.56 160.77,136.65 161.91,136.65 162.42,137.16 162.42,137.74 162.29,137.87 161.97,137.87 v2(161.76,138.08)
  BOTTOM w0.203: PR7073.2 144.67,154.67 v1(144.5,154.84)
N24492000: length 1.2
  BOTTOM w0.203: PR7049.1 166.62,134.84 PC7012.1
N24507636:
  vias: v1(9.35,41.7)
N24507642: length 4.1
  BOTTOM w0.114: PU3003.6 3.49,35.59 3.27,35.81 3.27,36.04 PR283.1 4.02,37.25 4.09,37.33 PR6418.2 PC9097.1
N24507664: length 2.2
  BOTTOM w0.114: PR6418.1 PC9097.2 5.36,38.8 5.57,39.01 PR6414.1
N24507676: length 10.6
  IN1 w0.089: v1(5.57,35.32) 4.82,36.06 v1(4.82,41.47)
  BOTTOM w0.114: v1(4.82,41.47) 5.37,40.92 PC6229.2 4.51,40.72 PR6417.2 ; v1(5.57,35.32) 5.85,35.59 PU3003.1 6.64,36.29 v1(6.53,36.39)
N24507691: length 4.1
  BOTTOM w0.114: v1(2.9,34.64) PU3003.5 4.65,34.64 4.9,34.39 4.9,33.27 4.57,32.93 4.57,32.58 PR284.2
N24515156: length 1.9
  BOTTOM w0.114: v1(158.37,145.08) 158.35,145.11 PC7018.1
  BOTTOM w0.203: PC7018.1 PR7056.1
N24602110: length 48.6
  IN1 w0.203: v1(168.17,135.68) 167.98,135.49 167.35,135.49 166.27,136.57 160.57,136.57 158.79,138.36 158.79,142.81 158.01,143.58 158.01,145.16 153.76,149.41 141.7,149.41 139.86,151.25 139.86,157.06 139.81,157.11 v1(139.81,157.62)
  BOTTOM w0.203: v1(167.49,135.71) 167.52,135.68 v1(168.17,135.68) 168.04,135.81 PR7014.1 168.16,136.67 168.55,136.67 168.64,136.77 PR7013.2 ; PR7007.2 140.1,157.32 v1(139.81,157.62)
N24622727: length 43.5
  TOP w0.114: v1(159.57,149.88) 159.73,149.72 v1(160.28,149.72)
  TOP w0.203: PR7099.2 160.18,149 PR7100.1 160.18,149.61 v1(160.28,149.72)
  IN3 w0.203: v1(160.28,149.72) 160,149.72 159.34,150.38 159.34,150.83 160.55,152.04 160.55,157.32 159.71,158.17 157.68,158.17 157.41,158.44 157.41,163.85 155.76,165.51 155.76,166.88 153.58,169.06 139.59,169.06 139.13,169.52 v1(137.97,169.52)
  BOTTOM w0.203: PR7101.1 v1(137.97,169.52)
