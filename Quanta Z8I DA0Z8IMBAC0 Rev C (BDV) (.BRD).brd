# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCT2: length 3.5
  TOP w0.114: v1(35.23,187.47) v1(35.23,186.74)
  TOP w0.508: R517.2 35.23,185.94 v1(35.23,186.74)
  BOTTOM w0.508: U25.21 35,186.97 v1(35.23,186.74)
MCT3: length 4.1
  TOP w0.114: v1(33.43,185.7) 32.18,185.7 R518.2
  TOP w0.508: v1(32,186.97) 32,185.87 R518.2
  BOTTOM w0.508: U25.18 v1(32,186.97)
MCT4: length 4.4
  TOP w0.114: v1(28.25,186.08) 28.38,186.2 28.38,186.7 28.5,186.82 v1(29,186.82)
  TOP w0.508: R519.2 29.63,185.81 29,186.44 v1(29,186.82)
  BOTTOM w0.508: U25.15 v1(29,186.82)
MDI0+: length 29.1
  TOP w0.089: v1(23.26,170.18) 23.02,170.42 22.69,170.42 22.13,169.86 22.13,169.74 22.19,169.67 U6521.13
  BOTTOM w0.089: U25.9 30,178.56 30.37,178.2 30.37,177.79 30.25,177.67 28.46,177.67 28.08,177.29 28.08,176.82 29.25,175.66 29.25,175.44 28.77,174.96 28.53,174.96 27.26,176.23 26.65,176.23 26.26,175.84 26.26,175.49 27.14,174.61 27.14,174.47 26.86,174.2 26.66,174.2 25.55,175.31 25.05,175.31 24.63,174.9 24.63,174.46 25.2,173.89 25.2,173.69 24.95,173.43 24.74,173.43 24.28,173.89 23.83,173.89 23.43,173.49 23.43,173.12 23.95,172.6 23.95,172.46 23.77,172.28 23.46,172.28 22.47,173.28 22.01,173.28 21.72,172.98 21.72,171.44 22.73,170.42 23.02,170.42 v1(23.26,170.18)
MDI0+_1: length 22.2
  IN4 w0.089: CN8.1 15.29,188.27 18.38,185.18 30.02,185.18 30.34,185.5 30.34,186.43 v1(30.12,186.65)
  BOTTOM w0.089: U25.16 30,187.55 30.37,187.19 30.37,186.9 v1(30.12,186.65)
MDI0-: length 29.1
  TOP w0.089: U6521.14 21.79,169.66 21.86,169.73 21.86,169.97 22.58,170.69 23.02,170.69 v1(23.26,170.94)
  BOTTOM w0.089: v1(23.26,170.94) 23.02,170.69 22.84,170.69 21.99,171.55 21.99,172.87 22.12,173.01 22.36,173.01 23.35,172.02 23.88,172.02 24.21,172.35 24.21,172.71 23.7,173.23 23.7,173.38 23.94,173.63 24.17,173.63 24.63,173.17 25.06,173.17 25.47,173.58 25.47,174 24.9,174.57 24.9,174.79 25.16,175.05 25.44,175.05 26.55,173.94 26.97,173.94 27.4,174.36 27.4,174.72 26.53,175.6 26.53,175.73 26.76,175.96 27.15,175.96 28.42,174.69 28.88,174.69 29.52,175.33 29.52,175.77 28.35,176.93 28.35,177.18 28.57,177.4 30.36,177.4 30.63,177.68 30.63,178.2 31,178.56 U25.8
MDI0-_1: length 22.2
  IN4 w0.089: v1(30.88,186.65) 30.66,186.43 30.66,185.36 30.15,184.86 18.25,184.86 15.15,187.95 14.15,187.95 13.95,187.76 CN8.2
  BOTTOM w0.089: v1(30.88,186.65) 30.63,186.9 30.63,187.19 31,187.55 U25.17
MDI1+: length 33.8
  TOP w0.089: U6521.17 20.59,169.67 20.54,169.72 20.54,171 20.74,171.2 20.87,171.2 v1(21.1,170.97)
  BOTTOM w0.089: U25.12 27,178.56 27.37,178.2 27.37,177.87 26.58,177.08 20.44,177.08 20.12,176.77 20.12,176.24 20.42,175.94 22.75,175.94 22.88,175.81 22.88,175.53 22.7,175.35 19.51,175.35 19.21,175.65 17.06,175.65 16.47,175.06 16.47,173.97 16.92,173.51 18.62,173.51 19.27,174.16 20.89,174.16 21.04,174 21.04,173.54 20.92,173.41 20.07,173.41 19.71,173.05 19.71,171.94 20.43,171.22 20.85,171.22 v1(21.1,170.97)
MDI1+_1: length 18.2
  IN1 w0.089: CN8.3 14.12,186.23 15.08,185.26 27.01,185.26 27.36,185.61 27.36,186.55 v1(27.14,186.76)
  BOTTOM w0.089: U25.13 27,187.55 27.39,187.16 27.39,187.01 v1(27.14,186.76)
MDI1-: length 33.8
  TOP w0.089: v1(21.1,171.73) 20.83,171.47 20.63,171.47 20.28,171.11 20.28,169.79 20.19,169.71 U6521.18
  BOTTOM w0.089: v1(21.1,171.73) 20.85,171.49 20.54,171.49 19.97,172.05 19.97,172.94 20.18,173.14 21.03,173.14 21.31,173.43 21.31,174.11 21,174.42 19.16,174.42 18.51,173.78 17.03,173.78 16.73,174.08 16.73,174.95 17.17,175.39 19.1,175.39 19.4,175.08 22.81,175.08 23.15,175.42 23.15,175.92 22.86,176.21 20.53,176.21 20.39,176.35 20.39,176.66 20.55,176.82 26.69,176.82 27.63,177.76 27.63,178.2 28,178.56 U25.11
MDI1-_1: length 18.3
  IN1 w0.089: v1(27.91,186.76) 27.68,186.53 27.68,185.48 27.14,184.95 15.25,184.95 13.95,183.65 CN8.6
  BOTTOM w0.089: v1(27.91,186.76) 27.66,187.01 27.66,187.21 28,187.55 U25.14
MDI2+: length 34.8
  TOP w0.089: U6521.20 19.39,169.66 19.45,169.72 19.45,171.42 19.09,171.78 18.85,171.78 v1(18.68,171.95)
  BOTTOM w0.089: v1(18.68,171.95) 18.5,171.77 16.76,171.77 16.19,171.2 16.19,169.15 16.93,168.4 24,168.4 28.73,173.13 29.65,173.13 33.45,176.93 34.03,176.93 34.4,177.31 36.37,177.31 37,177.94 U25.2
MDI2+_1: length 28.2
  IN4 w0.089: CN8.4 13.95,184.75 14.19,184.51 16.24,184.51 16.62,184.13 32.17,184.13 34.47,186.44 34.47,187.21 34.96,187.7 36.32,187.7 36.66,187.36 36.66,186.95 v1(36.88,186.73)
  BOTTOM w0.089: v1(36.88,186.73) 36.63,186.98 36.63,187.19 37,187.55 U25.23
MDI2-: length 34.8
  TOP w0.089: v1(18.68,170.98) 18.53,171.13 18.53,171.44 18.6,171.52 18.98,171.52 19.18,171.31 19.18,169.83 18.99,169.64 U6521.21
  BOTTOM w0.089: v1(18.68,170.98) 18.76,171.07 18.76,171.34 18.6,171.5 16.87,171.5 16.46,171.09 16.46,169.26 17.04,168.67 23.89,168.67 28.62,173.4 29.54,173.4 33.34,177.2 33.91,177.2 34.29,177.58 36.26,177.58 36.73,178.05 36.73,178.21 36.63,178.31 36.12,178.31 36,178.43 U25.3
MDI2-_1: length 28.2
  IN4 w0.089: CN8.5 16.11,184.19 16.49,183.82 32.3,183.82 34.79,186.31 34.79,187.08 35.09,187.39 36.19,187.39 36.34,187.23 36.34,186.95 v1(36.12,186.73)
  BOTTOM w0.089: v1(36.12,186.73) 36.37,186.98 36.37,187.19 36,187.55 U25.22
MDI3+: length 25.6
  TOP w0.089: U6521.23 18.19,169.67 18.13,169.73 18.13,170.1 17.49,170.73 17.35,170.73 v1(17.09,170.99)
  BOTTOM w0.089: v1(17.09,170.99) 17.37,170.72 17.53,170.72 17.83,170.42 17.83,169.81 18.18,169.47 23.48,169.47 23.84,169.83 23.84,170.33 25.56,172.05 25.56,172.95 26.05,173.44 27.49,173.44 28.26,174.21 29.11,174.21 32.86,177.96 33.26,177.96 33.37,178.07 33.37,178.2 33,178.56 U25.6
MDI3+_1: length 25.1
  IN1 w0.089: CN8.7 15.94,182.15 17.88,184.1 31.76,184.1 33.34,185.67 33.34,186.51 v1(33.12,186.73)
  BOTTOM w0.089: U25.19 33,187.55 33.37,187.19 33.37,186.98 v1(33.12,186.73)
MDI3-: length 25.6
  TOP w0.089: U6521.24 17.79,169.68 17.86,169.75 17.86,169.99 17.38,170.46 17.33,170.46 v1(17.09,170.23)
  BOTTOM w0.089: U25.5 34,178.56 33.63,178.2 33.63,177.96 33.37,177.69 32.97,177.69 29.22,173.94 28.37,173.94 27.6,173.17 26.16,173.17 25.83,172.84 25.83,171.94 24.11,170.22 24.11,169.72 23.59,169.2 18.07,169.2 17.57,169.7 17.57,170.31 17.42,170.45 17.31,170.45 v1(17.09,170.23)
MDI3-_1: length 25.1
  IN1 w0.089: v1(33.88,186.73) 33.66,186.51 33.66,185.54 31.9,183.78 18.01,183.78 16.07,181.83 14.14,181.83 13.95,181.65 CN8.8
  BOTTOM w0.089: v1(33.88,186.73) 33.63,186.98 33.63,187.19 34,187.55 U25.20
ME_WR#: length 147.2
  TOP w0.114: U37.109 160.56,110.31 160.32,110.07 160.32,106.61 160.56,106.37 160.56,103.91 v1(160.56,103.91) ; R118.1 80.11,131.56 80.01,131.46 v1(76.07,131.46) 73.48,128.87 73.48,127.61 71.75,125.88 71.75,109.54 69.26,107.05 69.26,103.1 68.25,102.09 v1(68.25,101.19)
  IN3 w0.102: v1(110.33,96.21) 113.27,99.16 116.83,99.16 117.44,99.77 121.67,99.77 123.25,101.35 128.81,101.35 130.38,102.92 138.46,102.92 139.53,101.86 141.02,101.86 142.68,100.2 148.06,100.2 149.89,102.03 155.87,102.03 156.93,103.1 159.74,103.1 v1(160.56,103.91)
  IN4 w0.089: v1(110.33,96.21) 109.74,96.8 109.35,96.8 107.65,98.5 101.04,98.5 100.23,97.69 97.8,97.69 97.6,97.49 92.55,97.49 92.19,97.84 88.8,97.84 88.59,97.63 84.82,97.63 84.75,97.7 83.43,97.7 82.86,97.13 81.91,97.13 81.22,97.82 72.17,97.82 71.5,98.5 71.5,99.01 71.11,99.4 70.04,99.4 v1(68.25,101.19)
MEM_VREF_CTL_QA: length 3.4
  TOP w0.381: Q20.3 R411.1 159.8,191.11 v1(160.25,191.56) 160.31,191.62 R25283.1
MIC2-VREFO: length 12.1
  TOP w0.381: v1(19.71,24.23) 19.71,24.74 R471.1 R468.1
  IN1 w0.381: v1(19.71,24.23) 19.71,24.5 18.13,26.09 18.13,28.08 17.35,28.86 16.6,28.86 16.12,29.34 16.12,31.25 v2(15.59,31.77)
  BOTTOM w0.203: U20.29 15.63,31.81 v2(15.59,31.77)
MINICAR_PME#: length 5.3
  TOP w0.114: Q33.1 184.24,108.87 183.8,108.43 v1(183.49,108.43) 183.44,108.48 R651.1 183.23,109.14 182.65,109.72 v1(182.14,109.72)
  BOTTOM w0.114: v1(182.14,109.72) 182.58,109.72 183.01,110.15 CN17.55
MODE: length 7.2
  TOP w0.114: U30.53 29.49,127.41 v1(29.9,127) 30.17,126.72 32.17,126.72 32.9,125.99 R755.2 33.3,125.67 34.35,125.67 R754.1
MODE1: length 264.7
  TOP w0.114: v1(157.79,102.59) 157.31,102.1 156.5,102.1 156.14,101.74 156.14,99.92 155.88,99.67 155.88,98.8 153.76,96.68 U37.35 ; v1(193.75,99.77) 193.75,99.94 196.08,102.26 196.08,103.55 195.6,104.03 195.6,105.15 196.43,105.98 196.43,106.53 197.11,107.21 197.11,111.32 196.58,111.85 196.58,114.86 197.11,115.39 197.11,117.46 197.59,117.94 197.59,119.33 196.7,120.22 196.7,122.07 196.13,122.63 196.13,123.39 194.78,124.74 194.78,125.87 v1(194.77,125.88) 194.77,126.71 v1(194.78,126.72)
  IN1 w0.089: v1(193.75,99.77) 193.4,99.77 192.38,98.76 184.16,98.76 182.85,100.06 181.79,100.06 181.44,100.41 162.1,100.41 160.46,102.05 158.33,102.05 v1(157.79,102.59)
  IN3 w0.102: v1(150.23,212.65) 150.23,212.24 150.82,211.65 150.82,211.07 149.05,209.29 147.49,209.29 146.67,208.47 146.31,208.47 144.59,206.74 140.87,206.74 139.82,205.69 137.36,205.69 136.31,206.74 135.54,207.51 132.3,207.51 132.21,207.6 128.07,207.6 127.62,208.04 125.38,208.04 123.43,206.09 123.43,204.17 123.16,203.9 123.16,203.21 121.26,201.31 121.26,194.65 121.99,193.92 121.99,190.09 123.12,188.97 123.12,186.89 122.53,186.3 122.53,184.72 121.99,184.18 121.99,172.82 124.33,170.49 126.01,170.49 126.73,169.77 126.73,169.01 127.24,168.5 127.24,165.4 129.9,162.73 130.64,162.73 132.15,161.23 138.12,161.23 138.51,160.84 138.51,159.39 139.69,158.21 139.98,158.21 140.24,157.95 140.24,149.83 141.11,148.96 141.11,133.66 141.97,132.8 142.99,132.8 143.69,132.1 146.55,132.1 148.49,130.16 148.49,129.4 150.57,127.32 150.57,125.56 151.43,124.7 159,124.7 159.18,124.88 164.23,124.88 165.83,123.28 167.66,123.28 168.13,122.8 168.78,122.8 169.24,122.34 174.1,122.34 174.39,122.63 176.39,122.63 176.71,122.95 183.09,122.95 183.76,122.28 191.37,122.28 194.78,125.69 v1(194.78,126.72)
  BOTTOM w0.114: R67877.1 150.35,214.09 150.38,214.13 R25650.1 151.01,213.98 151.01,212.93 R25645.2 150.73,212.65 v1(150.23,212.65)
MODE1_HUB: length 3.4
  TOP w0.079: U6516.A3 v1(153.14,214.14)
  BOTTOM w0.114: R25645.1 151.93,213.07 151.93,213.34 152.23,213.64 152.64,213.64 v1(153.14,214.14) 153.14,214.61 v1(152.96,214.79)
MODE2: length 277.6
  TOP w0.114: v1(154.31,103.97) 152.29,101.94 U37.20
  IN2 w0.102: v1(154.31,103.97) 154.75,104.4 159.41,104.4 161.11,106.1 166.04,106.1 168.42,108.48 171.72,108.48 174.96,111.72 185.02,111.72 186.57,110.17 186.57,108.93 187.39,108.11 194.05,108.11 194.77,108.82 197.03,108.82 197.43,108.43 202.34,108.43 202.75,108.84 202.75,112.59 201.93,113.41 201.93,116.09 207.58,121.74 207.58,121.93 210.23,124.58 210.23,126.61 210.14,126.7 v1(210.14,127.62)
  IN3 w0.102: v1(210.14,127.62) 209.72,127.2 205.92,127.2 205.18,127.95 198.33,127.95 198.01,128.28 194.32,128.28 192.58,126.54 192.58,125.19 192.18,124.79 191.56,124.79 190.3,123.53 189.9,123.53 189.1,122.73 183.95,122.73 182.64,124.04 179.32,124.04 178.75,123.47 172.83,123.47 172.16,122.8 169.43,122.8 168.97,123.25 168.32,123.25 167.84,123.73 167.2,123.73 165.6,125.34 158.99,125.34 158.81,125.16 151.62,125.16 151.03,125.75 151.03,127.51 148.95,129.59 148.95,130.37 146.76,132.56 144.49,132.56 142.65,134.4 142.65,135.32 141.57,136.41 141.57,149.19 140.7,150.06 140.7,158.14 140.17,158.67 139.88,158.67 138.97,159.58 138.97,161.03 138.31,161.69 132.34,161.69 131.08,162.95 131.08,164.91 130.59,165.4 130.59,167.45 127.09,170.94 124.52,170.94 123.17,172.29 123.17,174.59 122.51,175.26 122.51,184.05 122.99,184.53 122.99,186.11 123.57,186.7 123.57,189.16 122.67,190.06 122.67,194.21 121.94,194.94 121.94,201.34 123.62,203.02 123.62,203.71 124.66,204.75 124.66,205.51 125.31,206.16 125.31,206.66 126.24,207.58 127.44,207.58 127.88,207.14 132.02,207.14 132.32,206.85 134.53,206.85 135.92,205.46 139.91,205.46 140.97,206.52 145.81,206.52 147.23,207.93 v1(147.23,208.34)
  BOTTOM w0.114: R25646.2 148.54,211.6 148.29,211.86 R25652.1 147.97,211.44 147.53,211.01 R67876.1 147.03,210.22 147.03,209.05 v1(147.04,209.04) 147.04,208.52 v1(147.23,208.34)
MODE2_HUB: length 5.3
  TOP w0.079: U6516.B2 153.86,213.4 153.31,213.4 153.14,213.22
  TOP w0.114: v1(153.08,213.16) 153.14,213.22
  BOTTOM w0.114: R25646.1 149.99,211.6 150.66,212.28 152.29,212.28 v1(152.5,212.49) 153.08,213.06 v1(153.08,213.16)
MODEM_CLKREQ: length 110.7
  TOP w0.114: U36.1 185.21,114.46 R679.2 ; R679.2 185.47,113.36 v1(185.53,113.29) 185.91,112.91 187.1,112.91 187.59,112.42 187.59,111.04 v1(187.38,110.83) ; R679.2 185.86,114.58 U36.2
  IN4 w0.089: v1(187.38,110.83) 187,111.2 186.24,111.2 185.14,110.1 185.14,109.26 179.02,103.14 173.1,103.14 171.86,101.9 167.33,101.9 165.91,100.49 155.92,100.49 155,101.4 151.66,101.4 150.92,100.66 146.95,100.66 146.7,100.91 141.87,100.91 141.31,101.47 131.85,101.47 131.02,102.3 126.85,102.3 124.4,104.74 124.4,105.43 123.74,106.09 122.19,106.09 116.59,111.69 116.59,114.38 115.76,115.21 115.76,118.33 114.37,119.72 113.09,119.72 112.6,120.21 112.6,120.82 111.89,121.53 110.14,121.53 108.7,122.97 107.72,122.97 107.5,123.19 107.5,123.64 106.71,124.43 105.67,124.43 v2(105.41,124.69)
  BOTTOM w0.079: U1.CH29 105.41,124.96 v2(105.41,124.69)
MODEM_CLKREQ_L: length 8.6
  TOP w0.114: v1(189.55,121.54) 188.12,121.54 v1(186.52,119.94) 186.24,119.66 R678.1 186.24,118.55 186.51,118.29 U36.4
  BOTTOM w0.114: v1(189.55,121.54) 190.69,120.4 CN17.14
MUX_3V: length 17.2
  TOP w0.178: U30.28 21.05,123.41 20.88,123.23 v1(20.88,122.86) ; 22.11,130.31 22.22,130.21 U30.14 ; 27.56,121.13 27.56,121.5 27.02,122.03 U30.41
  TOP w0.381: v1(32.27,127.2) 32.19,127.27 R25525.1 ; v1(33.94,125.13) 34.48,124.6 R754.2 ; 22.11,130.31 21.79,130.64 C913.2 20.88,130.31 v1(21.29,129.9) ; R762.2 v1(31.91,133.63) ; R842.2 24.15,119.72 v1(24.45,119.72)
  TOP w0.508: v1(28.34,120.31) C880.1 27.56,121.13 ; R758.2 19.97,120.05 v1(19.97,119.27) 20.15,119.27 R756.2 ; v1(34.33,120.79) v1(34.33,119.71) 34.33,118.32 33.97,117.96 R764.2 R843.2
  vias: v1(32.93,130.41) v1(32.93,129.7) v1(32.94,128.99)
MX0: length 48.8
  TOP w0.114: U37.58 162.96,96.35 164.18,97.58 164.18,98.68 162.8,100.06 162.8,100.88 161.77,101.91 161.77,103.8 v1(161.88,103.91) ; v1(185.96,100.28) 185.96,100.25 185.91,100.2 185.91,99.69 v1(185.83,99.62) 185.83,99.28 C725.1
  IN3 w0.102: v1(161.88,103.91) 161.7,103.73 161.7,101.54 162.78,100.46 165.81,100.46 167.23,101.88 181.45,101.88 182.87,100.46 183.17,100.46 183.36,100.28 185.17,100.28 v1(185.83,99.62)
  BOTTOM w0.114: v1(185.83,99.62) 186.55,100.33 CN18.10 ; v1(161.88,103.91) 161.88,104.91 158.9,107.88 CN19.10
MX1: length 48.6
  TOP w0.114: v1(162.23,102.5) 162.23,101.83 163.07,100.99 163.07,100.17 164.45,98.79 164.45,97.47 163.36,96.38 U37.59 ; v1(186.95,101.14) 186.62,100.81 186.62,99.74 v1(186.49,99.62) C727.1
  IN3 w0.102: v1(162.23,102.5) 162.23,101.87 163.42,100.68 165.46,100.68 167.57,102.79 169.37,102.79 170.06,102.1 181.54,102.1 182.96,100.69 183.27,100.69 183.45,100.5 185.6,100.5 v1(186.49,99.62)
  BOTTOM w0.114: CN19.9 159.9,107.26 162.34,104.82 162.34,103.32 162.23,103.22 v1(162.23,102.5) ; v1(186.49,99.62) 186.71,99.62 187.55,100.45 CN18.9
MX2: length 48
  TOP w0.114: U37.60 163.76,96.4 164.72,97.36 164.72,98.9 163.34,100.28 163.34,101.15 162.71,101.78 v1(162.71,102) ; v1(187.89,100.2) 187.89,100.12 v1(187.38,99.62) C723.1
  IN3 w0.102: v1(162.71,102) 163.8,100.91 165.36,100.91 167.47,103.02 169.47,103.02 169.85,102.63 171.19,102.63 171.63,103.07 173.1,103.07 173.84,102.33 181.64,102.33 183.05,100.91 183.36,100.91 183.54,100.73 186.26,100.73 v1(187.38,99.62)
  BOTTOM w0.114: CN18.8 188.55,100.51 188.11,100.08 187.84,100.08 v1(187.38,99.62) ; CN19.8 160.9,109.51 160.28,108.89 160.28,107.26 162.61,104.93 162.61,102.77 162.71,102.67 v1(162.71,102)
MX3: length 50.3
  TOP w0.114: C722.1 v1(188.27,99.62) 188.93,100.28 v1(189.18,100.28) ; U37.61 164.16,96.42 164.98,97.25 164.98,99.01 163.6,100.39 163.6,101.37 163.18,101.79 v1(163.18,102.51)
  IN3 w0.102: v1(188.27,99.62) 186.92,100.96 183.64,100.96 183.46,101.14 183.15,101.14 181.73,102.56 173.94,102.56 172.61,103.89 171.03,103.89 170.39,103.25 167.38,103.25 165.27,101.14 163.93,101.14 163.18,101.89 v1(163.18,102.51)
  BOTTOM w0.114: v1(163.18,102.51) 163.18,102.58 162.87,102.89 162.87,105.04 160.54,107.37 160.54,108.78 161.06,109.29 161.58,109.29 161.9,109.61 CN19.7 ; v1(188.27,99.62) 188.45,99.62 188.94,100.11 189.23,100.11 189.55,100.42 CN18.7
MX4: length 52
  TOP w0.114: v1(163.64,102.04) 163.88,101.8 163.88,100.49 165.25,99.12 165.25,97.14 164.56,96.45 U37.62 ; v1(189.89,101.34) 189.89,100.2 189.31,99.62 v1(189.16,99.62) C720.1
  IN3 w0.102: v1(163.64,102.04) 163.64,101.99 164.27,101.37 165.18,101.37 167.28,103.48 170.29,103.48 170.93,104.12 172.7,104.12 174.03,102.79 181.82,102.79 183.24,101.37 183.55,101.37 183.73,101.19 187.58,101.19 v1(189.16,99.62)
  BOTTOM w0.114: v1(189.16,99.62) 189.64,100.09 190.15,100.09 190.55,100.49 CN18.6 ; v1(163.64,102.04) 163.64,102.88 163.8,103.04 163.8,104.1 163.14,104.76 163.14,105.15 160.81,107.48 160.81,108.67 161.17,109.03 162.37,109.03 162.9,109.55 CN19.6
MX5: length 49.8
  TOP w0.114: v1(164.11,102.51) 164.15,102.47 164.15,100.6 165.52,99.23 165.52,97.03 164.96,96.47 U37.63 ; C726.1 v1(190.05,99.62) 190.45,100.02 v1(190.45,100.2)
  IN3 w0.102: v1(190.05,99.62) 188.24,101.42 184.58,101.42 183.93,102.07 183.93,102.45 183.36,103.02 174.12,103.02 172.8,104.35 170.84,104.35 170.2,103.7 167.19,103.7 165.08,101.6 164.36,101.6 164.11,101.85 v1(164.11,102.51)
  BOTTOM w0.114: v1(164.11,102.51) 164.07,102.55 164.07,104.21 163.71,104.57 163.71,106.86 164.63,107.78 164.63,108.61 163.9,109.34 CN19.5 ; CN18.5 191.55,100.49 191.15,100.09 190.53,100.09 190.05,99.62 v1(190.05,99.62)
MX6: length 51.5
  TOP w0.114: v1(164.61,102.04) 164.61,100.51 165.78,99.34 165.78,96.92 165.36,96.49 U37.64 ; C721.1 v1(190.94,99.62)
  IN3 w0.102: v1(164.61,102.04) 165.2,102.04 167.09,103.93 170.1,103.93 170.75,104.58 172.89,104.58 174.22,103.25 183.46,103.25 184.16,102.54 184.16,102.17 184.68,101.65 188.9,101.65 v1(190.94,99.62)
  BOTTOM w0.114: v1(164.61,102.04) 164.57,102.08 164.57,102.77 164.87,103.07 165.48,103.07 166.28,103.87 166.28,106.88 164.9,108.26 CN19.4 164.9,111.18 164.63,111.45 TP13180.1 ; v1(190.94,99.62) 191.05,99.62 191.53,100.09 192.34,100.09 192.55,100.3 CN18.4
MX7: length 50.4
  TOP w0.114: U37.65 166.21,97.14 166.05,97.3 166.05,99.45 165.15,100.35 165.15,102.46 v1(165.04,102.58) ; C724.1 v1(191.82,99.62)
  IN3 w0.102: v1(165.04,102.58) 165.41,102.58 167,104.16 170.01,104.16 170.65,104.81 172.98,104.81 174.31,103.48 183.55,103.48 184.39,102.64 184.39,102.26 184.77,101.88 189.56,101.88 v1(191.82,99.62)
  BOTTOM w0.114: v1(191.82,99.62) 192.87,99.62 193.55,100.29 CN18.3 ; v1(165.04,102.58) 165.26,102.8 165.59,102.8 166.55,103.76 166.55,108.51 165.9,109.16 CN19.3 TP13181.1
MY0: length 50.4
  TOP w0.114: v1(171.38,99.62) 171.53,99.46 C719.1 ; U37.36 154.16,96.7 156.19,98.73 156.19,99.34 156.37,99.52 v1(156.37,99.54)
  BOTTOM w0.114: 156.37,99.52 155.25,98.4 151.74,98.4 146.81,103.32 146.81,105.01 144.35,107.47 144.35,108.18 142.9,109.63 CN19.26 ; 156.37,99.52 v1(156.37,99.54) ; 156.37,99.52 157.9,97.98 162.08,97.98 162.67,98.57 163.56,98.57 164.14,97.99 164.14,97.65 164.7,97.09 167.61,97.09 169.07,98.55 169.07,98.75 168.55,99.26 168.36,99.26 167.52,100.11 167.52,101.59 167.8,101.87 170.07,101.87 170.54,101.4 CN18.26 170.54,100.22 171.15,99.62 v1(171.38,99.62)
MY1: length 44.5
  TOP w0.114: C716.1 172.24,99.44 v1(172.06,99.62) ; v1(157.03,99.54) 157.03,99.52 156.49,98.98 156.49,98.73 154.56,96.79 U37.37
  BOTTOM w0.114: CN19.25 143.9,109.24 144.62,108.52 144.62,107.58 147.08,105.12 147.08,103.46 150.52,100.02 156.62,100.02 157.03,99.61 v1(157.03,99.54) 158.32,98.25 161.97,98.25 164.23,100.51 165.74,100.51 168.06,102.82 169.72,102.82 171.54,101 CN18.25 171.54,100.13 v1(172.06,99.62)
MY2: length 45.1
  TOP w0.114: v1(172.77,99.62) 172.95,99.44 C717.1 ; U37.38 154.96,96.86 157.17,99.08 157.22,99.08 157.68,99.54 v1(157.69,99.54)
  BOTTOM w0.114: v1(172.77,99.62) 172.54,99.84 CN18.24 172.54,101.28 172.19,101.63 171.29,101.63 169.83,103.09 167.95,103.09 165.63,100.78 164.12,100.78 161.86,98.52 158.72,98.52 v1(157.69,99.54) 157.69,99.59 156.99,100.29 150.63,100.29 147.35,103.57 147.35,105.23 144.9,107.68 CN19.24
MY3: length 45.9
  TOP w0.114: C708.1 174.16,99.09 v1(174.16,99.62) ; U37.39 155.36,96.82 157.6,99.05 157.89,99.05 158.35,99.52 v1(158.35,99.54)
  BOTTOM w0.114: v1(174.16,99.62) 173.84,99.62 173.54,99.91 CN18.23 173.54,101.26 172.9,101.9 171.4,101.9 169.94,103.36 167.84,103.36 165.52,101.04 164.01,101.04 161.75,98.78 159.11,98.78 v1(158.35,99.54) 158.35,99.64 157.43,100.56 155.07,100.56 154.33,101.29 151.79,101.29 150.85,102.23 149.17,102.23 147.61,103.78 147.61,105.34 145.9,107.06 CN19.23
MY4: length 46.2
  TOP w0.114: C718.1 174.86,99.58 v1(174.82,99.62) ; v1(159.01,99.54) 159.01,99.49 158.3,98.79 157.71,98.79 155.76,96.84 U37.40
  BOTTOM w0.114: v1(174.82,99.62) 174.54,99.89 CN18.22 174.54,101.04 v1(173.31,102.28) 173.19,102.17 171.51,102.17 170.05,103.62 167.73,103.62 165.41,101.31 163.9,101.31 161.64,99.05 159.5,99.05 v1(159.01,99.54) 159.01,99.59 157.78,100.82 155.18,100.82 154.44,101.56 151.9,101.56 150.96,102.5 149.28,102.5 147.88,103.89 147.88,107.46 146.9,108.44 CN19.22
MY5: length 43
  TOP w0.114: v1(175.48,99.62) 175.59,99.5 C707.1 ; v1(159.67,99.54) 159.67,99.51 158.68,98.52 157.82,98.52 156.16,96.86 U37.41
  IN3 w0.102: v1(175.48,99.62) 175.04,99.18 167.44,99.18 166.66,98.4 160.81,98.4 v1(159.67,99.54)
  BOTTOM w0.114: CN19.21 147.9,109.71 148.35,109.26 148.35,105.88 152.4,101.83 154.55,101.83 155.29,101.09 158.12,101.09 v1(159.67,99.54) ; v1(175.48,99.62) 175.48,100.78 CN18.21
MY6: length 54.3
  TOP w0.114: v1(156.65,101.57) 158.18,100.03 159.88,100.03 160.14,99.77 160.14,99.26 159.13,98.25 157.93,98.25 156.56,96.88 U37.42 ; C706.1 177.32,99.52 v1(177.4,99.59) 177.4,100.15 v1(176.76,100.78)
  IN3 w0.102: v1(177.4,99.59) 176.11,99.59 175.46,98.95 169.7,98.95 168.82,98.07 165.7,98.07 164.89,97.25 161.32,97.25 160.53,98.04 157.02,98.04 155.94,99.13 155.94,100.86 v1(156.65,101.57)
  BOTTOM w0.114: v1(177.4,99.59) 176.54,100.45 CN18.20 ; CN19.20 148.9,109.68 148.61,109.39 148.61,105.99 152.51,102.09 154.67,102.09 155.19,101.57 v1(156.65,101.57)
MY7: length 55.4
  TOP w0.114: v1(157.31,101.57) 158.58,100.3 159.99,100.3 160.4,99.88 160.4,99.15 159.24,97.99 158.04,97.99 156.96,96.91 U37.43 ; v1(177.93,100.28) 177.93,99.74 v1(178.06,99.62) C709.1
  IN3 w0.102: v1(178.06,99.62) 177.6,99.16 176,99.16 175.55,98.72 169.79,98.72 168.91,97.84 165.8,97.84 164.99,97.02 161.22,97.02 160.43,97.81 156.93,97.81 155.71,99.03 155.71,101.24 156.47,102 156.87,102 v1(157.31,101.57)
  BOTTOM w0.114: v1(157.31,101.57) 157.31,101.8 157.07,102.03 155.1,102.03 154.78,102.36 153.28,102.36 150.37,105.27 150.37,108 149.58,108.79 149.58,109.26 149.9,109.58 CN19.19 ; CN18.19 177.54,100.13 v1(178.06,99.62)
MY8: length 50.8
  TOP w0.114: v1(157.97,101.57) 158.97,100.57 160.1,100.57 160.67,99.99 160.67,99.04 159.35,97.72 158.15,97.72 157.36,96.93 U37.44 ; C711.1 178.79,99.54 v1(178.72,99.62) 178.72,100.73 178.97,100.99 v1(178.97,101.01)
  IN3 w0.102: v1(157.97,101.57) 158.85,100.68 159.94,100.68 162,98.63 166.56,98.63 167.98,100.05 178.41,100.05 178.72,99.74 v1(178.72,99.62)
  BOTTOM w0.114: CN19.18 150.9,105.11 152.94,103.07 157.97,103.07 158.32,102.71 158.32,102.46 157.97,102.1 v1(157.97,101.57) ; v1(178.72,99.62) 178.54,99.79 CN18.18
MY9: length 49.3
  TOP w0.114: U37.45 157.76,96.95 158.26,97.45 159.46,97.45 160.94,98.93 160.94,100.1 160.21,100.83 159.37,100.83 v1(158.63,101.57) ; C713.1 179.53,99.46 v1(179.38,99.62) 179.38,100.71 v1(180.22,101.55)
  IN3 w0.102: v1(158.63,101.57) 159.29,100.91 160.04,100.91 162.09,98.86 166.47,98.86 167.89,100.28 178.72,100.28 v1(179.38,99.62)
  BOTTOM w0.114: v1(158.63,101.57) 158.63,102.79 158.08,103.34 155.44,103.34 154.92,103.86 154.92,104.42 151.9,107.44 CN19.17 ; v1(179.38,99.62) 179.54,99.78 CN18.17
MY10: length 47.4
  TOP w0.114: C714.1 180.04,99.28 v1(180.04,99.62) v1(180.04,100.28) ; U37.46 158.16,96.34 158.07,96.43 158.07,96.88 158.37,97.19 159.57,97.19 161.2,98.82 161.2,100.22 160.32,101.1 159.76,101.1 v1(159.29,101.57)
  IN3 w0.102: v1(159.29,101.57) 159.72,101.14 160.13,101.14 162.19,99.08 166.38,99.08 167.8,100.5 179.15,100.5 v1(180.04,99.62)
  BOTTOM w0.114: CN19.16 152.9,109.6 153.22,109.28 153.46,109.28 153.93,108.82 153.93,106.12 155.6,104.44 157.94,104.44 158.32,104.06 158.32,103.47 158.89,102.9 158.89,101.96 v1(159.29,101.57) ; v1(180.04,99.62) 180.54,100.12 CN18.16
MY11: length 46
  TOP w0.114: U37.51 160.16,96.3 160.39,96.53 160.39,97.62 161.47,98.71 161.47,100.33 160.23,101.57 v1(159.95,101.57) ; C715.1 181.11,99.1 v1(181.11,99.62) 181.31,99.82 v1(181.31,100.28)
  IN3 w0.102: v1(181.11,99.62) 181.11,100.15 180.52,100.73 167.7,100.73 166.28,99.31 162.28,99.31 160.02,101.57 v1(159.95,101.57)
  BOTTOM w0.114: CN19.15 153.9,109.51 154.19,109.21 154.19,106.23 155.71,104.71 158.05,104.71 158.58,104.17 158.58,103.58 159.16,103.01 159.16,102.36 v1(159.95,101.57) ; CN18.15 181.54,100.06 v1(181.11,99.62)
MY12: length 47.6
  TOP w0.114: U37.52 160.56,96.25 161.74,97.42 161.74,100.44 159.72,102.46 v1(159.72,102.46) ; C728.1 182.05,99.28 182.12,99.36 v1(182.12,99.62) 182.12,100.17 181.54,100.76 v1(181.54,101.55)
  IN3 w0.102: v1(159.72,102.46) 160.66,101.52 160.66,101.26 162.38,99.54 166.19,99.54 167.61,100.96 180.98,100.96 182.12,99.82 v1(182.12,99.62)
  BOTTOM w0.114: CN18.14 182.55,100.04 v1(182.12,99.62) ; CN19.14 154.9,109.39 155.13,109.16 155.13,108.26 155.65,107.74 156.55,107.74 158.91,105.37 158.91,105.02 159.56,104.37 159.56,102.62 v1(159.72,102.46)
MY13: length 45.4
  TOP w0.114: U37.53 160.96,96.27 162,97.31 162,100.55 160.38,102.17 v1(160.38,102.46) ; v1(182.78,99.57) 182.93,99.41 C729.1
  IN3 w0.102: v1(160.38,102.46) 160.38,102.12 160.98,101.52 160.98,101.26 162.47,99.77 166.09,99.77 167.51,101.19 181.16,101.19 182.78,99.57 v1(182.78,99.57)
  BOTTOM w0.114: v1(182.78,99.57) 183.55,100.33 CN18.13 ; v1(160.38,102.46) 159.83,103.01 159.83,104.32 159.99,104.48 159.99,105.67 157.77,107.88 156.97,107.88 156.31,108.54 156.31,108.91 155.9,109.32 CN19.13
MY14: length 46.3
  TOP w0.114: v1(184.51,99.62) 184.38,99.74 v1(183.85,99.74) 183.82,99.72 C730.1 ; v1(161.04,102.46) 161.04,101.89 162.27,100.66 162.27,97.2 161.36,96.29 U37.54
  IN3 w0.102: v1(161.04,102.46) 161.21,102.29 161.21,101.35 162.57,100 166,100 167.42,101.42 181.26,101.42 182.68,100 182.96,100 183.34,99.62 v1(184.51,99.62)
  BOTTOM w0.114: v1(161.04,102.46) 160.09,103.41 160.09,104.21 160.25,104.37 160.25,105.78 157.29,108.74 157.29,109 156.9,109.39 CN19.12 ; CN18.12 184.55,99.65 v1(184.51,99.62)
MY15: length 47.1
  TOP w0.114: v1(161.22,103.91) 161.22,102.94 161.5,102.65 161.5,101.8 162.54,100.77 162.54,97.09 161.76,96.32 U37.55 ; v1(185.17,99.62) 185.17,99.51 C731.1
  IN3 w0.102: v1(185.17,99.62) 184.74,100.05 183.26,100.05 183.08,100.23 182.77,100.23 181.35,101.65 167.32,101.65 165.9,100.23 162.69,100.23 161.47,101.44 161.47,103.65 v1(161.22,103.91)
  BOTTOM w0.114: v1(185.17,99.62) 185.55,99.99 CN18.11 ; CN19.11 157.9,109.52 158.55,108.87 158.55,107.86 161.22,105.19 v1(161.22,103.91)
MY16: length 45.9
  TOP w0.114: U37.56 162.16,96.34 163.02,97.2 v1(163.02,97.74) ; C732.1 170.11,99.34 v1(169.83,99.62)
  BOTTOM w0.114: CN18.28 168.55,100.35 169.09,99.8 169.65,99.8 v1(169.83,99.62) 169.83,98.55 167.83,96.56 164.48,96.56 163.8,97.24 163.51,97.24 v1(163.02,97.74) 162.74,97.74 162.46,97.45 157.66,97.45 157.29,97.82 149.26,97.82 144.68,102.4 144.68,106.39 143.82,107.25 143.82,107.95 142.92,108.86 142.21,108.86 141.74,108.39 141.27,108.39 140.8,108.85 140.8,109.37 140.9,109.47 CN19.28
MY17: length 48.6
  TOP w0.114: v1(163.68,97.74) 163.68,97.48 162.56,96.36 U37.57 ; C733.1 170.82,99.29 v1(170.49,99.62)
  BOTTOM w0.114: v1(170.49,99.62) 170.49,99.9 170.29,100.09 169.81,100.09 169.55,100.36 CN18.27 169.55,101.36 169.3,101.61 167.91,101.61 167.79,101.48 167.79,100.22 168.47,99.53 168.66,99.53 169.33,98.86 169.33,98.44 167.72,96.83 164.59,96.83 v1(163.68,97.74) 163.19,98.23 162.7,98.23 162.19,97.72 157.77,97.72 157.4,98.09 149.37,98.09 146.55,100.91 146.55,104.9 144.08,107.36 144.08,108.06 142.86,109.29 142.08,109.29 141.9,109.47 CN19.27
N12E_SCL: length 10.1
  BOTTOM w0.102: U8.C9 126.4,183.77 126,183.37 126,183.12 125.8,182.92 125.8,182.2 125.96,182.05 125.96,181.38 125.6,181.02 124.9,181.02 123.92,180.04 122.31,180.04 121.74,179.47 120.8,179.47 120.71,179.38
  BOTTOM w0.114: 120.71,179.38 R367.1
N12E_SDA: length 10
  BOTTOM w0.102: U8.C8 125.56,183.77 125.12,183.33 125.12,181.57 123.82,180.27 122.1,180.27 121.52,179.7 120.06,179.7 119.75,179.38
  BOTTOM w0.114: 119.75,179.38 R368.1
NBSWON#: length 140.6
  TOP w0.114: v1(204.79,97.26) R67861.2 v1(205.72,96.06) 206.26,95.52 208.24,95.52 208.57,95.84 C6615.2 v1(208.57,98.03) ; v1(163.43,113.08) 163.28,112.93 R25314.1 162.41,112.93 162.12,112.64 161.86,112.64 161.36,112.14 U37.107 ; v1(194.73,98.9) 194.55,98.72 R720.2
  IN1 w0.089: v1(227.33,112.39) 225.55,110.61 225.55,105.38 222.58,102.4 215.36,102.4 210.47,97.51 209.09,97.51 v1(208.57,98.03) ; v1(204.79,97.26) 204.79,97.54 204.13,98.19 195.43,98.19 v1(194.73,98.9)
  IN4 w0.089: v1(227.33,112.39) 227.33,116.76 225.66,118.44 219.01,118.44 216.8,120.65 215.87,120.65 214.16,122.35 212.73,122.35 212.06,121.69 210.81,121.69 208.31,124.19 207.97,124.19 206.44,125.71 204.09,125.71 202.77,124.4 198.95,124.4 198.53,123.98 193.57,123.98 192.86,123.27 191.11,123.27 190.35,122.5 189.7,122.5 189.35,122.85 184.45,122.85 183.92,123.38 181.8,123.38 179.98,121.56 178.42,121.56 176.07,119.21 173.44,119.21 172.14,117.92 169.91,117.92 169.44,117.44 169.12,117.44 168.16,116.48 168.16,116.48 167.02,115.34 165.11,115.34 163.81,114.04 163.81,113.46 v1(163.43,113.08)
  BOTTOM w0.114: v1(227.33,112.39) 228.08,113.4 SW5.2 230.31,113.81 232.43,113.81 SW5.1 ; v1(163.43,113.08) 163.41,113.1 C96346.1 ; CN52.4 208.85,98.31 v1(208.57,98.03)
NBSWON#_R: length 43.9
  TOP w0.114: v1(195.08,99.86) 195.63,99.3 D33.2 195.43,98.87 194.94,99.36 194.53,99.36 194.34,99.17 R720.1 ; v1(167.24,111.27) 167.29,111.32 172.68,111.32 172.94,111.06 173.92,111.06 175.09,112.23 178.97,112.23 179.49,111.71 v1(180.28,111.71) 181.65,110.34 v1(181.84,110.34)
  IN3 w0.102: v1(181.84,110.34) 182.24,110.75 183.87,110.75 186.68,107.93 190.1,107.93 191.61,106.42 194.9,106.42 194.97,106.5 v1(195.97,106.5)
  BOTTOM w0.114: v1(195.97,106.5) 196.09,106.38 196.09,101.35 195.58,100.85 CN18.1 195.55,100.47 195.08,100 v1(195.08,99.86) ; CN19.1 167.9,110.6 v1(167.24,111.27)
Net_88:
  vias: v1(4.94,50.61) v1(4.94,49.34) v1(6.11,50.61) v1(6.11,49.34) v1(7.28,50.61) v1(7.28,49.34) v1(8.21,50.6) v1(8.21,49.33)
NFC_DWL_REQ: length 9.1
  TOP w0.114: v1(69.75,95.78) R67567.2 69.36,94.84 69.19,94.67 Q6558.1 68.63,96.34 68.37,96.6 67.86,96.6 R67563.2 66.87,97.6 66.38,97.6 v1(65.91,98.07)
  BOTTOM w0.114: v1(65.91,98.07) 65.2,98.78 CN58.5
NFC_I2C_SCL: length 7.9
  TOP w0.114: v1(64.52,92.73) 64.52,93.6 R67570.2 64.52,93.98 64.12,94.38 Q6556.1 64.12,96.5 63.84,96.78 63.65,96.78 R67568.2 63.29,97.43 v1(63.93,98.07)
  BOTTOM w0.114: CN58.8 63.7,98.3 v1(63.93,98.07)
NFC_I2C_SDA: length 9.6
  TOP w0.114: R67564.2 60.59,93.52 60.89,93.82 Q6559.1 60.89,95.8 R67571.2 61,96.38 62.22,97.6 62.81,97.6 v1(63.27,98.07) 63.58,98.38 v1(63.58,98.78)
  BOTTOM w0.114: CN58.9 63.2,98.14 v1(63.27,98.07)
NFC_INT: length 7.2
  TOP w0.114: v1(61.95,98.07) 61.95,97.71 60.99,96.75 v1(60.3,96.75) 60.19,96.63 59.44,96.63 R67561.2 58.72,95.49 58.6,95.38 Q6555.1
  BOTTOM w0.114: CN58.11 62.2,98.32 v1(61.95,98.07)
NFC_RST#: length 73.7
  TOP w0.114: Q6557.3 65.86,94.29 66.31,93.83 R67566.1 66.04,93.31 R67572.2 65.52,92.21 v1(65.52,91.78)
  IN1 w0.089: v1(99.76,96.03) 99.36,95.63 93.31,95.63 92.63,94.95 79.02,94.95 78.05,93.98 76.78,93.98 73.82,91.02 66.28,91.02 v1(65.52,91.78)
  BOTTOM w0.079: U1.CN28 105.94,122.16 106.22,121.89 106.22,121.4 106.28,121.23 106.28,120.93 106.84,120.37 106.84,118.46 106.56,118.19 106.56,116.28 106.85,115.99 106.85,115.72
  BOTTOM w0.114: v1(99.76,96.03) 99.76,96.75 99.54,96.97 99.54,99.57 98.28,100.83 98.28,105 98.61,105.32 v1(98.61,105.64) 98.28,105.96 98.28,107.45 99.27,108.44 100.44,108.44 102.17,110.17 102.17,110.9 102.44,111.17 102.44,112.27 102.84,112.67 102.84,113.11 103.26,113.52 105.99,113.52 106.85,114.39 106.85,115.72
NFC_RST#_Q: length 7.5
  TOP w0.114: R67566.2 65.54,93.87 65.36,94.05 Q6557.1 64.82,96.62 R67573.2 64.82,97.64 v1(65.25,98.07) 65.03,98.29 v1(65.03,98.7)
  BOTTOM w0.114: v1(65.25,98.07) 64.7,98.62 CN58.6
NFC_SWP: length 4.2
  TOP w0.114: TP13163.1 58.82,98.57 60.13,98.57 v1(60.63,98.07)
  BOTTOM w0.114: CN58.13 61.2,98.64 v1(60.63,98.07)
NGFF_SATA_DET: length 129
  TOP w0.114: v1(101.33,97.71) 100.1,98.94 100.1,102.59 101.08,103.57 104.41,103.57 105.56,104.72 105.56,105.83 105.22,106.17 105.22,107.03 106.5,108.3 110.42,108.3 111.26,109.14 111.26,109.65 111.78,110.17 112.83,110.17 113.79,111.13 116.58,111.13 118.37,112.92 118.72,113.27 v2(118.72,113.5) 118.72,113.88 118.83,113.99 R134.1
  IN2 w0.102: v1(101.33,97.71) 101.23,97.61 98.44,97.61 97.9,97.08 92.19,97.08 92.1,97.17 88.15,97.17 88.04,97.28 83.8,97.28 83.37,96.85 81.59,96.85 81.21,97.23 77.12,97.23 75.8,95.92 73.79,95.92 73.32,95.44 68.85,95.44 67.99,94.58 44.84,94.58 44.15,95.26 33.49,95.26 31.46,97.3 27.36,97.3 26.73,97.92 25.86,97.92 25.09,97.16 v1(25.09,96.49)
  IN4 w0.089: v1(25.09,96.49) 24.46,96.49 23.65,95.68 23.65,95.05 22.93,94.32 v1(22.93,91.34)
  BOTTOM w0.079: 118.41,118.66 117.58,119.5 117.58,119.91 117.36,120.13 117.36,120.63 117.5,120.77 117.5,121.21 117.24,121.73 U1.CP10
  BOTTOM w0.102: 118.41,118.66 118.72,118.36 118.72,115.69 118.64,115.62
  BOTTOM w0.114: 118.64,115.62 118.14,115.11 v1(118.14,115.01) 118.14,115 118.14,114.08 v2(118.72,113.5) ; v1(22.93,91.34) 22.47,91.34 R653.1
NV_PLLVDD: length 13
  TOP w0.254: L7.2 C457.2 115.43,195.52 115.7,195.25 v1(115.93,195.25) 117.7,195.25 119.2,193.75 120.19,193.75 122.3,191.64 122.89,191.64 v2(123.44,191.09) 124.21,190.32 C458.2
  BOTTOM w0.254: U8.L6 v2(123.44,191.09)
ODD_PRSNT#: length 11.9
  BOTTOM w0.079: U1.CP14 114.5,121.53 114.5,121.33 114.47,121.24 114.45,121.18 114.45,120.97 114.61,120.81 114.61,120.26 114.38,120.02 114.38,119.49 114.87,118.99 115.34,118.99 115.97,118.37 115.97,118.03
  BOTTOM w0.114: 115.97,118.03 115.97,115.31 TP13165.1 115.06,114.4 114.22,114.4 114,114.18 114,112.45 R25475.2
PBA_FP_PWREN#: length 112.3
  TOP w0.114: v1(164.8,103.72) 164.8,103.47 165.5,102.77 165.5,101.91 165.87,101.54 U37.76
  IN1 w0.089: v1(206.34,102.88) 204.75,101.29 198.7,101.29 198.22,101.77 196.57,101.77 195.76,100.96 193.12,100.96 192.18,100.02 183.71,100.02 183.09,100.63 182.03,100.63 181.68,100.98 170.27,100.98 169.45,101.8 169.45,102.49 168.84,103.1 165.42,103.1 v1(164.8,103.72) 164.4,103.72 163.74,103.06 151.9,103.06 151.48,102.64 151.16,102.64 150.89,102.37 147.46,102.37 147.35,102.25 144.92,102.25 144.34,102.83 144.06,103.11 138.41,103.11 137.59,103.93 134.03,103.93 133.43,104.53 130.22,104.53 127.41,107.34 120.78,107.34 117.81,110.31 111.75,110.31 111.23,109.79 110.15,109.79 109.81,109.45 v1(109.81,109.28)
  BOTTOM w0.114: v1(109.81,109.28) 109.81,109.77 v1(109.6,109.98) 109.39,110.19 R609.1 ; CN52.11 205.35,102.07 206.16,102.88 v1(206.34,102.88)
PCBEEP_EC: length 201.9
  TOP w0.114: U37.34 153.36,94.63 153.19,94.46 152.71,94.46 v1(152.3,94.87) ; v1(22.87,22.1) 22.9,22.07 v1(23.63,22.07)
  IN2 w0.102: v1(152.3,94.87) 152.05,94.61 142.93,94.61 142.29,95.25 138.36,95.25 137.64,95.97 122.04,95.97 120.71,94.64 98.52,94.64 97.91,95.25 93.23,95.25 92.59,94.61 79.16,94.61 78.4,93.85 75.86,93.85 73.72,91.72 68.7,91.72 67.9,92.52 57.19,92.52 56.38,91.72 38.26,91.72 35.25,88.7 35.25,87.61 32.6,84.96 32.6,78.38 30.81,76.59 30.81,64.11 31.51,63.41 31.51,54.4 30.81,53.71 30.81,37.4 32.05,36.17 32.05,32.16 31.77,31.88 31.77,29.93 31.38,29.54 31.38,27.93 30.74,27.29 28.28,27.29 28.03,27.54 27.42,27.54 24.96,25.09 23.71,25.09 22.87,24.25 v1(22.87,22.1)
  BOTTOM w0.114: D6543.2 v1(22.87,22.1)
PCH_AZ_CODEC_BITCLK: length 160.7
  TOP w0.114: R187.1 86.78,130.83 86.55,130.6 85.64,130.6 C96350.1 85.07,130.03 84.37,130.03 84.13,130.26 80.24,130.26 79.54,130.96 76.27,130.96 73.97,128.67 73.97,127.41 72.24,125.68 72.24,109.33 69.76,106.85 69.76,102.89 68.75,101.89 68.75,100.96 68,100.21 66.25,100.21 66.2,100.26 60.36,100.26 59.43,99.33 58.06,99.33 56.44,97.71 56.44,94 v1(56.05,93.61)
  IN3 w0.102: v1(56.05,93.61) 56.05,93.39 54.22,91.56 38.28,91.56 35.98,89.26 35.98,88.95 35.75,88.72 35.75,88.35 32.17,84.77 32.17,81.31 30.52,79.66 30.52,63.38 31.36,62.54 31.36,46.67 29.54,44.85 29.54,42.13 32.3,39.36 32.3,32.76 31.69,32.15 v1(29.92,32.15)
  BOTTOM w0.114: v1(29.92,32.15) 29.92,32.74 29.37,33.29 28.74,33.29 C587.2 26.33,32.79 26.06,32.51 25.27,32.51 25.02,32.76 23.34,32.76 23.23,32.65 22.76,32.65 U20.6
PCH_AZ_CODEC_RST#: length 152.6
  TOP w0.114: v1(53.41,93.63) 53.87,94.09 53.87,98.34 54.44,98.91 55.92,98.91 57.56,100.55 58.92,100.55 59.85,101.48 65.91,101.48 68.04,103.61 68.04,107.56 70.53,110.04 70.53,127.7 76.58,133.75 77.52,133.75 78.1,133.17 79.66,133.17 79.96,133.47 80.8,133.47 80.96,133.63 C216.2 81.79,134.03 82.58,133.25 83.54,133.25 83.7,133.4 R194.1
  IN1 w0.089: v1(27.5,30.17) 27.5,30.55 v1(30.54,33.59)
  IN3 w0.102: v1(53.41,93.63) 52.51,92.73 37.8,92.73 34.81,89.74 34.81,89.43 34.58,89.2 34.58,88.84 31.4,85.66 30.33,85.66 29.01,84.33 29.01,64.39 26.73,62.11 26.73,57.24 29.01,54.96 29.01,45.98 28.37,45.33 28.37,41.64 31.13,38.88 31.13,34.18 v1(30.54,33.59)
  BOTTOM w0.114: v1(27.5,30.17) 27.3,30.38 R738.1 ; v1(30.54,33.59) Q21.1
PCH_AZ_CODEC_SDIN0: length 1.3
  BOTTOM w0.114: R191.1 23.8,32.13 23.48,31.81 U20.8
PCH_AZ_CODEC_SDOUT: length 149.3
  TOP w0.114: v1(55.39,93.56) 55.39,93.65 55.94,94.2 55.94,97.91 57.86,99.83 59.22,99.83 60.15,100.75 66.21,100.75 68.77,103.31 68.77,107.26 71.25,109.74 71.25,126.09 72.98,127.82 72.98,129.13 75.8,131.95 79.88,131.95 80.28,132.36 R25374.1
  IN3 w0.102: v1(25.73,33.04) 26.29,33.04 26.68,32.66 30.96,32.66 31.82,33.52 31.82,39.16 29.06,41.93 29.06,45.05 30.04,46.03 30.04,54.91 27.42,57.52 27.42,61.83 30.04,64.44 30.04,79.86 31.6,81.43 31.6,84.89 35.27,88.55 35.27,88.92 35.5,89.15 35.5,89.46 38.08,92.04 53.87,92.04 v1(55.39,93.56)
  BOTTOM w0.114: U20.5 25.7,33.01 v1(25.73,33.04)
PCH_AZ_CODEC_SYNC: length 155.8
  TOP w0.114: v1(54.73,93.57) 54.73,93.77 55.7,94.74 55.7,98.01 57.76,100.07 59.12,100.07 60.05,100.99 66.11,100.99 68.53,103.41 68.53,107.36 71.01,109.84 71.01,126.19 72.74,127.92 72.74,129.23 75.7,132.19 79.65,132.19 80.34,132.89 81.51,132.89 82.14,132.25 R188.1
  IN3 w0.102: v1(24.46,30.38) 24.77,30.38 25.51,31.12 25.51,31.88 24.94,32.45 24.94,33.26 25.22,33.54 27.05,33.54 27.71,32.88 30.86,32.88 31.59,33.61 31.59,39.07 28.83,41.83 28.83,45.14 29.47,45.79 29.47,55.15 27.19,57.43 27.19,61.92 29.47,64.2 29.47,79.62 31.38,81.53 31.38,84.98 35.04,88.65 35.04,89.01 35.27,89.24 35.27,89.55 37.99,92.27 53.43,92.27 v1(54.73,93.57)
  BOTTOM w0.114: U20.10 23.43,31.01 24.06,30.38 v1(24.46,30.38)
PCH_BLON_C: length 6.2
  BOTTOM w0.114: v1(82.07,191.51) 82.42,191.87 R440.2 83.14,191.87 83.77,191.24 R25365.2 83.77,189.88 R25369.1 83.91,189.73 R25366.2 84.18,188.74 84.65,189.22 Q6521.5
PCH_BLON_EC: length 250.4
  TOP w0.114: v1(203.26,105.17) 207.31,109.22 207.31,109.99 207.78,110.46 207.78,113.11 v1(208.54,113.86) 208.73,114.06 209.13,114.06 210.09,115.01 210.09,123.26 v1(212.22,125.39) ; U37.88 165.97,106.34 v1(165.76,106.55)
  IN1 w0.089: v1(165.76,106.55) 168.69,106.55 168.87,106.72 169.26,106.72 169.42,106.88 169.81,106.88 170.12,107.2 172.5,107.2 175.33,110.03 178.87,110.03 181.63,107.27 189.96,107.27 191.54,105.69 195,105.69 195.63,105.06 199.4,105.06 200.18,104.28 202.37,104.28 v1(203.26,105.17)
  IN3 w0.102: v1(83.66,188.08) 84.29,188.71 87.21,188.71 87.97,187.95 91.21,187.95 92.7,186.47 92.7,184.73 93.73,183.7 96.06,183.7 96.46,184.1 99.44,184.1 100.06,183.49 102.7,183.49 104.77,181.41 104.77,180.94 105.71,180.01 107.78,180.01 108.28,179.51 110.54,179.51 116.73,173.32 116.73,171.15 118.17,169.7 118.17,167.06 119.36,165.87 120.53,165.87 122.48,163.92 122.48,155.23 123,154.7 128.36,154.7 129.55,153.51 129.55,152.11 135.29,146.37 135.29,143.95 132.26,140.92 132.26,140.23 132.63,139.86 133.51,139.86 136.76,136.61 136.76,133.68 137.78,132.66 137.78,131.36 139.86,129.28 143.98,129.28 144.96,128.29 145.83,128.29 146.49,127.63 147.3,127.63 147.56,127.37 147.56,126.63 150.86,123.33 155.2,123.33 156.16,122.37 156.16,122.08 156.94,121.31 163.09,121.31 163.32,121.08 164.88,121.08 165.72,121.92 168.07,121.92 168.39,121.59 169.11,121.59 169.4,121.88 174.29,121.88 174.58,122.17 176.3,122.17 177.16,121.32 180.56,121.32 181.8,120.07 183.95,120.07 184.39,119.63 188.77,119.63 189.5,120.36 190.6,120.36 190.87,120.62 203.12,120.62 206.96,124.46 211.29,124.46 v1(212.22,125.39)
  BOTTOM w0.114: R25366.1 83.13,188.56 83.61,188.08 v1(83.66,188.08)
PCH_DISP_ON: length 108.6
  TOP w0.114: R445.2 79.19,194.72 v1(79.3,194.61) 80.98,194.61 82.17,193.42 82.17,192.53 81.26,191.62 81.26,190.67 81.67,190.25 v1(81.67,190.1)
  IN3 w0.102: v1(81.67,190.1) 82.59,191.01 86.16,191.01 86.72,190.46 88.68,190.46 v1(89.81,189.33)
  IN4 w0.089: v1(89.81,189.33) 90.19,189.64 94.35,189.64 95.52,188.47 96.94,188.47 100.74,184.67 103.74,184.67 104.14,185.08 110.13,185.08 110.39,184.81 110.39,184.05 111.65,182.8 111.65,181 111.09,180.45 111.09,174.34 109.77,173.01 109.77,171.6 110.18,171.19 110.18,151.41 110.9,150.7 110.9,136.27 109.88,135.25 109.88,129.13 110.67,128.34 110.67,127.2 111.1,126.77 111.3,126.77 111.89,126.18 112.95,126.18 113.11,126.34 113.51,126.34 113.72,126.13 113.72,125.77 113.92,125.56 113.92,125.1 114.01,125.01 116.24,125.01 v2(116.56,125.33)
  BOTTOM w0.079: v2(116.56,125.33) 116.89,125.66 U1.CG11
PCH_DPST_PWM: length 124.8
  TOP w0.102: C2.2 117.83,123.82 116.97,124.68 v2(116.56,124.68)
  TOP w0.114: v1(64.34,188.34) 64.34,189.01 v1(64.32,189.03)
  IN3 w0.102: v1(89.07,188.61) 88.54,189.14 80.74,189.14 v1(79.78,188.19)
  IN4 w0.089: v2(116.56,124.68) 117,125.11 117,125.55 116.67,125.87 114.78,125.87 114.66,125.76 113.98,125.76 113.89,125.85 113.89,126.21 113.59,126.51 113.03,126.51 112.88,126.36 111.96,126.36 111.53,126.79 111.53,129.96 111.62,130.05 111.62,134.23 110.76,135.08 110.76,135.57 111.29,136.1 111.29,150.86 110.58,151.57 110.58,158.02 111.2,158.64 111.2,165.73 111.19,165.73 111.19,165.93 110.65,166.47 110.65,171.28 110.16,171.77 110.16,172.85 111.49,174.17 111.49,180.29 112.04,180.84 112.04,183.72 110.29,185.47 103.98,185.47 103.57,185.07 100.96,185.07 97.15,188.87 95.68,188.87 94.51,190.03 89.78,190.03 89.07,189.32 v1(89.07,188.61) ; v1(79.78,188.19) 79.78,188.46 77.89,190.36 69.8,190.36 68.6,189.15 64.44,189.15 v1(64.32,189.03)
  BOTTOM w0.079: v2(116.56,124.68) 116.59,124.68 U1.CH11
  BOTTOM w0.114: v1(64.32,189.03) 64.83,189.03 64.98,188.88 R443.1
PCH_LVDS_BLON: length 107.7
  TOP w0.102: C1.2 116.78,123.24 v2(116.48,123.24)
  IN1 w0.089: v1(109.97,183.16) 109.68,183.16 109.6,183.24 108.45,183.24 108.21,183.49 106.92,183.49 106.74,183.66 105.82,183.66 105.66,183.49 103.98,183.49 103.69,183.78 101.69,183.78 100.51,184.96 100.51,185.82 97.8,188.53 94.75,188.53 90.72,184.5 88.26,184.5 86.78,185.98 v1(85.74,185.98)
  IN4 w0.089: v1(109.97,183.16) 110.73,183.16 111.25,182.64 111.25,181.17 110.7,180.61 110.7,174.5 109.38,173.18 109.38,171.44 109.79,171.03 109.79,151.25 110.5,150.53 110.5,136.43 109.47,135.4 109.47,128.98 110.26,128.19 110.26,127.05 110.81,126.5 111.32,126.5 111.84,125.98 112.67,125.98 112.86,125.79 112.86,125.66 113,125.52 113.61,125.52 113.74,125.4 113.74,125.03 113.93,124.85 113.93,123.31 114.14,123.09 114.84,123.09 114.96,123.21 116.46,123.21 v2(116.48,123.24)
  BOTTOM w0.079: v2(116.48,123.24) 116.48,123.24 116.56,123.31 116.56,123.38 116.89,123.71 U1.CK11
  BOTTOM w0.114: R25365.1 82.38,191.05 82.16,190.84 82.16,190.05 82.45,189.75 82.45,187.9 82.73,187.62 85,187.62 v1(85.74,186.88) v1(85.74,185.98)
PCH_OPI_RCOMP: length 5.2
  TOP w0.102: v2(107.77,130.06) 107.72,130.1 v1(107.72,130.91) 107.98,131.16 107.98,132 108.31,132.33 108.31,133.47 108.62,133.78 R18.2
  BOTTOM w0.079: 107.72,130.07 U1.BW25
  BOTTOM w0.089: 107.72,130.07 107.75,130.07 107.76,130.06 v2(107.77,130.06)
PCH_PWROK: length 148.7
  TOP w0.114: v1(165.46,103.7) 165.46,103.18 165.77,102.88 165.77,102.53 165.95,102.34 U37.78 ; R25357.2 82.88,129.77 v1(80.04,129.77) 79.36,130.44 76.49,130.44 74.47,128.42 74.47,127.2 72.74,125.47 72.74,108.36 73.12,107.98 73.12,106.13 71.91,104.92 71.91,100.88 71.09,100.07 71.09,99.02 v1(70.9,98.83)
  IN3 w0.102: v1(109.67,96.21) 112.84,99.39 116.74,99.39 117.35,100 121.57,100 123.15,101.58 128.72,101.58 130.29,103.15 138.56,103.15 139.62,102.08 141.12,102.08 142.77,100.43 147.97,100.43 149.79,102.26 155.77,102.26 156.84,103.32 159.36,103.32 160.47,104.43 162.16,104.43 163.34,103.25 165,103.25 v1(165.46,103.7)
  IN4 w0.089: v1(70.9,98.83) 72.09,97.63 74.25,97.63 75.24,96.64 75.84,96.64 76.78,97.58 81.19,97.58 81.84,96.94 82.94,96.94 83.51,97.51 84.67,97.51 84.74,97.44 88.67,97.44 88.88,97.65 92.11,97.65 92.47,97.3 97.68,97.3 97.88,97.5 100.87,97.5 101.55,96.82 103.93,96.82 105.41,98.31 107.57,98.31 v1(109.67,96.21)
PCH_PWROK_R: length 22.8
  TOP w0.114: R25357.1 84.74,129.5 85.01,129.22 R25501.1 86.86,129.62 v1(90.76,129.62) 91.16,130.03 92.53,130.03 92.88,130.37 94.89,130.37 96.5,131.99 v1(96.5,132.5)
  BOTTOM w0.079: v1(96.5,132.5) 96.91,132.5 97.95,133.54 100.29,133.54 100.44,133.61 100.68,133.61 100.74,133.58 101.05,133.58 101.1,133.61 101.5,133.61 101.58,133.69 101.98,133.69 102.17,133.5 102.17,133.28 102.43,133.02 103.28,133.02 103.66,133.39 U1.BP31
PCH_SLP_S0_N: length 118.1
  TOP w0.114: R592.1 82.38,94.76 v1(82.3,94.69) 82.05,94.43 77.81,94.43 77.73,94.35 77.73,90.69 77.5,90.46 55.18,90.46 52.92,92.72 52.92,93.84 53.37,94.29 53.37,98.55 54.23,99.41 55.71,99.41 57.35,101.05 58.72,101.05 60.22,102.55 65.58,102.55 67.05,104.02 67.05,107.97 69.54,110.46 69.54,128.19 76.24,134.89 83.12,134.89 83.38,134.63 R38.1 84.52,135.02 86.74,135.02 88.51,133.25 91.2,133.25 91.59,133.65 92.68,133.65 93.59,134.57 94.88,134.57 v1(95,134.44)
  BOTTOM w0.079: 98.31,135.64 99.19,136.52 U1.BJ37
  BOTTOM w0.114: 98.31,135.64 96.2,135.64 v1(95,134.44)
PCH_SPI1_CLK: length 105.8
  TOP w0.114: v1(91.39,112.04) 91.39,111.43 R88.2 92.07,109.63 92.3,109.39 92.71,109.39 92.94,109.17 v1(92.94,107.9) 92.94,107.38 93.33,106.99 93.33,106.46 93.86,105.93 96.93,105.93 97.83,106.82 97.83,107.26 98.97,108.4 99.81,108.4 100.3,107.91 100.3,104.95 98.75,103.4 v1(98.75,101.06) ; R596.1 82.14,100.11 82.3,100.27 v1(82.3,100.57)
  IN1 w0.089: v1(115.6,101.57) 110.66,101.57 110.15,101.06 107.84,101.06 107.63,100.86 107.63,99.99 107.51,99.87 107.11,99.87 107,99.99 107,100.92 106.85,101.06 106.48,101.06 106.39,100.98 106.39,99.48 106.29,99.37 105.93,99.37 105.86,99.45 105.86,100.98 105.77,101.06 105.41,101.06 105.33,100.98 105.33,99.48 105.22,99.37 104.87,99.37 104.79,99.45 104.79,100.98 104.7,101.06 104.35,101.06 104.26,100.98 104.26,99.48 104.16,99.37 103.8,99.37 103.72,99.45 103.72,100.63 103.64,100.71 103.29,100.71 103.19,100.62 103.19,99.48 103.09,99.37 102.73,99.37 102.66,99.45 102.66,100.63 102.57,100.71 102.22,100.71 102.12,100.62 102.12,99.48 102.02,99.37 101.67,99.37 101.59,99.45 101.59,100.63 101.51,100.71 101.15,100.71 101.06,100.62 101.06,99.48 100.95,99.37 100.6,99.37 100.52,99.45 100.52,100.98 100.44,101.06 100.08,101.06 99.99,100.98 99.99,99.48 99.89,99.37 99.53,99.37 99.46,99.45 99.46,100.98 99.37,101.06 v1(98.75,101.06) 96.43,98.75 89.57,98.75 86.43,101.89 85.1,101.89 84.77,102.22 82.77,102.22 82.38,101.83 82.38,100.65 v1(82.3,100.57)
  BOTTOM w0.079: 95.02,122.37 95.21,122.56 97.14,122.56 98.15,123.57 98.15,123.88 99.31,125.03 99.74,125.03 99.86,125.15 U1.CH37
  BOTTOM w0.114: 95.02,122.37 93.68,122.37 91.73,120.42 91.73,117.18 91.39,116.84 91.39,114.24 v1(91.39,112.04) ; v1(115.6,101.57) 115.6,103.76 115.91,104.08 R111.1
PCH_SPI1_CLK_R: length 63.4
  TOP w0.114: U37.105 162.16,110.16 161.39,109.39 v1(161.39,108.43)
  IN3 w0.102: v1(119.12,104.49) 119.12,103.77 120.01,102.88 128.18,102.88 129.86,104.56 129.86,107.38 131.83,109.35 133.31,109.35 135.96,106.71 137.09,106.71 138.63,105.17 139.41,105.17 139.65,104.92 147.32,104.92 148.24,105.84 150.23,105.84 151.36,106.97 151.36,109.31 151.99,109.93 159.31,109.93 160.81,108.43 v1(161.39,108.43)
  BOTTOM w0.114: U6526.6 CN60.6 U6528.6 CN59.6 120.19,106.83 TP15.1 118.88,105.31 119.12,105.07 v1(119.12,104.49) 118.32,104.49 C191.1 R111.2
PCH_SPI1_CLK_TPM: length 2.9
  TOP w0.114: R596.2 83.17,99.2 83.48,99.2 83.86,98.82 U33.19
PCH_SPI1_SI: length 90
  TOP w0.114: R597.1 83.02,98.28 82.49,98.81 81.94,98.81 81.77,98.64 80.78,98.64 80.67,98.74 80.67,101.86 81.12,102.31 81.49,102.31 81.96,102.78 84.04,102.78 84.62,103.36 86.42,103.36 v1(87.11,104.05)
  IN1 w0.089: v1(87.11,104.05) 87.11,102.77 90.45,99.43 96.15,99.43 99.26,102.54 104.27,102.54 104.64,102.18 109.58,102.18 110.13,102.73 116.12,102.73 v1(117,101.85)
  BOTTOM w0.079: U1.CF36 100.67,126.45 100.47,126.65 100.26,126.73 100.09,126.73 99.88,126.52 99.2,126.52 99.06,126.37 98.07,126.37 97.32,125.63 95.18,125.63 95.11,125.55 95.02,125.55
  BOTTOM w0.114: v1(117,101.85) 117.4,101.44 R221.2 117.69,102.19 R25667.1 ; v1(87.11,104.05) 87.36,104.3 87.36,104.63 87.22,104.77 86.53,104.77 86.37,104.93 86.37,105.21 86.51,105.35 87.79,105.35 87.9,105.47 87.9,105.78 87.79,105.9 86.52,105.9 86.37,106.04 86.37,106.36 86.5,106.49 87.73,106.49 87.84,106.6 87.84,107.46 87.73,107.57 86.6,107.57 86.37,107.8 86.37,109.5 87.15,110.28 87.82,110.28 87.94,110.4 87.94,110.85 87.82,110.97 87.1,110.97 86.99,111.08 86.99,112.1 88.09,113.2 88.09,116.93 88.65,117.49 88.65,120.12 94.07,125.55 95.02,125.55
PCH_SPI1_SI_R: length 66
  TOP w0.114: v1(163.38,108.43) 163.38,109.13 163.36,109.15 U37.102 163.36,112.02 163.5,112.16 163.98,112.16 164.35,112.53 164.66,112.53 165.15,113.03 R25303.1
  IN3 w0.102: v1(163.38,108.43) 163.38,108.73 163.02,109.09 160.83,109.09 159.51,110.42 151.79,110.42 150.88,109.51 150.88,107.17 150.03,106.32 148.04,106.32 147.12,105.41 141.8,105.41 140.01,107.2 136.16,107.2 133.51,109.84 131.63,109.84 129.38,107.58 129.38,104.76 127.98,103.36 120.34,103.36 v1(119.64,104.06)
  BOTTOM w0.114: R25667.2 119.08,102.81 TP16.1 v1(119.64,104.06) 119.64,105.15 120.04,105.56 CN59.5 U6528.5 CN60.5
