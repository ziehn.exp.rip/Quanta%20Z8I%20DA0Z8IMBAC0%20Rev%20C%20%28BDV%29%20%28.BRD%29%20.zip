# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDS_SDA: length 4.6
  TOP w0.114: R67375.1 30.14,121.56 29.82,121.88 29.82,122.35 29.5,122.67 29.5,123.8 28.97,124.33 28.97,124.81 28.78,125.01 U30.47
TP_I2C_CLK: length 33.8
  TOP w0.079: 117.7,118.36 117.7,118.74 v2(116.8,119.65)
  TOP w0.114: 117.7,118.36 R25415.2 ; R558.2 131.58,101.1 132.08,101.6 132.08,101.62 v1(132.26,101.8) 132.46,102 v1(132.46,102.49)
  IN4 w0.089: v1(132.46,102.49) 131.65,103.3 131.27,103.3 127.96,106.61 124.64,106.61 124.16,107.09 122.61,107.09 120.4,109.3 120.4,110.63 119.7,111.33 119.24,111.33 117.87,112.7 117.87,114.25 116.57,115.55 116.57,118.53 116.8,118.75 v2(116.8,119.65)
  BOTTOM w0.079: v2(116.8,119.65) 116.8,119.93 116.26,120.47 116.26,120.72 116.37,120.84 116.37,121.23 116.33,121.34 116.33,121.52 116.35,121.59 116.59,121.95 U1.CN11
TP_I2C_DATA: length 38.9
  TOP w0.102: v2(116.28,119.92) 116.28,119.64 116.97,118.94 R25413.2
  TOP w0.114: v1(131.8,102.49) 131.24,101.93 v1(130.31,101.93) 130,101.62 126.44,101.62 125.88,101.06 R560.2
  IN4 w0.089: v1(131.8,102.49) 131.76,102.49 131.3,102.96 131.13,102.96 127.82,106.27 124.5,106.27 124.02,106.75 122.47,106.75 120.06,109.16 120.06,110.49 119.56,110.99 119.09,110.99 117.53,112.56 117.53,114.1 116.23,115.41 116.23,118.73 116.28,118.78 v2(116.28,119.92)
  BOTTOM w0.079: U1.CM11 116.3,122.44 116.3,121.92 116.16,121.55 116.16,121.31 116.2,121.19 116.2,120.91 116.04,120.74 116.04,120.16 v2(116.28,119.92)
TP_INTH#_L: length 13.5
  BOTTOM w0.114: CN33.7 126.6,101.44 127.08,101.93 v1(131.4,101.93) 131.28,102.05 131.28,104.51 131.54,104.77 131.54,105.3 131.64,105.41 R25471.2 131.99,105.4 R25472.1 132.88,104.39 Q29.1
TP_SMB_CLK: length 4.9
  TOP w0.114: Q27.3 127.32,99.83 127.14,99.64 126.95,99.64 R559.1 126.94,99.32 126.68,99.06 C699.1 126.68,98.69 v1(127.34,98.03)
  BOTTOM w0.114: v1(127.34,98.03) 127.34,98.39 127.6,98.65 CN33.6
TP_SMB_DATA: length 8.5
  TOP w0.114: Q27.6 129.02,101.13 128.91,101.01 128.91,99.42 129.02,99.31 129.8,99.31 R562.1 129.74,98.75 C698.1 129.2,98.35 v1(128.86,98.02) 128.86,97.94 128.07,97.15 v1(128.07,97.08)
  BOTTOM w0.114: CN33.5 128.6,98.28 v1(128.86,98.02)
TPCLK: length 117.2
  TOP w0.114: v1(139.38,94.59) 139.38,94.67 137.83,96.22 137.48,96.22 v1(137.16,96.54) 135.96,96.54 R566.1 134.5,97.37 L23.1 ; U37.89 166.23,106.74 165.96,107.01 165.57,107.01 v1(165.1,106.55)
  IN1 w0.089: v1(199.09,105.69) 198.64,105.25 195.71,105.25 194.92,106.04 191.65,106.04 190.23,107.46 181.71,107.46 178.95,110.22 175.26,110.22 172.42,107.39 170.05,107.39 169.73,107.07 169.34,107.07 169.22,106.95 165.93,106.95 165.5,106.95 v1(165.1,106.55)
  BOTTOM w0.114: v1(199.09,105.69) 199.14,105.64 199.14,101.16 199.59,100.71 199.59,96.62 198.8,95.82 197.65,95.82 196.22,94.39 142.87,94.39 142.21,95.05 139.84,95.05 v1(139.38,94.59)
TPCLK-1: length 7.7
  TOP w0.114: v1(135.18,96.52) 134.89,96.81 L23.2 133.77,96.3 133.06,96.3 C696.1 132.43,96.93 131.29,96.93 130.95,97.28 v1(130.95,98.05)
  BOTTOM w0.114: v1(130.95,98.05) 130.95,98.39 131.6,99.04 CN33.2
TPD_EN: length 140.7
  TOP w0.114: R572.2 R574.1 127.32,95.69 136.62,95.69 137.72,94.59 v1(138.03,94.59) ; v1(197.63,104.64) 197.96,104.97 197.96,105.9 198.63,106.57 198.63,116.83 199.11,117.31 199.11,119.96 198.88,120.19 198.88,122.17 v1(198.45,122.6) 198.45,123.13 v1(198.3,123.29) ; R895.2 169.34,113.21 170.16,112.39 172.37,112.39 173.16,111.59 173.7,111.59 174.87,112.76 175.33,112.76 177.04,114.47 177.04,115.16 178.32,116.44 178.32,118.07 177.44,118.95 177.44,121.61 v1(178.27,122.44)
  IN3 w0.102: v1(198.3,123.29) 198.04,123.29 197.07,122.32 192.45,122.32 192.18,122.05 188.97,122.05 188.46,121.54 181.31,121.54 180.84,122 178.7,122 v1(178.27,122.44)
  BOTTOM w0.114: v1(138.03,94.59) 139.02,95.58 142.43,95.58 142.73,95.88 143.87,95.88 144.13,95.62 144.13,95.23 144.44,94.92 151.33,94.92 152,95.6 152.6,95.6 153.28,94.92 190.64,94.92 193.1,97.39 194.96,97.39 195.73,98.16 195.73,98.82 196.48,99.57 196.48,100.21 196.41,100.28 196.41,100.93 197.28,101.79 197.28,102.84 197.63,103.19 v1(197.63,104.64)
TPD_INT#: length 42.2
  IN4 w0.089: v1(136.12,101.88) 135.9,101.66 131.93,101.66 131.1,102.49 130.93,102.49 127.62,105.8 124.3,105.8 123.82,106.28 122.27,106.28 117.03,111.52 v1(117.03,112.73)
  BOTTOM w0.079: U1.CN14 114.99,122.05 114.99,120.16 114.73,119.9 114.73,119.61 114.99,119.35 115.5,119.35 116.44,118.42 116.44,118.36
  BOTTOM w0.102: 116.44,117 116.44,118.36
  BOTTOM w0.114: R573.1 135.15,106.73 v1(135.36,106.52) 135.36,105.1 136.06,104.4 136.06,103.06 136.12,103 v1(136.12,101.88) ; v1(117.03,112.73) 116.24,113.52 R25477.1 115.96,113.58 115.82,113.73 115.82,114.12 116.43,114.74 116.43,116.74 116.44,116.74 116.44,117
TPD_INT#_EC: length 21.8
  TOP w0.114: v1(136.3,104.9) 136.83,105.43 v1(136.96,105.43) 137.43,105.9 137.74,105.9 140.2,108.35 141.52,108.35 142.57,109.4 144.06,109.4 145.71,111.05 R25323.1 R25308.2
  BOTTOM w0.114: R25473.1 133.66,107.42 134.12,107.88 135.47,107.88 135.84,107.51 135.84,105.36 v1(136.3,104.9)
TPDAT-1: length 4.2
  TOP w0.114: v1(130.29,98.02) 129.84,97.57 C697.1 130.43,96.47 L24.2
  BOTTOM w0.114: v1(130.29,98.02) 130.29,98.44 130.6,98.75 CN33.3
TPDATA: length 122.2
  TOP w0.114: U37.90 166.24,107.14 166.1,107.28 165.17,107.28 v1(164.44,106.55) ; R567.1 130.16,96.19 130.4,95.96 131.07,95.96 L24.1 132.1,95.96 137.06,95.96 v1(137.75,95.27) 138.03,95.27 v1(138.72,94.59)
  IN1 w0.089: v1(198.42,105.69) 195.54,105.69 195,106.23 191.72,106.23 190.31,107.65 181.79,107.65 179.03,110.41 175.18,110.41 172.34,107.58 169.97,107.58 169.65,107.26 169.26,107.26 169.14,107.14 166.01,107.14 165.03,107.14 v1(164.44,106.55)
  BOTTOM w0.114: v1(138.72,94.59) 139.45,95.32 142.32,95.32 142.98,94.66 151.44,94.66 152.11,95.33 152.49,95.33 153.17,94.66 196.11,94.66 197.54,96.09 198.69,96.09 199.33,96.73 199.33,100.6 198.88,101.05 198.88,104.8 198.42,105.26 v1(198.42,105.69)
TPM_LRESET#: length 1.8
  TOP w0.114: U33.17 84.56,99.82 84.36,100.02 84.36,100.4 84.23,100.53 R601.2
TPM_PIRQ#: length 12.2
  BOTTOM w0.079: U1.CF22 109.04,125.66 109.04,123.22 108.75,122.93 108.75,119.99 109.28,119.46 109.28,119.12 108.71,118.55 108.71,117.9
  BOTTOM w0.114: 108.71,117.9 108.71,117.07 108.6,116.95 108.6,115.08 R102.1
TS_EN: length 286.5
  TOP w0.114: v1(170.49,106.09) 170.51,106.07 R956.1 ; v1(215.75,121.99) 215.45,121.69 213.03,121.69 212.4,121.06 212.4,111.88 211.74,111.22 v1(211.74,110.49) 211.74,109.78 207.03,105.07 v1(207.03,102.9)
  IN1 w0.089: v1(170.49,106.09) 173.33,103.25 183.97,103.25 184.33,102.89 192.89,102.89 193.23,103.23 199.16,103.23 199.64,103.71 206.22,103.71 v1(207.03,102.9)
  IN3 w0.102: v1(215.75,121.99) 215.71,121.58 210.92,121.58 209.54,122.96 206.4,122.96 203.61,120.17 191.06,120.17 190.79,119.9 189.69,119.9 188.96,119.18 184.2,119.18 183.76,119.62 177.84,119.62 176.64,120.81 176.64,121.04 175.97,121.72 174.77,121.72 174.48,121.42 169.59,121.42 169.3,121.13 168.2,121.13 167.88,121.45 167.12,121.45 164.56,118.89 164.56,118.09 163.74,117.27 161.05,117.27 160.49,116.71 160.49,115.91 159.84,115.26 157.38,115.26 157.06,115.57 154.98,115.57 153.4,113.99 152.24,113.99 151.38,113.13 149.71,113.13 147,110.42 140.46,110.42 140.05,110.01 137.4,110.01 135.36,112.06 135.36,115 132.73,117.63 132.73,122.38 133.65,123.3 133.65,127.03 135.37,128.75 136.36,128.75 137.18,129.56 137.18,130.58 136.03,131.72 136.03,132.83 134.68,134.18 134.68,138.04 133.32,139.4 132.44,139.4 131.38,140.46 131.38,140.61 130.49,141.5 130.49,141.87 129.22,143.14 129.22,151 128.43,151.79 128.43,152.44 127,153.88 123.19,153.88 122.02,155.04 122.02,163.73 120.34,165.41 119.17,165.41 117.72,166.87 117.72,169.51 116.27,170.96 116.27,173.13 111.79,177.62 108.54,177.62 106.61,179.55 105.52,179.55 104.32,180.75 104.32,181.22 103.38,182.15 100.24,182.15 100.1,182.29 99.43,182.29 98.3,183.42 96.43,183.42 96.25,183.24 93.54,183.24 90.99,185.79 89.03,185.79 86.92,187.9 85.12,187.9 84.64,187.42 82.65,187.42 82.41,187.66 79.67,187.66 78.79,188.54 74.59,188.54 74.54,188.59 72.63,188.59 71.84,187.81 v1(70.5,187.81)
  BOTTOM w0.114: v1(70.5,187.81) 70.48,187.79 R436.2
TS_EN_C: length 4.1
  TOP w0.114: R956.2 170.46,103.78 C1210.1 169.04,102.99 v1(168.86,103.17) 168.75,103.17 168.38,103.54 U37.81
TS_EN_R: length 5.4
  BOTTOM w0.114: R436.1 69.03,187.8 69.03,188.73 69.24,188.94 v1(69.24,190.09) 69.24,191.39 69.65,191.79 CN29.28
TS_I2C_SCL: length 33.8
  TOP w0.114: v1(99.46,110) 99.46,109.13 v1(99.44,109.12) 99.32,108.99 98.86,108.99 97.33,107.46 97.33,107.03 96.72,106.42 95.49,106.42 R126.1
  IN3 w0.102: v1(99.46,110) 99.46,110.37 101.68,112.59 101.68,116.76 101.93,117.01 105.91,117.01 106.81,117.92 106.81,120.33 107.24,120.76 107.98,120.76 109.89,122.67 114.68,122.67 115.14,123.13 115.14,124.26 v2(115.48,124.61)
  BOTTOM w0.079: U1.CJ12 115.67,124.61 v2(115.48,124.61)
TS_I2C_SCL_C: length 1.6
  BOTTOM w0.114: TP13177.1 58.42,189.93 R67411.1
TS_I2C_SDA: length 34.7
  TOP w0.114: v1(98.81,109.73) 97.96,108.89 v1(97.89,108.89) 97.89,108.55 96.96,107.61 96.96,107.21 96.67,106.91 R67413.1
  IN3 w0.102: v1(98.81,109.73) 98.81,110.23 101.32,112.74 101.32,116.91 101.79,117.37 105.76,117.37 106.45,118.06 106.45,120.48 107.09,121.12 107.8,121.12 109.55,122.87 114.6,122.87 114.93,123.21 114.93,124.82 v2(115.5,125.38)
  BOTTOM w0.079: U1.CK12 115.92,123.92 116.22,124.23 116.22,124.45 116.1,124.58 116.1,124.78 116.23,124.91 116.23,125.13 116.02,125.33 115.54,125.33 v2(115.5,125.38)
TS_I2C_SDA_C: length 1.5
  BOTTOM w0.114: R67412.1 54.54,190.01 TP13178.1
TS_INT#: length 1.6
  BOTTOM w0.114: CN29.11 TP13179.1
TS_INT#_L: length 145.2
  TOP w0.114: R67884.1 50.3,190.69 v1(50.42,190.57) 50.45,190.6 v1(51.08,190.6)
  IN3 w0.102: v1(111.96,172.77) 112.82,172.77 113.11,172.48 113.11,172.08 113.72,171.46 113.72,159.03 113.61,158.92 113.61,135.73 114.16,135.18 114.16,134.24 113.99,134.07 113.99,133.73 114.16,133.56 114.16,133.04 114.91,132.29 114.91,125.08 114.73,124.9 114.73,123.3 114.51,123.08 114.04,123.08 113.78,123.34 113.78,123.63 v2(113.31,124.1)
  IN4 w0.089: v1(50.42,190.57) 50.56,190.71 55.76,190.71 57.67,192.62 57.94,192.62 60.38,195.06 61.83,195.06 62.03,194.86 62.5,194.86 66.32,198.69 69.78,198.69 71.87,200.78 87.38,200.78 89.87,198.29 89.87,194.47 93.15,191.19 95.58,191.19 96.72,190.04 97.61,190.04 99.51,188.15 101.47,188.15 102.17,187.45 104.92,187.45 105.74,186.63 110.77,186.63 113.2,184.2 113.2,174 v1(111.96,172.77)
  BOTTOM w0.079: v2(113.31,124.1) 113.55,123.86 113.55,123.6 114.1,123.05 U1.CM14
TYPEC1_CCG1_CC1: length 27.7
  IN3 w0.508: v1(13.87,64.04) 11.87,64.04 10.36,65.55 v1(9.53,65.55)
  BOTTOM w0.178: CN10.A5 8.14,65.87 8.4,66.12 8.44,66.12
  BOTTOM w0.203: 8.44,66.12 8.82,66.12 9.13,65.81
  BOTTOM w0.254: 9.13,65.81 9.4,65.55 v1(9.53,65.55)
  BOTTOM w0.305: U6511.9 23.52,53.11 24.06,53.65 C20086.2
  BOTTOM w0.508: C20086.2 24.68,54.24 24.85,54.41 24.85,57.05 22.46,59.44 22.25,59.44 20.38,61.31 v1(17.55,61.31) 14.74,61.31 14.25,61.8 D16.1 14.2,62.31 14.2,63.39 C691.2 14.2,63.72 v1(13.87,64.04)
TYPEC1_CCG1_CC2: length 37.7
  TOP w0.152: v1(11.87,71.55) 11.84,71.55 11.81,71.52 v1(11.1,71.52)
  IN1 w0.152: CN10.B5 6.22,68.18 6.53,68.64
  IN1 w0.508: v1(21.94,54.83) 16.39,54.83 11.59,59.63 11.59,69.55 11.13,70.01 11.13,71.31 11.37,71.55 v1(11.87,71.55) ; v1(9.86,70.84) 9.4,70.84 9.32,70.75 9.32,70.74 8.99,70.42 8.99,69.66 8.06,68.72 6.62,68.72 6.53,68.64
  BOTTOM w0.305: C20087.2 22.71,53.94 22.52,53.75 U6511.7
  BOTTOM w0.381: v1(21.94,54.83) 22.15,54.62 C20087.2
  BOTTOM w0.508: v1(11.87,71.55) 11.53,71.55 11.43,71.44 C692.2 10.73,71.44 10.68,71.49 D17.1 9.86,71.29 v1(9.86,70.84)
TYPEC1_CCG4_VBUS_P_CTRL: length 27
  IN1 w0.089: v1(7.67,46.82) 8.96,45.54 14.22,45.54 16.39,47.7 16.39,49.93 18.59,52.14 23.5,52.14 23.81,52.45 v1(25.41,52.45)
  BOTTOM w0.114: v1(7.67,46.82) R67592.1 7.38,45.97 6.94,45.53 R67591.1 6.42,45.28 v1(5.82,45.28) ; U6511.11 25.37,51.55 25.54,51.72 25.54,52.32 v1(25.41,52.45)
TYPEC1_OUT_1-5A: length 204.1
  TOP w0.114: v1(158.55,96.69) 158.96,96.28 U37.48
  IN2 w0.102: v1(14.7,43.76) 14.9,43.96 17.88,43.96 19.07,42.78 21.78,42.78 23.3,44.29 23.3,44.45 23.55,44.7 24.64,44.7 25.25,44.09 28.16,44.09 29.79,45.72 29.79,53.97 30.6,54.78 30.6,63.03 29.79,63.84 29.79,76.86 31.69,78.75 31.69,85.34 34.34,87.99 34.34,89.08 37.88,92.63 56,92.63 56.81,93.43 68.14,93.43 69.23,94.52 74.05,94.52 74.28,94.29 75,94.29 75.48,94.77 78.02,94.77 78.78,95.53 92.21,95.53 92.85,96.16 98.28,96.16 98.82,96.69 100.76,96.69 100.87,96.59 103.71,96.59 104.81,97.68 117.88,97.68 118.23,97.33 120.6,97.33 122.43,99.17 133.76,99.17 134.41,98.51 139.05,98.51 140.15,97.41 150.42,97.41 150.6,97.23 152.83,97.23 153.39,96.67 158.52,96.67 v1(158.55,96.69)
  BOTTOM w0.114: v1(14.7,43.76) 13.85,42.91 v1(11.43,42.91) R67852.2 7.19,42.91 6.49,43.61 Q6562.2
TYPEC1_RX1N: length 16.9
  TOP w0.102: U12.31 17.32,66.52 17.23,66.43 17.03,66.43 16.85,66.25 16.85,65.7 16.95,65.6 17.05,65.6 v1(17.33,65.88) ; CN10.B10 6.03,64.61 7.68,64.61 7.93,64.37 9.74,64.37 10,64.62 10,65.82 10.36,66.18 10.59,66.18 10.74,66.33 RV3.9 RV3.2 11.98,66.33 12.13,66.18 12.36,66.18 12.54,66 12.54,65.47 12.65,65.37 12.93,65.37 13.03,65.48 v1(13.03,65.65)
  IN1 w0.102: v1(17.33,65.88) 17.12,65.67 15.93,65.67 15.63,65.37 13.31,65.37 v1(13.03,65.65)
TYPEC1_RX1P: length 16.9
  TOP w0.102: v1(13.03,64.89) 12.75,65.17 12.56,65.17 12.34,65.39 12.34,65.91 12.27,65.98 12.13,65.98 11.98,65.83 RV3.1 RV3.10 10.75,65.83 10.6,65.98 10.45,65.98 10.2,65.73 10.2,64.54 9.82,64.16 7.84,64.16 7.6,64.41 6.02,64.41 CN10.B11 ; v1(17.33,65.22) 17.15,65.4 16.86,65.4 16.64,65.62 16.64,66.33 16.92,66.61 U12.30
  IN1 w0.102: v1(13.03,64.89) 13.31,65.17 15.72,65.17 16.01,65.47 17.08,65.47 v1(17.33,65.22)
TYPEC1_RX2N: length 18.1
  TOP w0.102: v1(21.09,65.45) 20.86,65.68 20.62,65.68 20.41,65.89 20.41,66.38 20.52,66.5 U12.39
  BOTTOM w0.102: CN10.A10 8.06,68.37 8.18,68.49 8.82,68.49 8.94,68.61 9.65,68.61 10.04,68.23 10.04,67.78 10.36,67.46 10.56,67.46 10.69,67.32 RV2.9 RV2.2 13.7,67.32 16.57,64.46 18.52,64.46 19.73,65.67 20.86,65.67 v1(21.09,65.45)
TYPEC1_RX2P: length 18.1
  TOP w0.102: U12.40 20.92,66.61 20.61,66.3 20.61,65.98 20.71,65.88 20.97,65.88 21.09,66 v1(21.09,66.11)
  BOTTOM w0.102: CN10.A11 8.04,68.87 8.22,68.69 8.73,68.69 8.86,68.82 9.74,68.82 10.24,68.31 10.24,67.86 10.44,67.66 10.57,67.66 10.73,67.82 RV2.10 RV2.1 12.11,67.82 12.41,67.53 13.79,67.53 16.66,64.66 18.43,64.66 19.65,65.88 20.93,65.88 21.09,66.04 v1(21.09,66.11)
TYPEC1_SBU1: length 10.5
  TOP w0.178: v1(14.87,67.82) 15.12,67.82 15.28,67.98 U12.27
  IN3 w0.254: v1(14.87,67.82) 14.49,67.44 12.09,67.44 12.01,67.53 v1(9.48,67.53)
  BOTTOM w0.114: v1(14.87,67.82) 14.7,67.99 v1(14.18,67.99)
  BOTTOM w0.203: CN10.A8 8.09,67.37 8.34,67.12
  BOTTOM w0.254: v1(14.87,67.82) 15.6,67.09 D19.1 ; v1(9.48,67.53) 9.25,67.53 8.85,67.12 8.34,67.12
TYPEC1_SBU2: length 15.4
  TOP w0.178: v1(14.88,68.56) 15.05,68.38 U12.26
  IN3 w0.152: CN10.B8 6.13,66.18 6.13,67.09 6.21,67.35 6.21,67.67 6.11,67.77 6.11,68 6.45,68.63
  IN3 w0.508: v1(14.88,68.56) 14.61,68.56 13.45,69.72 13.04,69.72 12.83,69.93 10.32,69.93 9.76,69.36 8.6,69.36 7.92,68.69 6.64,68.69 6.45,68.63
  BOTTOM w0.114: v1(14.88,68.56) 14.46,68.98 v1(14.46,69.24)
  BOTTOM w0.254: v1(14.88,68.56) 15.05,68.39 D18.1
TYPEC1_TX1N: length 15.4
  TOP w0.102: v1(18.7,63.19) 18.42,63.47 18.42,63.64 C20055.2
  BOTTOM w0.102: v1(18.7,63.19) 18.46,63.43 18.46,63.76 18.17,64.05 16.4,64.05 14.13,66.32 RV2.4 RV2.7 10.73,66.32 10.6,66.19 10.27,66.19 10,65.92 10,64.46 9.79,64.26 9.47,64.26 8.99,64.74 8.16,64.74 8.03,64.87 CN10.A3
TYPEC1_TX1P: length 15.4
  TOP w0.102: v1(17.93,63.19) 18.02,63.19 18.21,63.38 18.21,63.63 C361.2
  BOTTOM w0.102: v1(17.93,63.19) 18.06,63.19 18.26,63.38 18.26,63.68 18.09,63.85 16.32,63.85 14.05,66.12 12.37,66.12 12.08,65.82 RV2.5 RV2.6 10.76,65.82 10.6,65.98 10.36,65.98 10.21,65.84 10.21,64.37 9.88,64.04 9.4,64.04 8.9,64.54 8.23,64.54 8.07,64.37 CN10.A2
TYPEC1_TX2N: length 21.2
  TOP w0.102: CN10.B3 6.06,68.65 9.65,68.65 9.96,68.34 9.96,67.68 10.18,67.46 10.52,67.46 10.65,67.33 RV3.7 RV3.4 11.97,67.33 12.12,67.49 12.34,67.49 12.54,67.69 12.54,68.19 12.67,68.32 12.91,68.32 13.02,68.21 v1(13.02,68) ; C20057.2 20.7,63.7 20.7,63.57 v1(20.42,63.29)
  IN1 w0.102: v1(13.02,68) 13.02,68.21 13.16,68.35 13.7,68.35 14.11,67.93 14.11,67.61 15.26,66.46 18.57,66.46 20.71,64.31 20.71,63.58 v1(20.42,63.29)
TYPEC1_TX2P: length 21.2
  TOP w0.102: v1(13.02,68.77) 12.78,68.52 12.58,68.52 12.34,68.28 12.34,67.78 12.25,67.69 12.14,67.69 12,67.83 RV3.5 RV3.6 10.69,67.83 10.52,67.66 10.26,67.66 10.16,67.76 10.16,68.43 9.73,68.86 5.99,68.86 CN10.B2 ; C20056.2 20.9,63.7 20.9,63.57 v1(21.18,63.29)
  IN1 w0.102: v1(21.18,63.29) 20.92,63.56 20.92,64.4 18.65,66.66 15.34,66.66 14.31,67.69 14.31,68.02 13.78,68.55 13.24,68.55 v1(13.02,68.77)
TYPEC1_USB0: length 23.3
  TOP w0.508: PD8007.2 30,112.21 28.96,113.26 PD8003.2 v1(28.69,112.26)
  IN1 w0.508: v1(27.38,52.34) 27.11,52.34 25.52,53.93 24.51,53.93 23.27,52.69 15.46,52.69 13.73,54.42 10.1,54.42 v1(9.56,54.97)
  BOTTOM w0.254: R206.2 27.18,52.51 v1(27.38,52.34)
  vias: v1(8.13,57.74) v1(8.45,58.34) v1(8.84,57.77) v1(9.19,58.35) v1(9.53,57.77) v1(10.75,68.39) v1(10.94,62.94) v1(20.18,106.14) v1(20.18,105.48) v1(20.18,104.82) v1(20.76,105.15) v1(21.01,109.17) v1(21.39,106.69) v1(21.61,110.2) v1(21.58,109.54) v1(21.58,103.09) v1(32.73,106.58) v1(32.73,105.92) v1(32.73,105.26) v1(33.25,104.57) v1(33.39,106.6) v1(33.39,105.94) v1(33.39,105.28) v1(34.02,106.79) v1(34.02,106.13) v1(34.02,105.47) v3(10.46,69.09) v3(10.62,63.57)
TYPEC1_USB0_EN: length 2.1
  BOTTOM w0.114: U6523.4 5.9,47.44 v1(6.23,47.11) 6.66,46.68 R67591.2
TYPEC1_USB0_PD: length 21.9
  TOP w0.254: v1(24.79,104.1) 24.79,102.2 25.17,101.82 PR9281.2
  IN1 w0.305: v1(24.79,104.1) 25.66,104.96 28.26,104.96 28.72,104.5 33.47,104.5 33.75,104.79 34.27,104.79 34.56,105.08 37.73,105.08 40.82,108.17 v1(41.87,108.17)
  vias: v1(41.43,107.62)
TYPEC_DDI2_HPD: length 191.1
  TOP w0.079: v2(119.13,123.31) 119,123.19 119,121.94
  TOP w0.102: v1(17.99,65.87) 17.99,66.33 17.72,66.59 U12.32 ; 119,121.94 119.28,121.66 120.02,121.66 120.48,121.2 120.48,119.58 120.73,119.33 120.73,118.57 122.31,116.99 123.13,116.99 123.5,116.62 123.5,115.59 124.13,114.96 124.13,112.04 124.46,111.71 124.46,110.86 124.07,110.48 121.53,110.48 121.21,110.16 120.37,110.16 119.72,109.51 117.39,109.51 116.4,108.52 115.43,108.52 115.18,108.27 115.18,107.42 115.43,107.17 115.43,105.28 114.35,104.21 106.01,104.21 104.69,102.89 101.36,102.89 100.78,102.31 100.78,99.69 102.44,98.03 102.44,96.9 v1(100.23,94.69) 97.74,94.69 v1(97.64,94.59)
  IN1 w0.102: v1(27.01,46.23) 27.37,46.23 28.08,46.94 28.08,54.23 26.8,55.5 26.8,56.14 26.06,56.88 24.51,56.88 22.78,58.6 22.78,59.54 22.14,60.18 22.14,61.32 ; 22.14,61.32 22.14,63.06 24.82,65.74 26.87,65.74 31.73,70.59 31.73,77.37 34.51,80.15 v1(34.51,81.7) ; 22.14,61.32 20.32,61.32 19.6,62.04 19.6,63.57 19.02,64.15 19.02,65.33 18.47,65.87 v1(17.99,65.87)
  IN4 w0.102: v1(64.73,91.74) 65.29,91.18 73.81,91.18 76.34,93.7 78.57,93.7 79.35,94.48 93,94.48 93.51,94.99 97.23,94.99 v1(97.64,94.59)
  BOTTOM w0.079: U1.CM6 119.42,123.31 v2(119.13,123.31)
  BOTTOM w0.102: U6511.18 25.57,48.05 26.35,47.27 26.35,46.81 R25578.1 26.35,46.74 26.86,46.23 v1(27.01,46.23) 27.01,45.62 27.79,44.84 27.79,44.59 R67890.1 ; v1(64.73,91.74) 63.69,90.71 37.42,90.71 35.51,88.8 35.51,82.71 v1(34.51,81.7)
UART2_CTS#: length 17.1
  BOTTOM w0.079: 115.62,118.41 115.21,118.82 114.81,118.82 114.21,119.42 114.21,120.09 114.44,120.33 114.44,120.74 114.29,120.9 114.29,121.2 114.31,121.29 114.33,121.35 114.33,121.51 114.28,121.64 114.28,121.87 114.35,122 114.35,122.57 114.48,122.71 115.55,122.71 115.89,123.05 U1.CM12
  BOTTOM w0.102: 115.71,118.01 115.71,118.32 115.62,118.41
  BOTTOM w0.114: 115.71,118.01 115.71,115.63 115.26,115.19 115.26,114.91 115.03,114.67 114.11,114.67 113.73,114.29 113.73,112.94 113.58,112.79 113.58,112.07 113.74,111.92 115.19,111.92 R604.1
UART2_RTS#: length 5.1
  BOTTOM w0.079: 116.71,118.49 116.6,118.49 115.52,119.57 115.52,121.28 115.67,121.59 115.67,121.99 U1.CN12
  BOTTOM w0.102: 116.71,118.49 116.87,118.34 R607.1
UART2_RXD: length 7.5
  BOTTOM w0.079: 117.53,118.41 116.98,118.96 116.61,118.96 115.85,119.71 115.85,120.95 115.94,121.04 U1.CR12
  BOTTOM w0.102: 117.57,118.37 117.53,118.41
  BOTTOM w0.114: R606.1 117.23,114.9 117.23,115.2 117.66,115.62 117.66,118.28 117.57,118.37
UART2_TXD: length 7.1
  BOTTOM w0.079: 117.44,118.03 117.44,118.11 116.83,118.73 116.6,118.73 115.69,119.64 115.69,121.24 115.74,121.36 115.94,121.56 U1.CP12
  BOTTOM w0.114: 117.44,118.03 117.44,116.24 R605.1
UGATE1_CORE: length 3.2
  BOTTOM w0.508: PR7106.2 156.65,157.73 155.9,157.73 v1(155.1,156.93) PQ7000.1
UGATE2_CORE: length 2.8
  BOTTOM w0.114: PR7078.2 157.25,141.98 v1(158.27,141.98)
  BOTTOM w0.508: 156.76,141.49 PR7078.2
  BOTTOM w0.61: PQ7001.1 156.76,141.49
UGATE_GT: length 1.3
  BOTTOM w0.508: PR7110.2 148.93,166.88 PQ7004.1
UGATE_SA: length 2.9
  BOTTOM w0.114: PR7114.2 164.27,129.93 v1(164.27,130.93)
  BOTTOM w0.508: PQ7002.4 163.68,129.26 163.78,129.36 163.78,129.45 PR7114.2
ULT_EDP_HPD: length 154
  TOP w0.114: R10880.1 119.37,114.46 119.37,113.79 119.55,113.62 v2(119.9,113.62) ; R25467.1 65.99,187.78 65.99,187.2 C6616.2 66.48,187.45 v1(66.53,187.5)
  IN1 w0.089: v2(119.9,113.62) 119.86,113.62 119.13,114.35 116.87,114.35 116.31,113.79 114.06,113.79 113.22,112.95 111.98,112.95 111.15,112.12 109.99,112.12 109.82,112.29 109.43,112.29 109.25,112.11 107.77,112.11 107.48,112.39 105.63,112.39 104.26,111.02 102.59,111.02 100.5,108.92 97.56,108.92 97.18,108.54 94.1,108.54 93.06,107.5 90.12,107.5 88.15,105.54 84.26,105.54 82.82,104.1 80.81,104.1 80.15,103.45 v1(79.39,103.45)
  IN4 w0.089: v1(72.37,177.48) 71.75,177.48 71.27,177.96 69.25,177.96 67.01,180.2 67.01,187.02 v1(66.53,187.5)
  BOTTOM w0.079: U1.CM7 118.85,122.46 118.85,121.98 118.89,121.88 118.89,121.63 118.84,121.5 118.84,121.37 119.05,120.87 119.05,120.24 119.99,119.3
  BOTTOM w0.102: 119.99,119.3 119.99,116.26 119.75,116.02 119.75,115.71
  BOTTOM w0.114: v1(79.39,103.45) 78.37,104.46 78.37,106.7 77.79,107.29 77.79,108.54 73.13,113.2 73.13,125.05 75.13,127.05 75.13,132.62 75.96,133.45 75.96,174.15 74.76,175.34 74.26,175.34 72.37,177.24 v1(72.37,177.48) ; v2(119.9,113.62) 119.9,113.67 119.14,114.42 R1.2 119.14,114.99 119.75,115.6 119.75,115.71
ULT_EDP_HPD_R: length 12.1
  TOP w0.114: v1(68.9,194.05) v1(69.68,193.27) 69.68,191.74 69.29,191.35 69.29,189.06 68.64,188.41 68,188.41 67.7,188.72 R25522.2 R25467.2
  BOTTOM w0.114: CN29.25 68.15,193.42 68.3,193.57 68.42,193.57 v1(68.9,194.05) 69.35,193.6 69.88,193.6 70.15,193.32 CN29.29
USB2_COMP: length 1.5
  TOP w0.102: R136.1 120.37,127.22 v2(119.79,127.22)
  BOTTOM w0.079: U1.CC5 120.17,127.55 119.84,127.22 v2(119.79,127.22)
USB2_ID: length 7.1
  TOP w0.102: v1(121.62,123.47) 121.82,123.67 121.82,124.74 121.55,125.01 R137.1 121.25,125.01 120.91,124.67 120.6,124.67 120.23,125.04 118.95,125.04 118.8,125.19 118.8,125.78 118.67,125.9 118.39,125.9 v2(117.88,126.41)
  BOTTOM w0.079: U1.CE8 118.22,126.75 v2(117.88,126.41)
USB2_VBUSSENSE: length 3.9
  TOP w0.102: v2(119.19,127.2) 119.59,126.81 120,126.81 120.22,126.59 120.57,126.59 121.41,125.75 R138.1
  BOTTOM w0.079: v2(119.19,127.2) 119.52,127.53 U1.CC6
USB30_RX1+: length 133.2
  TOP w0.102: v1(24.96,86.32) 24.96,86.22 24.76,86.02 24.17,86.02 23.65,86.54 23.65,89.28 22.59,90.34 21.7,90.34 21.47,90.57 C518.2 R422.2
  IN1 w0.102: v1(24.96,86.32) 24.96,86.1 25.09,85.96 25.28,85.96 25.56,86.25 25.56,87.13 25.32,87.37 25.32,93.23 28.16,96.07 32.76,96.07 34.23,94.6 38.48,94.6 39.34,95.45 44.42,95.45 45.14,94.73 48.8,94.73 51.16,95.67 56.67,95.67 57.36,96.37 67.29,96.37 67.66,96.74 68.48,96.74 70.29,98.55 70.29,101.71 78.2,109.62 80.34,109.62 83.27,112.55 85.51,112.55 86.02,113.06 87.38,113.06 88.4,114.08 89.34,114.08 94.18,118.92 99.94,118.92 100.5,119.48 103.39,119.48 104.01,120.1 104.01,120.49 105.25,121.74 114.97,121.74 116.07,122.83 116.62,122.83 116.97,123.18 116.97,126.7 116.64,127.03 116.64,127.55 116.89,127.8 119.68,127.8 119.81,127.93 v2(119.81,128.18)
  BOTTOM w0.079: v2(119.81,128.18) 119.88,128.25 119.88,128.58 119.82,128.64 U1.CB6
USB30_RX1+_C: length 11.5
  TOP w0.102: v1(16.49,90.07) 16.67,90.25 16.67,90.7 17.09,91.12 U6530.9 U6530.2 18.55,91.12 18.69,90.98 18.88,90.98 19.15,90.7 19.15,90.41 19.26,90.31 19.5,90.31 19.67,90.49 R422.1
  IN3 w0.102: v1(16.49,90.07) 16.21,89.79 16.04,89.79 15.77,89.52 15.77,88.97 15.99,88.75 15.99,87.38 15.6,86.99 14.74,86.99 14.07,86.31 13.72,86.31 13.6,86.43 CN2.6
USB30_RX1-: length 133.2
  TOP w0.102: v1(24.96,85.56) 24.7,85.82 24.08,85.82 23.45,86.45 23.45,89.2 22.51,90.14 21.68,90.14 21.47,89.93 C513.2 R421.2
  IN1 w0.102: v1(24.96,85.56) 25.16,85.76 25.36,85.76 25.76,86.16 25.76,87.21 25.52,87.45 25.52,93.15 28.24,95.87 32.67,95.87 34.15,94.39 38.56,94.39 39.42,95.25 44.33,95.25 45.06,94.52 48.84,94.52 51.19,95.47 56.76,95.47 57.45,96.16 67.37,96.16 67.75,96.54 68.57,96.54 70.49,98.47 70.49,101.62 78.28,109.41 80.43,109.41 83.36,112.35 85.59,112.35 86.1,112.86 87.47,112.86 88.48,113.87 89.42,113.87 94.26,118.72 100.03,118.72 100.59,119.28 103.47,119.28 104.21,120.01 104.21,120.41 105.34,121.53 115.06,121.53 116.15,122.63 116.7,122.63 117.17,123.09 117.17,126.78 116.84,127.11 116.84,127.46 116.98,127.6 119.76,127.6 120.01,127.84 120.08,127.84 v2(120.39,128.16)
  BOTTOM w0.079: v2(120.39,128.16) 120.17,128.38 U1.CB5
USB30_RX1-_C: length 11.5
  TOP w0.102: R421.1 19.67,89.9 19.46,90.11 19.17,90.11 18.95,90.33 18.95,90.62 18.83,90.74 18.65,90.74 18.53,90.62 U6530.1 U6530.10 17.03,90.62 16.95,90.54 16.95,89.86 v1(16.49,89.4)
  IN3 w0.102: CN2.5 13.6,85.57 14.82,86.8 15.68,86.8 16.18,87.3 16.18,88.83 15.96,89.05 15.96,89.44 16.12,89.6 16.3,89.6 v1(16.49,89.4)
USB30_RX2+: length 117.1
  TOP w0.102: R428.2 22.83,105.97 23.04,105.76 23.61,105.76 23.82,105.98 C526.2 24.29,105.88 25.45,105.88 26.17,106.6 26.78,106.6 26.89,106.71 v1(26.89,106.88)
  IN3 w0.102: v2(117.23,129.05) 117.01,128.83 116.73,128.83 115.93,128.02 115.93,123.8 115.74,123.61 115.74,122.59 115.25,122.1 110,122.1 107.66,119.76 107.66,118.08 106.57,116.99 106.57,115.88 105.24,114.55 103.69,114.55 102.44,113.31 102.44,112.65 100.67,110.87 100.67,109.82 100.32,109.47 100.04,109.47 97.94,107.36 96.45,107.36 95.51,106.42 92.94,106.42 92.64,106.73 89.83,106.73 89.56,106.46 86.08,106.46 85.94,106.32 77.42,106.32 77.02,106.72 73.64,106.72 72.71,105.79 71.05,105.79 68.49,103.23 67.08,103.23 66.5,102.65 65.61,102.65 64.1,101.15 58.77,101.15 57.9,102.02 54.91,102.02 54.51,102.42 52.37,102.42 52.09,102.14 51.26,102.14 50.61,102.78 48.02,102.78 47.46,103.35 45.4,103.35 45.39,103.35 37.07,103.35 36.71,103.71 33.27,103.71 30.39,106.6 27.17,106.6 v1(26.89,106.88)
  BOTTOM w0.079: U1.BY9 117.57,129.41 117.23,129.07 v2(117.23,129.05)
USB30_RX2+_C: length 11.4
  TOP w0.102: R428.1 21.58,105.88 21.21,105.88 20.88,106.21 20.88,106.51 20.57,106.82 19.91,106.82 19.72,106.63 19.61,106.63 19.49,106.76 U6531.2 U6531.9 18.08,106.76 17.89,106.57 17.5,106.57 v1(17.26,106.81)
  BOTTOM w0.102: CN3.6 13.6,104.53 13.75,104.38 14.14,104.38 14.94,105.18 15.39,105.18 16.73,106.51 17.13,106.51 17.26,106.65 v1(17.26,106.81)
USB30_RX2-: length 117.1
  TOP w0.102: R427.2 23.18,105.56 23.47,105.56 C523.2 24.3,105.68 25.53,105.68 26.25,106.4 26.61,106.4 v1(26.89,106.12)
  IN3 w0.102: v2(117.85,129.05) 117.45,128.64 116.81,128.64 116.12,127.94 116.12,123.72 115.93,123.53 115.93,122.51 115.33,121.91 110.08,121.91 107.85,119.68 107.85,118.01 106.76,116.91 106.76,115.81 105.31,114.36 103.77,114.36 102.63,113.23 102.63,112.57 100.86,110.79 100.86,109.74 100.4,109.28 100.12,109.28 98.01,107.17 96.53,107.17 95.59,106.23 92.86,106.23 92.56,106.54 89.91,106.54 89.64,106.27 86.16,106.27 86.02,106.13 77.34,106.13 76.94,106.53 73.71,106.53 72.78,105.6 71.13,105.6 68.57,103.04 67.16,103.04 66.58,102.46 65.68,102.46 64.18,100.96 58.69,100.96 57.82,101.83 54.84,101.83 54.43,102.23 52.45,102.23 52.17,101.95 51.18,101.95 50.53,102.59 47.95,102.59 47.38,103.16 45.32,103.16 45.32,103.16 36.99,103.16 36.63,103.52 33.19,103.52 30.31,106.41 27.17,106.41 v1(26.89,106.12)
  BOTTOM w0.079: v2(117.85,129.05) 118.22,129.41 U1.BY8
USB30_RX2-_C: length 11.4
  TOP w0.102: v1(17.26,106.05) 17.58,106.36 17.92,106.36 18.03,106.26 U6531.10 U6531.1 19.46,106.26 19.63,106.43 19.81,106.43 19.99,106.62 20.48,106.62 20.67,106.43 20.67,106.13 21.13,105.68 21.57,105.68 R427.1
  BOTTOM w0.102: v1(17.26,106.05) 17,106.31 16.81,106.31 15.48,104.98 15.03,104.98 14.23,104.18 13.79,104.18 13.6,103.99 CN3.5
USB30_RX3+: length 137
  TOP w0.102: v1(25.71,68.56) 25.47,68.8 25.47,69.09 25.27,69.29 23.98,69.29 C20070.1
  IN1 w0.102: v1(25.71,68.56) 25.49,68.77 25.49,68.86 25.76,69.13 26.48,69.13 27.06,69.71 27.06,70.81 29.86,73.62 29.86,79.98 31.46,81.58 31.46,87.15 37.46,93.15 47.41,93.15 50.06,94.05 52.09,94.78 57.05,94.78 57.73,95.46 67.64,95.46 68.01,95.83 68.85,95.83 71.91,98.89 71.91,102.07 78.5,108.66 80.69,108.66 83.69,111.65 85.87,111.65 86.37,112.16 87.74,112.16 88.77,113.19 89.71,113.19 94.45,117.93 100.26,117.93 100.85,118.52 104.27,118.52 105.21,119.45 105.21,120.01 106.04,120.85 115.36,120.85 116.45,121.94 116.99,121.94 118.79,123.75 120.09,123.75 120.45,124.1 120.45,124.81 120.37,124.88 120.37,126.97 121.01,127.61 121.01,128.38 120.61,128.78 119.89,128.78 119.75,128.91 119.75,129.05 v2(119.84,129.14)
  BOTTOM w0.079: U1.BY6 119.84,129.24 v2(119.84,129.14)
USB30_RX3-: length 137
  TOP w0.102: v1(25.01,68.57) 25.11,68.57 25.26,68.72 25.26,69 25.18,69.08 24.13,69.08 C20071.1
  IN1 w0.102: v1(25.01,68.57) 25.08,68.57 25.29,68.78 25.29,68.94 25.68,69.33 26.39,69.33 26.85,69.79 26.85,70.9 29.66,73.7 29.66,80.06 31.26,81.67 31.26,87.23 37.37,93.35 47.37,93.35 49.99,94.24 52.05,94.99 56.97,94.99 57.65,95.67 67.56,95.67 67.92,96.03 68.76,96.03 71.7,98.98 71.7,102.15 78.41,108.86 80.61,108.86 83.6,111.86 85.78,111.86 86.29,112.36 87.66,112.36 88.69,113.39 89.62,113.39 94.36,118.13 100.17,118.13 100.76,118.72 104.19,118.72 105,119.54 105,120.1 105.96,121.05 115.27,121.05 116.36,122.14 116.9,122.14 118.71,123.95 120.01,123.95 120.25,124.19 120.25,124.72 120.17,124.8 120.17,127.05 120.81,127.69 120.81,128.29 120.53,128.57 119.8,128.57 119.24,129.14 v2(119.19,129.14)
  BOTTOM w0.079: v2(119.19,129.14) 118.87,129.45 U1.BY7
USB30_RX4+: length 112.6
  IN4 w0.102: v1(205.32,114.75) 205.46,114.75 205.59,114.63 205.59,114.02 205.29,113.72 202.56,113.72 199.98,116.3 199.98,118.66 197.87,120.77 191.92,120.77 191.18,120.03 189.41,120.03 189.17,119.79 184.9,119.79 183.27,121.41 182.33,121.41 179.66,118.73 173.63,118.73 171.79,116.89 171.79,116.34 171.12,115.68 169.75,115.68 167.58,113.51 166.43,113.51 164.33,111.4 159.87,111.4 159.49,111.02 153.42,111.02 152.77,110.37 151.24,110.37 150.81,110.8 141.05,110.8 140.44,110.19 137.34,110.19 135.69,111.83 135.69,115.42 131.36,119.75 131.36,120.66 130.57,121.45 129.49,121.45 127.77,123.18 127.77,125 127.23,125.53 127.23,126.54 126.58,127.19 125.09,127.19 123.93,128.36 122.88,128.36 121.56,129.68 120.45,129.68 120.22,129.9 120.22,130.11 120.34,130.23 v2(120.56,130.23)
  BOTTOM w0.079: v2(120.56,130.23) 120.56,130.43 120.43,130.56 120.24,130.56 U1.BW5
  BOTTOM w0.102: v1(205.32,114.75) 205.47,114.75 205.6,114.63 205.6,114.07 205.45,113.92 CN48.14
USB30_RX4-: length 112.6
  IN4 w0.102: v2(119.84,130.15) 120.03,129.96 120.03,129.82 120.37,129.49 121.48,129.49 122.16,128.81 122.16,128.79 122.8,128.15 123.84,128.15 125.01,126.99 126.5,126.99 127.03,126.46 127.03,125.45 127.56,124.91 127.56,123.09 129.4,121.25 130.48,121.25 131.16,120.57 131.16,119.67 135.49,115.33 135.49,111.75 137.25,109.99 140.52,109.99 141.14,110.6 150.72,110.6 151.15,110.17 152.86,110.17 153.51,110.82 159.57,110.82 159.95,111.2 164.41,111.2 166.52,113.31 167.67,113.31 169.83,115.47 171.21,115.47 172,116.26 172,116.81 173.72,118.53 179.74,118.53 182.42,121.21 183.19,121.21 184.81,119.58 189.25,119.58 189.49,119.82 191.27,119.82 192.01,120.56 197.78,120.56 199.77,118.57 199.77,116.22 202.48,113.51 205.38,113.51 205.79,113.93 205.79,114.47 v1(206.08,114.75)
  BOTTOM w0.079: U1.BW6 119.52,130.47 v2(119.84,130.15)
  BOTTOM w0.102: v1(206.08,114.75) 205.8,114.47 205.8,114.07 205.95,113.92 CN48.13
USB30_TX1+: length 143.2
  TOP w0.102: C520.1 23.94,92.56 24,92.5 24.35,92.5 24.63,92.22 24.63,88.81 27.8,85.65 30.92,85.65 31.46,85.11 32.84,85.11 33.65,84.31 34.41,84.31 34.51,84.41 v1(34.51,84.62)
  IN1 w0.102: v1(34.51,84.62) 34.51,84.43 34.36,84.29 34.02,84.29 33.65,84.66 33.65,87.39 38.01,91.75 55.43,91.75 56.66,92.98 57.23,92.98 58.34,94.09 68.2,94.09 68.58,94.46 69.44,94.46 73.5,98.52 73.5,101.21 76.25,103.96 76.68,103.96 79.93,107.21 81.26,107.21 82.89,108.84 84.11,108.84 85.17,109.91 89.38,109.91 90.22,110.75 92.81,110.75 93.94,111.88 93.94,114.18 96.14,116.38 101.38,116.38 102.09,117.09 106.19,117.09 107.14,118.05 113.61,118.05 114.52,118.96 118.09,118.96 118.57,119.44 118.57,119.93 120.46,121.83 122.21,121.83 122.72,122.34 122.72,124.12 122.09,124.75 122.09,127.03 121.99,127.12 121.99,127.84 122.35,128.2 123.81,128.2 125.01,127 125.4,127 125.62,127.22 125.62,127.49 v2(125.82,127.69)
  BOTTOM w0.079: v2(125.82,127.69) 125.53,127.98 125.53,128.1 125.29,128.34 124.43,128.34 123.96,128.81 123.23,128.81 122.9,129.14 122.7,129.19 122.34,129.19 122.27,129.16 122.17,129.16 122.1,129.18 121.89,129.28 121.65,129.29 U1.CA3
USB30_TX1+_C: length 1.5
  TOP w0.102: R432.2 22.21,92.62 22.28,92.55 22.68,92.55 C520.2
USB30_TX1+_C_R: length 9.5
  TOP w0.102: R432.1 C522.1 20,92.48 18.77,92.48 18.63,92.62 U6530.5 U6530.6 17.05,92.62 16.86,92.43 16.19,92.43 15.36,91.6 14.83,91.6 14.25,92.18 13.94,92.18 13.6,92.52 CN2.9
USB30_TX1-: length 143.2
  TOP w0.102: v1(34.51,83.86) 34.26,84.1 33.57,84.1 32.76,84.91 31.37,84.91 30.84,85.44 27.71,85.44 24.43,88.73 24.43,92.14 24.27,92.3 24.2,92.3 C519.1
  IN1 w0.102: v1(34.51,83.86) 34.28,84.09 33.94,84.09 33.45,84.58 33.45,87.47 37.93,91.95 55.35,91.95 56.57,93.18 57.14,93.18 58.25,94.29 68.12,94.29 68.49,94.66 69.35,94.66 73.3,98.61 73.3,101.29 76.17,104.16 76.6,104.16 79.85,107.42 81.17,107.42 82.8,109.05 84.03,109.05 85.09,110.11 89.29,110.11 90.14,110.96 92.72,110.96 93.73,111.96 93.73,114.27 96.05,116.59 101.3,116.59 102.01,117.3 106.1,117.3 107.06,118.25 113.52,118.25 114.44,119.17 118.01,119.17 118.36,119.52 118.36,120.02 120.38,122.04 122.12,122.04 122.51,122.43 122.51,124.04 121.89,124.67 121.89,126.94 121.79,127.04 121.79,127.93 122.26,128.4 123.89,128.4 125.09,127.2 125.31,127.2 125.41,127.3 125.41,127.46 v2(125.21,127.67)
  BOTTOM w0.079: U1.CA4 121.26,129.16 121.72,129.13 121.84,129.12 121.85,129.11 122.03,129.03 122.14,128.99 122.31,128.99 122.4,129.03 122.68,129.03 122.82,129 123.16,128.65 123.9,128.65 124.37,128.18 125.22,128.18 125.37,128.03 125.37,127.83 v2(125.21,127.67)
USB30_TX1-_C: length 1.5
  TOP w0.102: C519.2 22.85,92.35 22.45,92.35 22.21,92.12 R424.2
USB30_TX1-_C_R: length 9.5
  TOP w0.102: R424.1 C521.1 19.97,92.28 18.88,92.28 18.73,92.12 U6530.4 U6530.7 17.12,92.12 17.01,92.23 16.27,92.23 15.45,91.4 14.74,91.4 14.16,91.98 13.76,91.98 13.6,91.82 CN2.8
USB30_TX2+: length 126.5
  TOP w0.102: C531.1 25.6,108.09 25.6,107.9 25.69,107.82 27.13,107.82 27.71,107.24 27.71,104.62 27.92,104.42 v1(28.06,104.42)
  IN3 w0.102: v2(123.36,129.17) 123.44,129.17 123.63,128.98 123.63,128.86 123.36,128.59 121.92,128.59 120.31,126.98 120.31,125.4 120.18,125.28 120.18,124.8 120.31,124.68 120.31,124.21 119.62,123.52 119.62,122.35 118.4,121.13 118.4,118.77 117.67,118.04 114.52,118.04 112.7,116.21 110.98,116.21 109.06,114.29 108.43,114.29 107.54,113.41 107.54,112.6 107.89,112.25 107.89,111.76 107.69,111.56 107.69,110.62 107.31,110.24 107.31,109.42 106.73,108.84 105.51,108.84 104.07,107.39 101.85,107.39 101.31,106.86 101.31,105.31 99.44,103.44 97.04,103.44 96.94,103.34 96.2,103.34 95.16,104.37 89.8,104.37 89.41,104.76 83.16,104.76 82.72,104.32 76.96,104.32 76.78,104.14 71.81,104.14 68.42,100.74 66.08,100.74 64.92,99.58 58.07,99.58 57.77,99.88 51.2,99.88 49.86,101.22 36.77,101.22 36,101.99 32.55,101.99 31.67,102.87 28.68,102.87 27.75,103.8 27.75,104.3 27.86,104.42 v1(28.06,104.42)
  BOTTOM w0.079: v2(123.36,129.17) 123.36,129.44 123.28,129.52 122.95,129.52 U1.CA1
USB30_TX2+_C: length 1.5
  TOP w0.102: C531.2 24.77,108.03 24.59,108.03 R430.2
USB30_TX2+_C_R: length 12.2
  TOP w0.102: CN3.9 13.6,110.46 13.8,110.26 14.2,110.26 15.08,109.37 16,109.37 17.23,108.15 17.83,108.15 17.94,108.26 U6531.6 U6531.5 19.59,108.26 19.83,108.03 21.73,108.03 C533.1 22.7,108.02 22.85,108.02 R430.1
USB30_TX2-: length 126.5
  TOP w0.102: v1(27.3,104.42) 27.51,104.63 27.51,107.15 27.05,107.61 26.27,107.61 C530.1
  IN3 w0.102: v1(27.3,104.42) 27.56,104.15 27.56,103.72 28.6,102.68 31.59,102.68 32.47,101.8 35.92,101.8 36.69,101.03 49.78,101.03 51.12,99.69 57.69,99.69 57.99,99.39 65,99.39 66.16,100.55 68.49,100.55 71.89,103.95 76.86,103.95 77.04,104.13 82.8,104.13 83.24,104.57 89.33,104.57 89.72,104.18 95.08,104.18 96.12,103.15 97.02,103.15 97.12,103.25 99.52,103.25 101.51,105.24 101.51,106.78 101.93,107.2 104.14,107.2 105.59,108.65 106.81,108.65 107.5,109.34 107.5,110.16 107.88,110.54 107.88,111.48 108.08,111.68 108.08,112.33 107.73,112.68 107.73,113.33 108.5,114.1 109.14,114.1 111.06,116.02 112.78,116.02 114.6,117.85 117.75,117.85 118.59,118.69 118.59,121.05 119.81,122.27 119.81,123.44 120.5,124.13 120.5,124.76 120.37,124.88 120.37,125.2 120.5,125.33 120.5,126.9 122,128.4 123.44,128.4 123.82,128.78 123.82,129 v2(123.99,129.17)
  BOTTOM w0.079: v2(123.99,129.17) 123.85,129.17 123.52,129.51 123.52,129.51 123.35,129.68 122.76,129.68 122.53,129.55 122.53,129.55 122.31,129.43 U1.CA2
USB30_TX2-_C: length 1.5
  TOP w0.102: C530.2 24.77,107.83 24.58,107.83 R429.2
USB30_TX2-_C_R: length 12.2
  TOP w0.102: CN3.8 13.6,109.9 13.76,110.05 14.11,110.05 15,109.17 15.92,109.17 17.14,107.94 17.83,107.94 18.01,107.76 U6531.7 U6531.4 19.79,107.76 19.85,107.82 21.74,107.82 22.21,107.36 C532.1 22.66,107.81 23.19,107.81 23.34,107.67 R429.1
USB30_TX3+: length 147.4
  TOP w0.102: v1(25.65,70.07) 25.34,70.37 25.34,70.52 25.13,70.74 23.85,70.74 23.77,70.81 C20072.1
  IN1 w0.102: v2(123.41,130.18) 123.53,130.18 123.64,130.08 123.64,129.86 123.54,129.76 122.91,129.76 121.29,128.14 121.29,127.21 120.8,126.72 120.8,125.83 121.16,125.46 121.16,124.78 120.8,124.41 120.8,123.7 120.27,123.17 119.72,123.17 119.18,122.63 118.52,122.63 117.28,121.4 116.6,121.4 115.55,120.34 114.67,120.34 114.27,119.95 107.65,119.95 105.74,118.04 101.59,118.04 100.83,117.27 95.77,117.27 93.01,114.51 93.01,114.21 92.22,113.43 90.67,113.43 89.91,112.67 89.41,112.67 87.92,111.17 83.94,111.17 80.88,108.11 79.53,108.11 76.3,104.87 75.84,104.87 72.61,101.65 72.61,98.92 69.05,95.35 68.21,95.35 67.84,94.98 57.97,94.98 57.29,94.3 52.51,94.3 47.53,92.65 37.65,92.65 32.74,87.74 32.74,82.4 30.29,76.9 30.29,72.37 25.96,68.04 25.77,68.04 25.35,67.62 25.35,67 25.06,66.71 24.17,66.71 23.81,67.08 23.81,68.13 25.39,69.72 25.39,69.97 25.49,70.07 v1(25.65,70.07)
  BOTTOM w0.079: U1.BY3 121.79,129.89 121.59,129.89 121.51,129.97 121.51,130.19 121.61,130.29 121.71,130.29 121.81,130.39 121.98,130.39 122.12,130.25 122.12,130.18 122.3,130 123.34,130 123.41,130.06 v2(123.41,130.18)
USB30_TX3-: length 147.4
  TOP w0.102: v1(24.98,70.07) 25.14,70.23 25.14,70.43 25.04,70.53 24.05,70.53 C20073.1
  IN1 w0.102: v2(124.02,130.17) 123.84,129.99 123.84,129.78 123.62,129.56 123,129.56 121.49,128.05 121.49,127.12 121,126.64 121,125.91 121.36,125.55 121.36,124.69 121,124.33 121,123.62 120.35,122.97 119.8,122.97 119.26,122.43 118.6,122.43 117.36,121.19 116.68,121.19 115.63,120.14 114.75,120.14 114.36,119.74 107.73,119.74 105.82,117.83 101.68,117.83 100.91,117.07 95.85,117.07 93.21,114.42 93.21,114.13 92.31,113.22 90.75,113.22 89.99,112.46 89.5,112.46 88,110.96 84.02,110.96 80.96,107.9 79.61,107.9 76.38,104.67 75.92,104.67 72.82,101.56 72.82,98.83 69.13,95.15 68.29,95.15 67.92,94.78 58.05,94.78 57.37,94.1 52.54,94.1 47.57,92.45 37.73,92.45 32.94,87.66 32.94,82.36 30.49,76.86 30.49,72.28 26.04,67.83 25.85,67.83 25.55,67.53 25.55,66.91 25.14,66.51 24.09,66.51 23.6,66.99 23.6,68.22 25.18,69.8 25.18,69.87 v1(24.98,70.07)
  BOTTOM w0.079: v2(124.02,130.17) 123.69,129.84 123.29,129.84 123.29,129.84 122.64,129.84 122.52,129.73 121.51,129.73 U1.BY4
USB30_TX4+: length 111.6
  IN1 w0.102: v2(125.21,129.45) 125.08,129.45 124.94,129.3 124.94,129.17 125.18,128.93 126.15,128.93 126.56,128.51 126.56,127.12 126.09,126.65 126.09,124.96 127.28,123.77 127.28,122.21 127.8,121.69 127.8,119.09 127.24,118.52 127.24,116.74 127.64,116.34 127.64,114.88 127.44,114.67 127.44,114.32 127.71,114.05 127.71,113.44 127.43,113.16 127.43,112.3 130.28,109.46 132.27,109.46 133.83,107.89 138.82,107.89 139.19,107.51 142.46,107.51 143.04,106.94 153.12,106.94 154.22,108.04 158.75,108.04 159.81,109.09 164.21,109.09 164.52,109.39 167.41,109.39 167.66,109.65 172.42,109.65 174.57,111.8 185.01,111.8 185.37,111.44 193.3,111.44 194.4,110.35 196.21,110.35 197.07,109.5 201.64,109.5 203.76,111.62 203.76,114.58 203.52,114.82 203.34,114.82 v1(203.27,114.75)
  BOTTOM w0.079: v2(125.21,129.45) 124.97,129.45 124.9,129.52 124.9,130.33 124.55,130.69 123.17,130.69 123.04,130.56 U1.BW1
  BOTTOM w0.102: v1(203.27,114.75) 203.48,114.75 203.75,114.49 203.75,114.05 203.66,113.97 203.5,113.97 203.45,113.92 CN48.18
USB30_TX4-: length 111.6
  IN1 w0.102: v2(124.56,129.44) 124.74,129.26 124.74,129.09 125.1,128.72 126.06,128.72 126.36,128.43 126.36,127.2 125.89,126.73 125.89,124.87 127.08,123.69 127.08,122.13 127.6,121.6 127.6,119.17 127.04,118.61 127.04,116.66 127.44,116.26 127.44,114.96 127.23,114.76 127.23,114.24 127.51,113.96 127.51,113.52 127.23,113.24 127.23,112.22 130.19,109.25 132.18,109.25 133.75,107.69 138.73,107.69 139.11,107.31 142.37,107.31 142.95,106.73 153.2,106.73 154.3,107.83 158.84,107.83 159.89,108.89 164.3,108.89 164.6,109.19 167.49,109.19 167.74,109.45 172.5,109.45 174.66,111.6 184.93,111.6 185.29,111.24 193.22,111.24 194.31,110.15 196.13,110.15 196.98,109.29 201.73,109.29 203.97,111.53 203.97,114.59 v1(204.13,114.75)
  BOTTOM w0.079: U1.BW2 122.47,130.56 122.72,130.31 123.02,130.31 123.23,130.53 124.48,130.53 124.75,130.27 124.75,129.63 v2(124.56,129.44)
  BOTTOM w0.102: v1(204.13,114.75) 203.95,114.57 CN48.17
USB_BC_ON: length 248
  TOP w0.114: v1(24.21,102.71) 23.5,102 20.59,102 19.94,101.36 19.5,101.36 18.2,100.06 U14.4 ; v1(177.5,114.8) 177.5,114.56 175.44,112.49 174.98,112.49 173.81,111.33 173.05,111.33 172.33,112.05 169.61,112.05 v1(169.57,112.01) 165.49,112.01 165.36,111.88 U37.97
  IN2 w0.102: v1(24.21,102.71) 24.21,102.27 25.39,101.08 25.39,100.23 27.64,97.98 31.78,97.98 33.82,95.95 44.44,95.95 45.12,95.26 67.7,95.26 69.8,97.36 74.24,97.36 75,96.6 75.52,96.6 76.84,97.92 81.49,97.92 81.88,97.53 83.08,97.53 83.52,97.96 85.21,97.96 85.98,98.73 88.09,98.73 88.96,97.85 92.38,97.85 92.47,97.76 96.54,97.76 97.46,98.68 97.81,98.68 97.89,98.6 117.95,98.6 118.24,98.88 120.61,98.88 121.87,100.14 138.42,100.14 140.47,98.09 143.08,98.09 143.91,98.93 149.86,98.93 150.88,97.91 153.11,97.91 153.32,97.71 160.29,97.71 160.7,97.3 164.73,97.3 166.71,99.29 168.51,99.29 169.5,100.28 176.82,100.28 177.07,100.53 189.51,100.53 191.49,102.51 192.1,102.51 193.15,101.47 196.7,101.47 196.79,101.55 198.72,101.55 v1(199.74,102.57)
  IN3 w0.102: v1(177.5,114.8) 177.87,115.17 186.19,115.17 186.47,114.89 190.89,114.89 193.59,112.18 198.54,112.18 199.1,112.75 199.66,112.75 202.81,109.6 202.81,107.73 202.09,107.01 202.09,104.92 200.19,103.01 200.17,103.01 v1(199.74,102.57)
USB_CHARGE_ON: length 252.3
  TOP w0.114: v1(23.53,102.82) 22.98,102.27 20.48,102.27 19.83,101.62 18.99,101.62 R416.1 16.78,99.42 16.78,97.93 16.98,97.72 U14.5 ; U37.96 167.97,109.54 168.66,110.23 v1(169.01,110.23) ; v1(200.97,113.15) v1(200.97,112.39)
  IN2 w0.102: v1(23.53,102.82) 23.53,102.62 25.17,100.99 25.17,100.14 27.55,97.75 31.68,97.75 33.72,95.72 44.34,95.72 45.03,95.03 67.8,95.03 69.89,97.13 74.15,97.13 74.9,96.37 75.61,96.37 76.93,97.69 81.4,97.69 81.78,97.3 83.18,97.3 83.61,97.74 85.31,97.74 86.07,98.5 87.99,98.5 88.87,97.62 92.29,97.62 92.38,97.53 97.72,97.53 98.55,98.37 118.05,98.37 118.33,98.65 120.71,98.65 121.97,99.91 138.32,99.91 140.37,97.86 143.17,97.86 144.01,98.7 149.77,98.7 150.79,97.69 153.02,97.69 153.22,97.48 160.2,97.48 160.6,97.08 164.82,97.08 165.43,97.69 168.36,97.69 169.25,98.57 169.25,99.7 169.6,100.05 176.92,100.05 177.17,100.3 189.6,100.3 191.59,102.28 192,102.28 193.05,101.24 196.8,101.24 196.88,101.32 199.19,101.32 v1(200.45,102.58)
  IN3 w0.102: v1(200.45,102.58) 200.45,102.95 202.32,104.82 202.32,106.92 203.04,107.64 203.04,110.32 v1(200.97,112.39)
  IN4 w0.089: v1(200.97,112.39) 200.97,112.52 200.67,112.82 200.67,112.83 196.44,117.06 194.21,117.06 194.03,116.87 187.92,116.87 187.67,117.12 182.82,117.12 181.02,115.32 177.46,115.32 175.82,113.68 173.54,113.68 170.91,111.06 170.71,111.06 169.89,110.23 v1(169.01,110.23)
USB_CLT1: length 222.9
  TOP w0.114: U37.79 166.17,102.74 166.03,102.88 166.03,103.87 165.18,104.72 v1(165.16,104.72) ; U14.6 16.87,97.22 16.51,97.58 16.51,99.72 16.69,99.9 16.69,101.04 17.66,102.01 19.84,102.01 20.37,102.54 22,102.54 v1(22.2,102.74) 22.78,102.74 v1(22.87,102.83)
  IN1 w0.089: v1(165.16,104.72) 165.64,105.2 166.04,105.2 167.17,104.07 169.25,104.07 170.43,102.89 170.43,102.21 170.68,101.96 182.08,101.96 182.43,101.61 183.5,101.61 184.11,100.99 190.91,100.99 v1(191.72,101.8)
  IN2 w0.102: v1(191.72,101.8) 189.99,100.07 177.26,100.07 176.2,99.01 170.01,99.01 168.46,97.46 165.53,97.46 164.92,96.85 160.51,96.85 160.1,97.25 153.13,97.25 152.92,97.46 150.69,97.46 150.51,97.63 140.28,97.63 138.23,99.68 122.06,99.68 120.8,98.42 118.43,98.42 118.14,98.14 98.65,98.14 97.81,97.3 92.28,97.3 92.19,97.39 88.25,97.39 88.13,97.51 83.71,97.51 83.27,97.08 81.69,97.08 81.3,97.46 77.02,97.46 75.71,96.15 74.81,96.15 74.06,96.9 69.99,96.9 67.89,94.8 44.93,94.8 44.25,95.49 33.6,95.49 31.56,97.53 27.46,97.53 24.94,100.04 24.94,100.76 v1(22.87,102.83)
USB_OC0#: length 126.1
  TOP w0.114: U14.13 21.19,96.22 21.45,96.49 22.59,96.49 22.81,96.72 24.33,96.72 25.35,97.74 31.45,97.74 v1(32.36,98.65) ; R60.1 118.9,117.39 118.9,117.05 119.26,116.69 119.88,116.69 120.22,116.35 v1(120.22,115.9) 119.6,115.9 119.35,116.16 C6614.2 118.68,116 118.28,115.61 118.28,113.23 116.45,111.4 113.68,111.4 112.72,110.43 111.67,110.43 111,109.76 111,109.25 110.31,108.57 106.39,108.57 104.85,107.03 104.85,106.16 v1(104.32,105.64) v1(103.57,104.89)
  IN2 w0.102: v1(103.57,104.89) 102.92,104.24 101.76,104.24 100.23,102.71 97.62,102.71 97.1,102.19 95.69,102.19 95.4,102.48 92.13,102.48 91.57,101.92 88.3,101.92 87.64,101.26 87.08,101.26 86.69,100.87 84.93,100.87 84.65,100.58 83.26,100.58 82.05,101.78 81.14,101.78 80.35,101 78.76,101 78.44,100.68 77.24,100.68 76.76,100.2 72.89,100.2 71.03,98.34 70.1,98.34 67.48,95.72 45.34,95.72 44.65,96.4 34.6,96.4 v1(32.36,98.65)
  BOTTOM w0.079: 120.41,118.41 120.41,119.31 119.48,120.24 119.48,122.62 119.59,122.73 119.82,122.73 120.02,122.93 120.02,123.52 U1.CK6
  BOTTOM w0.114: 120.41,118.41 120.41,116.09 v1(120.22,115.9)
USB_OC1#: length 148.8
  TOP w0.114: v1(106.32,103.21) 106.59,103.48 114.58,103.48 116.1,105 116.1,106.11 116.53,106.53 116.6,106.53 v1(117.07,107.01) 116.84,107.24 116.84,107.99 117.65,108.81 119.98,108.81 120.65,109.48 121.49,109.48 121.81,109.8 124.36,109.8 125.14,110.58 125.14,111.36 125.53,111.75 125.53,112.28 125.74,112.49 126.81,112.49 128.49,114.17 128.49,114.54 127.52,115.52 126.6,115.52 126.38,115.74 126.38,116.36 125.49,117.24 125.49,117.5 125.12,117.87 C6613.2 124.49,118.19 124.63,118.34 R25439.1 124.15,118.64 123.87,118.92 v2(123.29,118.92)
  IN2 w0.102: v1(23.11,103.44) 23.3,103.25 23.75,103.25 23.85,103.15 24.38,103.15 24.67,102.86 24.67,102.13 25.62,101.18 25.62,100.33 27.74,98.21 31.9,98.21 33.94,96.18 44.53,96.18 45.22,95.49 67.57,95.49 70.2,98.11 71.12,98.11 72.98,99.97 82.49,99.97 82.87,100.35 84.74,100.35 85.03,100.64 86.78,100.64 87.18,101.03 87.74,101.03 88.23,101.53 95.08,101.53 95.52,101.96 97.19,101.96 97.71,102.49 100.33,102.49 101.09,103.25 106.28,103.25 v1(106.32,103.21)
  BOTTOM w0.079: v2(123.29,118.92) 123.29,119.04 121.44,120.89 121.44,121.46 121.26,121.64 121.26,122.53 121.01,122.78 120.75,122.78 120.68,122.86 120.68,123.24 120.17,123.74 U1.CK5
  BOTTOM w0.114: v1(23.11,103.44) 22.64,103.44 22.25,103.06 22.25,101.83 22.1,101.68 22.1,99.09 22.97,98.22 22.97,97.12 22.11,96.26 22.11,95.36 21.86,95.1 19.64,95.1 19.17,94.62 U15.3
USB_OC2#: length 122
  TOP w0.079: v2(118.69,124.48) 119.15,124.02 119.92,124.02 120,124.1 C6612.2 120.35,123.8 120.03,123.48 R25438.1
  IN4 w0.089: v2(118.69,124.48) 119.65,123.52 120.54,123.52 123.01,121.06 124.08,121.06 124.39,120.75 124.39,119.93 125.49,118.82 125.49,118.37 126.3,117.57 126.3,117.08 126.6,116.78 127.09,116.78 128.51,115.36 131.12,115.36 131.69,114.79 132.07,114.79 132.69,114.18 132.69,110.54 133.31,109.92 133.31,109.22 135.36,107.17 137.34,107.17 137.88,106.62 140.2,106.62 140.71,107.13 144.33,107.13 145.03,106.43 147.63,106.43 147.79,106.59 153.65,106.59 154.56,107.5 155.29,107.5 155.4,107.6 162.87,107.6 163.11,107.83 167,107.83 167.78,108.62 169.79,108.62 171.18,110.01 171.18,110.46 173.83,113.1 177.05,113.1 178.69,114.74 183.99,114.74 185.54,116.29 192.28,116.29 193.12,115.45 196.75,115.45 200.41,111.79 200.91,111.79 202.96,109.75 205.87,109.75 208.11,107.5 213.71,107.5 v1(214.97,106.24)
  BOTTOM w0.079: v2(118.69,124.48) 118.69,124.47 118.25,124.02 U1.CK8
  BOTTOM w0.114: U18.3 216.13,106.09 215.4,106.83 v1(215.27,106.83) 215.19,106.83 214.97,106.61 v1(214.97,106.24)
USB_OC3#: length 213.4
  TOP w0.079: 119.39,122.09 119.34,122.15 C96333.2 119.34,122.81 119.56,123.03 119.56,123.47 119.23,123.8 118.72,123.8 118.46,124.05
  TOP w0.102: 118.46,124.05 118.03,124.48 v2(117.73,124.48)
  TOP w0.114: 119.39,122.09 119.54,121.94 120.79,121.94 R25437.1 120.98,121.75 120.98,121.1 120.69,120.81 120.69,119.67 120.94,119.41 120.94,118.68 122.43,117.2 123.22,117.2 124.34,116.08 124.34,115.05 124.39,115 124.39,113.38 v1(124.64,113.13) 124.64,112.95 124.39,112.7 124.39,112.16 124.87,111.68 124.87,110.69 124.25,110.06 121.7,110.06 121.38,109.74 120.54,109.74 119.87,109.08 117.54,109.08 116.57,108.11 116.57,106.95 115.84,106.22 115.84,105.11 114.52,103.8 106.18,103.8 104.86,102.48 101.53,102.48 101.19,102.14 101.19,99.87 102.9,98.15 v1(102.9,97.29)
  IN1 w0.089: v1(27.18,50.3) 24.99,48.11 24.99,47.45 23.62,46.07 17.18,46.07 16.66,46.59 15.54,46.59 14.3,45.35 5.73,45.35 v1(3.81,47.27)
  IN2 w0.102: v1(27.18,50.3) 26.66,50.81 26.66,53.48 27.28,54.1 27.28,58.17 27.13,58.32 27.13,62.74 29.15,64.76 29.15,85.59 25.61,89.13 25.61,93.22 28.28,95.89 32.15,95.89 34.94,93.09 50.59,93.09 51.56,94.06 68.12,94.06 69.04,94.98 73.5,94.98 73.98,95.46 75.99,95.46 77.25,96.72 77.72,96.72 78.46,95.98 92.03,95.98 92.66,96.62 98.09,96.62 98.63,97.15 100.95,97.15 101.06,97.05 102.66,97.05 v1(102.9,97.29)
  BOTTOM w0.079: U1.CK9 117.57,124.17 117.73,124.34 117.73,124.45 117.73,124.46 v2(117.73,124.48)
  BOTTOM w0.114: U6523.10 3.31,50.43 2.78,49.9 2.78,47.6 C96322.2 v1(3.81,47.27)
