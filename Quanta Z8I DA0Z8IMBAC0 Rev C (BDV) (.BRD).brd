# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_CDZ: length 6.2
  BOTTOM w0.114: U40.13 30.26,57.56 29.85,57.15 29.42,57.15 v1(29.04,56.77) 28.76,56.77 28.6,56.61 28.6,55.5 29.36,54.74 Q6565.3
SD_CDZ_R: length 6.8
  TOP w0.114: CN62.11 33.81,55.68 33.45,56.04 v1(33.45,56.83)
  BOTTOM w0.114: R67539.2 30.23,55.9 31.01,55.12 31.4,55.12 32.41,56.12 32.41,56.35 32.89,56.83 v1(33.45,56.83)
SD_CLK: length 33.7
  IN1 w0.089: v1(29.26,58.31) 30.39,58.31 30.59,58.11 30.59,57.84 30.5,57.75 29.94,57.75 29.85,57.66 29.85,57.48 29.94,57.39 30.5,57.39 30.59,57.3 30.59,53.47 30.68,53.38 30.95,53.38 31.04,53.29 31.04,53.12 30.95,53.03 30.68,53.03 30.59,52.94 30.59,52.76 30.68,52.67 31.79,52.67 31.88,52.58 31.88,52.41 31.79,52.32 30.68,52.32 30.59,52.23 30.59,52.05 30.68,51.96 31.79,51.96 31.88,51.87 31.88,51.69 31.79,51.61 30.68,51.61 30.59,51.52 30.59,51.34 30.68,51.25 31.79,51.25 31.88,51.16 31.88,50.98 31.79,50.89 30.68,50.89 30.59,50.81 30.59,50.63 30.68,50.54 31.79,50.54 31.88,50.45 31.88,50.27 31.79,50.18 30.68,50.18 30.59,50.09 30.59,49.92 30.68,49.83 31.79,49.83 31.88,49.74 31.88,49.56 31.79,49.47 30.68,49.47 30.59,49.38 30.59,48.93 30.72,48.79 32.58,48.79 32.7,48.67 32.7,48.45 32.58,48.33 30.88,48.33 30.78,48.22 30.78,47.9 30.87,47.81 32.65,47.81 33.2,48.36 v1(33.33,48.36)
  BOTTOM w0.114: v1(33.33,48.36) 33.33,48.42 R67532.1 ; U40.15 v1(29.26,58.31)
SD_CLK_R: length 3.7
  TOP w0.114: v1(33.48,47.71) 33.48,47.52 33.83,47.18 CN62.6
  BOTTOM w0.114: v1(33.48,47.71) 32.77,47.71 C1648.1 32.05,48.43 R67532.2
SD_CMD: length 35.9
  IN1 w0.089: v1(24.96,57.97) 26.36,57.97 27.78,56.55 27.78,55.91 29.06,54.63 29.06,41.88 29.2,41.74 31.48,41.74 31.6,41.63 31.6,41.33 31.48,41.21 30.1,41.21 30.01,41.12 30.01,40.84 30.14,40.72 31.12,40.72 31.21,40.63 31.21,40.47 31.08,40.34 30.13,40.34 30.01,40.22 30.01,39.87 30.21,39.68 32.66,39.68 v1(33.07,39.27)
  BOTTOM w0.114: v1(24.96,57.97) 26.41,57.97 26.57,57.82 C1647.1 27.76,58.47 U40.18 ; R67899.1 31.54,39.65 31.93,39.27 v1(33.07,39.27)
SD_D0/MS_D6: length 37.1
  IN1 w0.089: v1(33.23,49.6) 34.01,50.39 34.01,53.29 33.81,53.49 32.24,53.49 31.85,53.88 31.85,54.56 31.98,54.68 33.74,54.68 33.94,54.88 33.94,55.74 33.76,55.92 31.54,55.92 31.45,56 31.45,56.31 31.55,56.41 33.83,56.41 33.94,56.51 33.94,57.15 33.82,57.27 31.55,57.27 31.45,57.38 31.45,57.64 31.54,57.73 32.57,57.73 32.68,57.83 32.68,58.06 32.59,58.15 31.53,58.15 31.45,58.22 31.45,58.48 31.54,58.57 32.8,58.57 32.86,58.64 32.86,58.92 32.79,58.99 31.53,58.99 31.45,59.07 31.45,60.37 31.54,60.47 31.85,60.47 31.93,60.39 31.93,59.54 32.02,59.45 33.86,59.45 33.95,59.37 33.95,58.39 33.86,58.3 v1(33.36,58.3)
  BOTTOM w0.114: U40.11 32.19,60.61 C1643.1 33.46,59.35 33.46,58.4 v1(33.36,58.3) ; v1(33.23,49.6) 33.2,49.58 32.67,49.58 32.43,49.81 R67897.1
SD_D1/MS_D7: length 36.7
  IN1 w0.089: v1(33.81,62.27) 33.74,62.34 31.15,62.34 31.04,62.23 31.04,62.04 31.15,61.93 33.45,61.93 33.54,61.84 33.54,61.64 33.48,61.57 30.6,61.57 30.52,61.49 30.52,61.23 30.6,61.16 33.48,61.16 33.59,61.04 33.59,60.85 33.5,60.76 30.55,60.76 30.44,60.64 30.44,60.42 30.56,60.3 31.08,60.3 31.16,60.22 31.16,59.92 31.08,59.85 30.53,59.85 30.47,59.78 30.47,59.51 30.55,59.43 31.09,59.43 31.16,59.36 31.16,55.72 31.26,55.62 32.86,55.62 32.98,55.5 32.98,55.16 32.9,55.08 31.3,55.08 31.16,54.93 31.16,54.16 32.2,53.11 32.44,53.11 32.69,52.86 32.69,52.24 33.2,51.74 v1(33.46,51.74)
  BOTTOM w0.114: v1(33.81,62.27) 33.79,62.27 32.68,61.17 C1644.1 31.11,61.11 U40.10 ; R67898.1 31.97,51.16 32.19,50.95 32.85,50.95 33.4,51.51 33.4,51.69 v1(33.46,51.74)
SD_D2/MS_D5: length 36.3
  IN1 w0.089: v1(24.14,59.26) 24.14,57.81 24.67,57.28 26.23,57.28 27.2,56.31 27.2,55.67 28.48,54.39 28.48,39.47 31.98,35.96 v1(33.07,35.96)
  BOTTOM w0.114: R67895.1 31.54,35.7 31.8,35.96 v1(33.07,35.96) ; U40.21 26.09,61.11 25.8,61.4 23.93,61.4 C1645.1 23.41,60.08 24.14,59.35 v1(24.14,59.26)
SD_D3/MS_D4: length 35.6
  IN1 w0.089: v1(24.95,60.02) 24.58,59.64 24.58,58.91 24.44,58.77 24.44,57.93 24.79,57.57 26.35,57.57 27.49,56.43 27.49,55.79 28.77,54.51 28.77,41.56 28.88,41.45 29.52,41.45 29.6,41.37 29.6,41.06 29.53,40.99 28.89,40.99 28.77,40.87 28.77,40.62 28.88,40.51 29.45,40.51 29.58,40.38 29.58,40.18 29.44,40.04 28.88,40.04 28.77,39.92 28.77,39.6 29.88,38.49 32.83,38.49 v1(33.07,38.25)
  BOTTOM w0.114: R67896.1 31.54,37.99 31.8,38.25 v1(33.07,38.25) ; U40.20 25.46,60.61 C1646.1 25.29,60.36 v1(24.95,60.02)
SD_WP/MS_D1: length 10.7
  BOTTOM w0.114: U40.8 32.03,62.11 32.77,62.86 34.13,62.86 34.63,62.36 34.63,59.52 v1(34.14,59.03) 33.89,58.77 33.89,57.88 33.73,57.73 33.28,57.73 33.09,57.92 Q6570.3
SD_WP/MS_D1_R: length 3
  TOP w0.114: v1(33.46,54) 33.63,54.18 CN62.10
  BOTTOM w0.114: v1(33.46,54) 33.81,54.35 v1(33.81,54.56) 33.35,54.56 33.15,54.76 R67887.2
SDA_GSENSOR: length 34.3
  TOP w0.114: R67873.2 148.3,216.2 v1(148.66,216.56) 148.99,216.89 149.88,216.89 150.32,216.46 Q6567.3 ; v1(158.09,213.81) 158.09,213.52 R25637.2 ; C20136.1 142.84,210.93 143.74,210.93 TP13175.1 144.14,210.53 144.36,210.53 v1(144.82,210.07)
  TOP w0.254: U6515.2 142.3,212.49 142.61,212.18 142.61,211.7 142.47,211.55 C20136.1
  IN1 w0.089: v1(144.82,210.07) 144.85,210.07 145.26,210.48 146.77,210.48 147.62,209.63 149.2,209.63 150.2,210.62 150.41,210.62 150.93,211.14 150.93,213.78 148.66,216.05 v1(148.66,216.56) 150.77,216.56 152.41,214.92 156.21,214.92 157.28,213.85 158.03,213.85 158.07,213.81 v1(158.09,213.81)
SDA_GSENSOR_R: length 4.9
  TOP w0.079: U6516.E4 155.75,214.64 155.88,214.78 156.24,214.78
  TOP w0.114: 156.24,214.78 156.71,214.78 157.1,215.16 R25635.2 156.8,214.31 v1(156.8,214.07) 156.8,214.04 R25637.1
SDA_SENSOR_HUB: length 99.8
  TOP w0.079: 154.61,215.64 U6516.C5
  TOP w0.114: v1(155.11,216.41) 154.61,215.92 154.61,215.64
  IN1 w0.089: v1(155.11,216.41) 157.21,216.41 159.06,214.57 159.06,211.39 157.76,210.09 154.62,210.09 154.29,209.76 152.03,209.76 151.71,209.44 150.69,209.44 150.32,209.08 150.32,208.39 148.15,206.22 140.98,206.22 140.06,205.3 135.32,205.3 134.95,204.93 134.95,204.44 134.65,204.14 129.84,204.14 127.72,206.26 127.72,206.72 127.13,207.32 125.98,207.32 125.05,206.38 125.05,205.98 124.61,205.54 124.61,205.18 124.17,204.74 123.65,204.74 121.92,203.01 121.92,197.65 120.88,196.61 120.88,194.97 118.66,192.75 118.66,190.85 119.44,190.07 119.44,185.56 118.9,185.01 118.52,185.01 116.51,183 110.84,183 110.37,182.53 109.44,182.53 109.32,182.66 108.21,182.66 107.97,182.9 107.19,182.9 106.84,182.56 104.09,182.56 103.75,182.89 v1(102.29,182.89)
  BOTTOM w0.114: R25629.2 R25630.2 106.1,178.91 v1(105.69,179.32) 104.44,180.58 104.44,181.14 104.04,181.53 Q6539.3 104.04,182.6 103.75,182.89 v1(102.29,182.89)
SDREG: length 3.1
  BOTTOM w0.305: U40.6 30.26,63.82 30.75,64.31 v1(31.35,64.31) 31.37,64.33 C1651.1
SDVO_CLK: length 136.9
  TOP w0.102: R494.2 31.18,124.46 31.41,124.69 32.09,124.69 32.21,124.57 R67596.1 32.21,124.12 31.97,123.89 v1(31.97,123.58)
  IN3 w0.102: v1(31.97,123.58) 32.62,122.93 32.62,120.61 32.39,120.38 32.39,118.61 31.42,117.64 31.06,117.64 24.34,110.92 24.34,106.31 25.78,104.87 26.71,104.87 26.79,104.95 28.43,104.95 29.97,103.41 31.96,103.41 32.9,102.47 36.2,102.47 36.4,102.27 44.94,102.27 45.51,101.7 50.17,101.7 50.83,101.04 54.27,101.04 54.39,100.92 57.48,100.92 58.32,100.07 64.55,100.07 66.05,101.57 66.94,101.57 67.48,102.11 68.89,102.11 71.41,104.62 76.58,104.62 76.76,104.8 82.52,104.8 82.96,105.24 86.39,105.24 86.53,105.38 90.4,105.38 90.71,105.08 92.4,105.08 92.67,105.34 95.96,105.34 96.38,105.77 99.12,105.77 99.61,106.25 99.61,106.37 100.15,106.91 100.15,107.77 101.75,109.37 101.75,110.43 103.33,112.01 103.83,112.01 105.29,113.47 105.68,113.47 107.67,115.46 107.67,116.57 108.74,117.64 108.74,117.92 109.75,118.93 109.75,119.8 110.06,120.1 110.06,120.32 110.86,121.13 115.8,121.13 117.3,122.63 117.3,126.55 v2(117.95,127.2)
  BOTTOM w0.079: U1.CC8 118.22,127.46 v2(117.95,127.2)
SDVO_CLK_R: length 33
  TOP w0.114: R67870.2 32.93,124.29 v1(33.23,123.98) ; v1(21.96,146.05) 21.64,145.73 21.64,145.03 21.92,144.75 U23.7
  IN3 w0.102: v1(33.23,123.98) 33.23,124.18 33.01,124.41 32.57,124.41 28.03,128.95 23.94,128.95 22.67,130.22 22.67,133.38 23.37,134.08 23.37,135.56 23.17,135.76 23.17,139.18 21.66,140.69 21.66,145.75 v1(21.96,146.05)
SDVO_DATA: length 134.7
  TOP w0.102: v1(32.65,123.61) 32.65,123.6 32.21,123.16 R67595.1 32.21,122.61 32.42,122.39 R502.2
  IN3 w0.102: v1(32.65,123.61) 32.65,123.47 33.02,123.1 33.02,120.44 32.79,120.21 32.79,118.44 31.58,117.24 31.23,117.24 24.75,110.75 24.75,106.48 25.95,105.28 26.53,105.28 26.61,105.36 28.62,105.36 30.17,103.82 32.13,103.82 33.07,102.88 36.37,102.88 36.57,102.68 45.11,102.68 45.68,102.11 50.33,102.11 50.99,101.45 54.43,101.45 54.54,101.34 57.62,101.34 58.49,100.48 64.38,100.48 65.88,101.98 66.78,101.98 67.31,102.51 68.73,102.51 71.24,105.03 76.41,105.03 76.59,105.21 82.36,105.21 82.79,105.65 86.22,105.65 86.36,105.79 90.71,105.79 91.01,105.48 92.23,105.48 92.5,105.75 95.79,105.75 96.22,106.17 98.95,106.17 99.2,106.42 99.2,106.54 99.74,107.08 99.74,107.94 101.34,109.54 101.34,110.59 103.16,112.41 103.66,112.41 105.12,113.88 105.51,113.88 107.27,115.63 107.27,116.74 108.33,117.8 108.33,118.09 109.35,119.1 109.35,119.97 109.65,120.27 109.65,120.53 110.62,121.49 115.59,121.49 116.99,122.89 116.99,126.91 v2(117.3,127.22)
  BOTTOM w0.079: U1.CC9 117.3,127.45 v2(117.3,127.22)
SDVO_DATA_R: length 32.7
  TOP w0.114: v1(22.11,145.36) 22.42,145.05 U23.6 ; v1(33.49,123.33) 33.1,122.94 R67869.2
  IN3 w0.102: v1(33.49,123.33) 33.67,123.51 33.67,124.21 33.24,124.63 32.67,124.63 28.12,129.18 24.03,129.18 22.9,130.31 22.9,133.28 23.6,133.99 23.6,135.66 23.4,135.85 23.4,139.28 21.89,140.79 21.89,145.14 v1(22.11,145.36)
SENSEA: length 3.3
  BOTTOM w0.203: U20.13 21.81,28.81 21.93,28.68 22.5,28.68 v1(22.61,28.57) 22.61,27.92 R451.1
  BOTTOM w0.381: R452.1 23.4,27.72 R451.1
SERIRQ: length 93.8
  TOP w0.079: 108.64,122.09 108.64,122.96 108.74,123.06 108.74,126.05 108.47,126.32 108.47,127.09 107.33,128.24 107.33,129.95 106.53,130.74 106.04,130.74 105.51,130.22 v2(105.51,130.12)
  TOP w0.114: v2(108.17,115.63) 108.6,115.63 R25520.1 109.12,117.19 v1(109.1,117.22) 109.17,117.29 109.17,117.83 109.29,117.95 109.29,119.69 108.64,120.35 108.64,122.09 ; U37.5 150.43,107.94 150.14,108.23 149.95,108.23 149.16,109.01 v1(149.08,109.01)
  IN2 w0.102: v1(149.08,109.01) 148.52,109.01 147.63,108.12 145.67,108.12 144.45,109.34 142.46,109.34 141.27,108.15 137.07,108.15 134.83,110.39 133.12,110.39 132.2,109.47 128.98,109.47 128.13,110.33 123.71,110.33 121.59,112.45 119.68,112.45 119.28,112.85 119.28,113.67 118.4,114.55 114.43,114.55 111.14,117.84 109.45,117.84 109.18,118.11 104.76,118.11 103.79,119.08 103.79,120.08 104.19,120.48 104.19,121.18 103.95,121.42 102.16,121.42 100.79,122.79 100.79,124.48 102.25,125.95 102.25,129.35 102.69,129.79 105.18,129.79 v2(105.51,130.12)
  BOTTOM w0.079: U1.BV28 105.81,130.66 105.5,130.35 105.5,130.13 v2(105.51,130.12)
  BOTTOM w0.114: v2(108.17,115.63) 107.86,115.63 107.65,115.42 107.65,113.49 R94.1
SIO_EXT_SCI#: length 55.8
  TOP w0.114: v1(154.24,99.14) 154.61,99.51 154.61,101.01 154.35,101.27 152.63,101.27 152.09,100.74 U37.23
  IN1 w0.089: v1(136.06,99.21) 136.57,98.7 138.85,98.7 139.53,98.02 143.48,98.02 144.11,98.65 144.74,98.65 145.57,97.82 153.3,97.82 154.24,98.76 v1(154.24,99.14)
  BOTTOM w0.114: R25448.2 121.93,114.08 R25436.1 122.59,114.08 122.81,113.86 122.81,111.01 123.26,110.56 127.77,110.56 128.06,110.26 133.18,110.26 134.05,109.39 135.72,109.39 v1(136.22,108.89) 137.07,108.04 137.07,106.46 137.98,105.56 137.98,101.17 136.06,99.26 v1(136.06,99.21)
SIO_EXT_SMI#: length 12.2
  BOTTOM w0.079: 108.98,117.9 108.98,118.53 109.45,119 109.45,119.84 109.55,119.94 109.55,120.58 109.26,120.87 109.26,121.25 109.28,121.35 109.28,121.55 109.26,121.6 109.26,121.89 109.28,122 109.28,122.59 109.32,122.63 109.32,122.91 109.21,123.02 109.21,125.17 U1.CG22
  BOTTOM w0.114: R98.1 108.82,114.53 108.82,116.86 108.98,117.03 108.98,117.9
SIO_RCIN#: length 88.4
  TOP w0.079: v2(104.93,130.2) 104.93,130.09 105.26,129.76 105.66,129.76 105.89,129.99 105.89,130.36 106.11,130.57 106.46,130.57 107.16,129.88 107.16,128.17 108.3,127.03 108.3,126.25 108.57,125.98 108.57,123.15 107.83,122.41 107.83,122.09
  TOP w0.114: U37.4 152.21,108.34 152.31,108.24 152.58,108.24 154.24,106.58 155.86,106.58 157.42,105.03 v1(158.45,105.03) ; R100.1 107.43,111.28 v2(107.43,111.89) 107.43,112.31 106.69,113.05 106.69,113.39 107.44,114.15 107.44,119.29 107.83,119.68 107.83,122.09
  IN1 w0.089: v2(107.43,111.89) 107.87,111.45 110.28,111.45 110.55,111.72 111.5,111.72 111.73,111.49 117.4,111.49 117.9,112 119.43,112 122.9,108.52 127.9,108.52 130.71,105.71 137.03,105.71 137.63,105.11 138.08,105.11 138.9,104.3 146.77,104.3 147.52,103.55 148.84,103.55 149.46,104.16 151.33,104.16 151.93,104.76 158.18,104.76 v1(158.45,105.03)
  BOTTOM w0.079: v2(104.93,130.2) 104.93,130.3 105.18,130.54 U1.BV29
SLEEVE: length 24.3
  IN3 w1.016: 5.63,15.15 6.07,15.15 6.59,15.67 8.76,15.67 9.3,15.13 10.65,15.13 11.8,16.28 13.76,16.28 15.14,17.65 15.14,17.83 15.78,18.46 15.78,18.69 16.34,19.25 16.68,19.25 17.21,19.78 17.21,20.12 17.33,20.25 17.67,20.25 18.19,20.77 18.19,21.1 18.72,21.64 18.78,21.64 19.3,22.16 19.3,22.21 20.62,23.54 20.62,24.81 19.3,26.13
  BOTTOM w0.203: v1(19.66,27.81) 19.81,27.96 U20.18
  vias: v1(3.96,15.47) v1(4.64,15.47) v1(19.08,27.48) v1(19.66,27.15)
SLP_A#: length 5.1
  BOTTOM w0.079: TP7.1 96.89,130.48 98.62,130.48 99.53,131.39 100.14,131.39 U1.BU37
SLP_LAN#: length 148.2
  TOP w0.079: v2(104.19,132.95) 104.17,132.92 103,132.92 101.06,134.86
  TOP w0.114: R67507.1 v1(33.33,174.29) ; 101.06,134.86 100.22,135.7 97.8,135.7 97.4,136.09 93.22,136.09 92.24,135.1 91.7,135.1 88.74,138.07 86.8,138.07 85.72,136.99 v1(76.56,136.99) 76.35,136.99 v1(75.1,135.75)
  IN2 w0.102: v1(71.69,178.14) 70.9,178.14 70.39,177.63 69.73,177.63 67.97,175.87 65.83,175.87 v1(64.44,177.26)
  BOTTOM w0.079: U1.BT31 103.88,132.63 v2(104.19,132.95)
  BOTTOM w0.114: v1(64.44,177.26) 64.44,177.17 63.27,176 46.56,176 43,172.44 43,168.4 42.78,168.18 42.78,162.71 41.35,161.28 36.05,161.28 35.36,161.97 32.62,161.97 31.82,162.77 31.82,164.06 30.99,164.9 30.99,165.24 28.82,167.4 28.82,170.8 32.31,174.29 v1(33.33,174.29) ; v1(71.69,178.14) 71.69,177.32 74.08,174.92 74.59,174.92 75.54,173.97 75.54,169.44 75.1,169.01 v1(75.1,135.75)
SLP_S5#: length 19
  TOP w0.079: v2(105.41,132) 104.97,132.44 104.09,132.44 103.85,132.68 102.86,132.68 100.87,134.67
  TOP w0.114: 100.87,134.67 100.19,135.35 97.56,135.35 97.1,135.81 93.33,135.81 92.33,134.81 91.62,134.81 90.05,136.38 TP3.1
  BOTTOM w0.089: U1.BT29 105.41,132.25 v2(105.41,132)
SLP_SUS#_EC: length 22.5
  TOP w0.079: 100.74,133.86 101.77,132.82 102.24,132.82 102.72,132.35 103.71,132.35 103.87,132.18 103.87,131.74 104,131.62 104.46,131.62 104.8,131.28 v2(104.8,131.18)
  TOP w0.114: TP9027.1 86.92,136.8 88.07,135.65 90.03,135.65 91.4,134.27 92.55,134.27 93.55,135.28 96.88,135.28 98.08,134.08 100.52,134.08 100.74,133.86
  BOTTOM w0.079: U1.BU29 105.16,131.57 104.8,131.21 v2(104.8,131.18)
SM_RCOMP_0: length 1.3
  TOP w0.381: R28.1 106.7,134.77 v2(106.3,134.77)
  BOTTOM w0.254: U1.BN28 105.84,134.31 v2(106.3,134.77)
SM_RCOMP_1: length 1.2
  TOP w0.381: R29.2 107.23,133.85 v2(106.78,133.85)
  BOTTOM w0.254: U1.BN27 106.48,134.15 v2(106.78,133.85)
SM_RCOMP_2: length 1.7
  TOP w0.381: v2(104.8,134.69) 104.44,135.05 R30.1
  BOTTOM w0.254: U1.BN29 105.18,134.31 v2(104.8,134.69)
SM_VREF: length 128.5
  TOP w0.508: R242.1 44.26,120.78 C266.1 v1(43.35,120.01)
  IN3 w0.508: v1(43.35,120.01) 43.59,120.01 44.79,121.2 44.79,122.16 45.26,122.63 52.87,122.63 54.65,124.41 55.55,124.41 56.12,124.98 56.12,133.44 55.51,134.04 55.51,137.94 55.95,138.38 55.95,152.93 55.44,153.43 54.72,153.43 53.87,154.28 53.87,171.11 56.76,174 58.49,174 59.66,175.17 66.57,175.17 67.54,176.14 68.65,176.14 69.01,176.5 74.02,176.5 74.38,176.14 80.8,176.14 82.5,177.83 v2(90.63,177.83)
  BOTTOM w0.203: 99.68,164.02 99.68,163.56 100.04,163.2 100.34,163.2 100.66,162.88 U1.F36
  BOTTOM w0.508: v2(90.63,177.83) 90.63,175.99 90.14,175.5 90.14,168.71 93.29,165.56 93.91,165.56 v1(94.79,164.68) 95.13,164.34 97.7,164.34 97.97,164.61 99.09,164.61 99.68,164.02
SMB_ME1_CLK: length 9.7
  TOP w0.114: Q6568.4 116.83,116.23 R67881.1 115.39,116.52 115.05,116.52 v2(114.87,116.35)
  BOTTOM w0.079: U1.CN15 114.07,121.9 113.89,121.72 113.8,121.52 113.8,121.33 113.85,121.24 113.85,120.88 113.51,120.54 113.51,119.88 114.8,118.59 114.8,118.42
  BOTTOM w0.102: 114.8,118.42 114.99,118.23 114.99,117.92 114.72,117.65 114.72,117.16 114.87,117.01 114.87,116.76
  BOTTOM w0.114: v2(114.87,116.35) 114.87,116.76
SMB_ME1_DAT: length 12.1
  TOP w0.114: v2(114.35,116) 114.35,115.79 114.02,115.45 114.02,114.5 R67882.1 115.29,114.05 Q6568.1
  BOTTOM w0.079: U1.CM15 113.78,122.44 113.78,121.89 113.64,121.56 113.64,121.3 113.68,121.2 113.68,120.95 113.33,120.6 113.33,119.82 114.42,118.73 114.42,118.41
  BOTTOM w0.102: 114.42,118.41 114.56,118.28 114.56,117.76 114.37,117.57 114.32,117.57 113.92,117.18 113.92,117.03
  BOTTOM w0.114: R104.2 114.13,115.77 v2(114.35,116) 113.92,116.43 113.92,117.03
SMB_PCH_CLK: length 17
  TOP w0.102: 117.83,121.36 117.68,121.51 v1(116.47,121.51) 115.64,121.51 114.45,122.7 114.45,123.31 v2(114.3,123.46)
  TOP w0.114: Q3.6 121.54,112.44 121.33,112.65 121.33,113.1 122.11,113.88 R95.1 122.11,115.69 121.55,116.25 121.55,117.15 120.24,118.46 120.24,119.11 119.12,120.23 118.96,120.23 117.83,121.36
  BOTTOM w0.079: v2(114.3,123.46) 114.35,123.46 114.59,123.71 U1.CK14
SMB_PCH_DAT: length 19.5
  TOP w0.102: 118.14,118.99 118.04,118.99 117.22,119.8 117.22,119.88 117.02,120.09 116.64,120.09 116.07,120.66 116.07,120.82 114.2,122.68 114.2,122.98 113.92,123.26 113.92,124.23 114.3,124.61 v2(114.3,124.63)
  TOP w0.114: 118.14,118.99 v1(118.77,118.99) 118.85,119.07 119.62,119.07 120,118.68 120,118.39 121.34,117.06 121.34,116.16 121.54,115.96 R97.1 121.54,113.82 120.97,113.25 120.97,111.31 120.8,111.14 Q3.3
  BOTTOM w0.079: v2(114.3,124.63) 113.93,125.01 U1.CH15
SMB_RUN_CLK: length 167
  TOP w0.114: v1(106.53,106.91) 106.6,106.84 106.6,106.59 107.59,105.6 111.02,105.6 111.55,105.07 113.96,105.07 114.57,105.67 114.57,106.82 114.32,107.06 114.32,109.29 114.88,109.84 116.37,109.84 118.52,112 R115.2 119.52,112 119.96,112.44 Q3.1 ; v1(33.51,147.05) 33.33,147.23 R25531.2
  IN1 w0.089: v1(43.31,146.94) 43.31,146.85 40.33,143.87 40.33,133.12 39.49,132.29 37.63,132.29 35.96,130.62 35.96,128.09 37.61,126.44 39.68,126.44 42.92,123.2 43.79,123.2 44.78,122.21 44.78,105.7 45.39,105.09 49.01,105.09 49.36,105.44 v1(49.59,105.44) 50.32,105.44 51.36,106.47 55.21,106.47 57.02,104.65 57.02,104.49 57.67,103.84 58.62,103.84 v1(59.34,104.56)
  IN4 w0.089: v1(106.53,106.91) 106.35,107.09 105.77,107.09 104.88,107.98 100.29,107.98 99.73,108.54 94.56,108.54 92.61,110.49 92.33,110.49 91.37,111.45 90.53,111.45 87.96,114.02 87.96,115.7 87,116.66 85.48,116.66 74.83,106.01 65.21,106.01 64.37,105.17 60.08,105.17 59.47,104.56 v1(59.34,104.56)
  BOTTOM w0.114: v1(43.31,146.94) 41.45,146.94 40.45,145.95 35.23,145.95 34.27,146.92 33.65,146.92 v1(33.51,147.05) ; JDIM02.253 63.45,106.57 62.99,106.11 62.99,105.31 62.49,104.81 59.83,104.81 59.58,104.56 v1(59.34,104.56) ; JDIM1.253 51.44,106.57 50.31,105.44 v1(49.59,105.44)
SMB_RUN_DAT: length 165.5
  TOP w0.114: v1(32.31,147.04) R25530.2 ; Q3.4 121.5,111.14 121,110.65 120.17,110.65 119.52,110 R114.2 v1(117.19,110) 116.66,109.47 115.03,109.47 114.69,109.13 114.69,107.22 114.94,106.97 114.94,105.52 114.12,104.7 111.4,104.7 110.87,105.23 107.28,105.23 v1(105.98,106.52)
  IN1 w0.089: v1(58.64,104.53) 58.3,104.19 57.81,104.19 57.37,104.63 57.37,104.8 55.35,106.81 50.04,106.81 v1(49.06,105.83) 48.66,105.43 45.53,105.43 45.13,105.84 45.13,122.35 43.93,123.54 43.06,123.54 39.82,126.79 37.75,126.79 36.3,128.24 36.3,130.47 37.77,131.94 39.64,131.94 40.67,132.98 40.67,143.64 v1(43.31,146.28)
  IN4 w0.089: v1(58.64,104.53) 59.03,104.13 59.53,104.13 60.22,104.83 64.52,104.83 65.35,105.66 74.97,105.66 85.62,116.32 86.86,116.32 87.62,115.56 87.62,113.88 90.39,111.11 91.22,111.11 92.19,110.14 92.47,110.14 94.42,108.2 99.59,108.2 100.15,107.63 104.74,107.63 105.85,106.52 v1(105.98,106.52)
  BOTTOM w0.114: v1(58.64,104.53) 57.67,105.5 57.67,106.13 57.48,106.32 JDIM02.254 ; JDIM1.254 45.57,106.32 45.73,106.48 47.02,106.48 47.67,105.83 v1(49.06,105.83) ; v1(43.31,146.28) 42.85,146.28 42.55,146.58 41.6,146.58 40.6,145.58 35.08,145.58 34.11,146.55 32.8,146.55 v1(32.31,147.04)
SMDDR_VREF_DQ1_M3: length 113.1
  TOP w0.508: R67514.1 56.6,123.09 C20130.1 v2(55.34,121.81)
  IN3 w0.508: v2(91.79,177.36) 91.02,176.59 90.81,176.59 90,175.78 87.43,175.78 86.64,174.99 68.01,174.99 67.05,174.03 60.13,174.03 58.96,172.85 57.34,172.85 56.45,171.97 56.45,154.06 57.09,153.42 57.09,137.9 56.66,137.47 56.66,135.51 57.26,134.91 57.26,123.72 v2(55.34,121.81)
  BOTTOM w0.127: 99.71,164.81 99.91,164.61 99.91,164.42 100.04,164.3 100.39,164.3 100.6,164.09 U1.E36
  BOTTOM w0.508: 99.71,164.81 99.33,165.19 97.73,165.19 97.46,164.93 95.4,164.93 94.89,165.43 94.89,165.96 v1(94.44,166.42) 94.05,166.42 91.29,169.18 91.29,175.02 91.79,175.53 v2(91.79,177.36)
SML0ALERT#: length 10.4
  BOTTOM w0.079: U1.CJ15 113.51,124.68 112.7,124.68 112.42,124.4 112.42,123.78 111.84,123.19 111.84,121.71 112.11,121.44 112.3,121.44 112.39,121.35 112.46,121.21 112.46,120.71 112.45,120.71 112.45,120.15 113.07,119.53 113.15,119.53 113.72,118.96 113.72,118.46
  BOTTOM w0.102: 113.72,118.46 113.64,118.38 113.64,117.89 113.47,117.73 113.44,117.73
  BOTTOM w0.114: R119.1 113.27,117.18 R121.1 113.44,117.73
SML1ALERT#: length 9.3
  TOP w0.102: 115.09,119.19 115.47,119.57 115.47,120.15 v1(115.28,120.34) 115.28,120.68 114.76,121.2 114.38,121.2 R125.2 114.27,121.62 112.61,123.28 112.61,124.22 113.32,124.93 v2(113.32,125.13)
  TOP w0.114: R123.1 114.71,118.81 115.09,119.19
  BOTTOM w0.079: v2(113.32,125.13) U1.CG15
SP2: length 2.1
  BOTTOM w0.114: U40.9 32.31,61.61 TP100.1
SP5: length 2.1
  BOTTOM w0.114: U40.12 31.58,60.11 TP101.1
SP7: length 1.5
  BOTTOM w0.114: TP102.1 29.76,57.82 U40.14
SP9: length 3.4
  BOTTOM w0.114: TP103.1 27.87,56.77 28.76,57.66 U40.16
SP11: length 2
  BOTTOM w0.114: U40.19 26.32,60.11 26.09,59.88 TP97.1
SP14: length 2
  BOTTOM w0.114: U40.22 26.21,61.61 26.07,61.75 25.32,61.75 TP98.1
SP_PLLVDD: length 17
  TOP w0.254: C462.1 112.8,198.03 L8.2 C461.1 115.06,198.03 v1(115.83,197.25) 116.3,196.78 116.89,196.78 119.41,194.25 120.42,194.25 122.53,192.15 123.18,192.15 v2(123.44,191.89) 123.5,191.83 123.84,191.83 123.85,191.82 R329.1 124.67,191.82 124.71,191.79 C460.2 C459.2
  BOTTOM w0.254: U8.M6 123.82,191.51 v2(123.44,191.89)
SPI1_CLK: length 8
  TOP w0.079: 110.76,122.09 110.76,122.36 110.7,122.42 110.7,125.58 v2(111.15,126.02)
  TOP w0.114: 110.76,122.09 110.76,120.31 111.25,119.83 TP9.1
  BOTTOM w0.079: v2(111.15,126.02) 110.86,126.31 U1.CF20
SPI1_CS#: length 9.6
  TOP w0.079: v2(110.15,125.83) 110.53,125.44 110.53,122.09
  TOP w0.114: TP12.1 111.45,117.9 110.47,118.88 110.47,119.75 110.55,119.83 110.55,121.92 110.53,121.93 110.53,122.09
  BOTTOM w0.079: U1.CG20 110.32,125.66 v2(110.15,125.83)
SPI1_IO2: length 5
  TOP w0.079: v2(108.21,125.83) 108.13,125.91 108.13,126.96 106.94,128.14 106.94,129.45 TP10.1
  BOTTOM w0.079: v2(108.21,125.83) 108.22,125.83 108.47,125.83 U1.CG23
SPI1_IO3: length 14.3
  TOP w0.079: 107.61,122.09 107.61,122.78 107.84,123.01 107.84,124.2 108.2,124.57 v2(108.2,125.19)
  TOP w0.114: 107.61,122.09 107.61,119.77 107.23,119.38 107.23,114.23 106.47,113.48 106.47,112.45 TP11.1
  BOTTOM w0.079: U1.CH23 108.63,125.03 108.37,125.03 v2(108.2,125.19)
SPI_TPM_CS#: length 53.4
  TOP w0.114: v1(89.56,103.04) 89.1,103.5 87.06,103.5 86.67,103.11 84.72,103.11 84.14,102.54 82.06,102.54 81.59,102.07 81.22,102.07 80.91,101.76 80.91,100.16 81.05,100.01 R586.1 81.05,99.13 R599.1
  BOTTOM w0.079: U1.CH34 101.89,125.45 99.86,125.45 99.61,125.2 99.24,125.2 97.98,123.95 97.98,123.64 97.21,122.87 95.02,122.87
  BOTTOM w0.114: 95.02,122.87 93.48,122.87 91.23,120.63 91.23,117.38 90.85,117 90.85,116.02 90.73,115.91 89.83,115.91 89.72,115.79 89.72,115.33 89.83,115.22 90.73,115.22 90.85,115.11 90.85,114.17 90.73,114.06 89.07,114.06 88.95,113.94 88.95,113.48 89.07,113.37 90.73,113.37 90.85,113.26 90.85,112.8 90.73,112.68 89.07,112.68 88.95,112.57 88.95,112.11 89.07,112 90.73,112 90.85,111.88 90.85,111.42 89.48,110.05 89.48,109.83 88.83,109.17 88.83,104.79 89.56,104.06 v1(89.56,103.04)
SPI_TPM_CS#_TPM: length 4.1
  TOP w0.114: U33.20 83.49,98.32 82.5,99.31 81.68,99.31 R599.2
SRTC_RST#: length 45.1
  TOP w0.114: v1(83.76,103.54) 83.77,103.55 83.77,104.78 83.08,105.47 C1211.1 83.08,106.12 82.51,106.7 R971.2 v1(80.88,106.7) 80.8,106.7 80.2,106.11 Q6520.3
  BOTTOM w0.079: U1.BR37 100.16,132.77 98.77,132.77 97.32,131.32 96.33,131.32 95.09,130.08 95.01,130.08
  BOTTOM w0.114: v1(83.76,103.54) 83.77,103.55 83.77,103.99 84.96,105.19 84.96,112.39 84.55,112.81 84.55,115.45 86.59,117.49 86.59,117.55 87.15,118.11 87.15,121.33 93.01,127.19 93.01,129.27 93.82,130.08 95.01,130.08
STRAP0: length 6.8
  BOTTOM w0.102: 116.49,185.55 116.89,185.55 117.42,185.02 119.38,185.02 119.55,184.85 U8.D1
  BOTTOM w0.114: 116.49,185.55 116.37,185.55 R353.2 115.91,185.09 114.73,185.09 114.08,185.74 R344.1
STRAP1: length 7.3
  BOTTOM w0.114: U8.D2 120.36,184.85 119.99,184.48 119.53,184.48 119.21,184.79 117.32,184.79 117.22,184.9 116.09,184.9 R354.2 115.16,184.83 114.63,184.83 114.43,185.03 R345.1
STRAP2: length 10.3
  BOTTOM w0.102: 116.72,182.37 117.09,182.37 118.47,183.74 119.58,183.74 119.68,183.64 120.04,183.64 120.22,183.82 120.22,184.2 120.5,184.48 120.78,184.48 121.03,184.73 121.03,185.01 121.26,185.24 121.76,185.24 U8.E4
  BOTTOM w0.114: R346.1 114.15,182.93 115.31,182.93 115.37,182.88 115.81,182.88 116.31,182.37 R355.2 116.72,182.37
STRAP3: length 9.8
  BOTTOM w0.114: v1(114.05,188.03) 114.08,188 R347.1 114.08,186.8 114.71,186.18 114.96,186.18 115.09,186.05 115.86,186.05 R356.2 116.76,186.56 118.06,185.26 120.78,185.26 121.21,185.7 U8.E3
STRAP4: length 10.4
  BOTTOM w0.102: 117.15,181.94 117.19,181.97 119.29,181.97 119.96,182.65 120.07,182.65 120.29,182.88 120.8,182.88 121.03,183.1 121.03,184.25 121.42,184.64 U8.D3
  BOTTOM w0.114: R348.1 114.08,181.63 114.75,180.96 115.96,180.96 R357.2 116.58,181.37 117.15,181.94
STRAP5: length 6.4
  BOTTOM w0.102: 116.49,183.38 117.42,183.38 118.01,183.97 119.74,183.97 U8.C1
  BOTTOM w0.114: 116.49,183.38 R358.2 115.81,183.94 115.31,183.94 115.04,184.22 114.28,184.22 R349.1
SUS_STAT#: length 23.2
  TOP w0.079: 104.3,122.09 104.3,122.11 105.71,123.51 105.71,123.96 106.3,124.55 106.3,125.02 v2(106.95,125.68)
  TOP w0.114: 104.3,122.09 104.3,120.5 103.79,119.99 103.79,118.96 104.75,118 105.66,118 105.93,117.74 105.93,114.77 105.11,113.95 102.91,113.95 102.39,113.43 102.39,111.88 102.61,111.67 C6626.1
  BOTTOM w0.079: U1.CA27 106.93,128.39 106.93,126.08 106.95,126.05 v2(106.95,125.68)
SUSACK#: length 24.9
  TOP w0.102: v2(102.82,129.22) 102.76,129.28 101.3,129.28 101.24,129.33 100.74,129.33
  TOP w0.114: 100.74,129.33 100.17,129.33 98.01,127.17 98.01,126.78 97.02,125.8 94.34,125.8 93.77,125.23 92.7,125.23 91.97,124.49 90.84,124.49 90.35,124.01 89.95,124.01 88.92,122.98 88.18,122.98 87.52,122.32 86.19,122.32 85.67,122.84 TP9018.1 82.81,122.43 82.69,122.43 R32.2
  BOTTOM w0.079: U1.BY32 102.82,129.34 102.82,129.25
  BOTTOM w0.089: v2(102.82,129.22) 102.82,129.25
SUSB#: length 151.9
  TOP w0.114: v1(159.45,105.37) 159.45,105.98 157.54,107.89 157.54,109.24 156.56,110.22 U37.119 ; v1(85.41,104.09) 85.41,104.55 85.9,105.04 89.12,105.04 v1(89.51,104.64) 89.75,104.41 91.1,104.41 92.41,105.72 92.41,106.61 91.79,107.24 C5.1 89.77,107.24 89.51,107.5 U2014.1
  IN1 w0.089: v1(115.6,100.89) 113.2,98.49 99.93,98.49 99.22,97.78 98.22,97.78 97.81,97.37 88.16,97.37 88,97.54 83.63,97.54 82.38,98.79 80.54,98.79 79.42,99.91 79.42,101.7 80.04,102.32 82.21,102.32 82.57,102.69 84.01,102.69 v1(85.41,104.09)
  IN3 w0.102: v1(115.6,100.89) 115.95,100.54 116.74,100.54 117.01,100.81 121.24,100.81 122.82,102.39 128.38,102.39 129.95,103.96 138.89,103.96 139.96,102.9 144.55,102.9 145.26,103.61 148.86,103.61 149.65,104.4 153.93,104.4 155.3,105.76 156.31,105.76 156.62,105.46 157.36,105.46 157.81,105.91 158.91,105.91 v1(159.45,105.37)
  BOTTOM w0.079: 95.01,129.32 95.14,129.32 96.52,130.71 98.61,130.71 99.46,131.56 99.87,131.56 100.06,131.74 100.36,131.74 100.47,131.67 100.7,131.67 U1.BU36
  BOTTOM w0.114: v1(85.41,104.09) 85.41,104.93 85.59,105.12 85.59,109.77 86.25,110.43 86.25,114.36 87.35,115.46 87.35,117.23 87.91,117.8 87.91,121.02 93.77,126.88 93.77,128.95 94.14,129.32 95.01,129.32
SUSC#: length 73.2
  TOP w0.079: v2(106.1,131.19) 105.8,131.48 105.8,132.14 106.02,132.35 106.33,132.35 106.51,132.54 106.86,132.54 107.09,132.76 C6.1
  TOP w0.114: U37.18 152.2,102.74 152.63,103.17 153.04,103.17 153.65,103.79 v1(153.65,103.97)
  IN4 w0.089: v2(106.1,131.19) 105.9,130.98 105.9,130.02 106.09,129.82 106.51,129.82 107.22,129.11 107.22,128.42 109.18,126.46 109.18,124.64 110.68,123.13 112.48,123.13 113.29,122.32 119.47,122.32 120.54,121.25 120.69,121.25 122.53,119.41 122.53,117.9 123.53,116.91 123.53,115.51 122.54,114.52 122.54,114.24 122.86,113.92 123.82,113.92 123.9,113.84 123.9,112.32 124.91,111.32 127.29,111.32 129,109.61 129,109.2 132.33,105.87 132.72,105.87 134.21,104.38 134.94,104.38 135.02,104.46 137.83,104.46 138.38,103.91 140.47,103.91 140.77,104.21 147.52,104.21 147.78,103.95 149.06,103.95 149.44,104.33 152.41,104.33 152.45,104.37 153.25,104.37 v1(153.65,103.97)
  BOTTOM w0.089: U1.BU27 106.48,131.57 v2(106.1,131.19)
SUSCLK_32K: length 121.1
  TOP w0.114: v1(195.27,113.43) 195.71,112.99 v1(195.71,112.72)
  IN4 w0.089: v2(103.47,131.98) 103.87,132.38 106.58,132.38 106.67,132.47 107.06,132.47 107.35,132.18 108.03,132.18 108.23,132.38 108.23,133.52 108.39,133.68 109.03,133.68 109.14,133.57 109.14,128.93 109.88,128.19 109.88,127.18 110.77,126.29 110.77,125.69 110.94,125.52 111.81,125.52 112.01,125.73 112.47,125.73 112.67,125.52 112.67,125.01 113.06,124.63 113.62,124.63 113.75,124.51 113.75,123.24 114.12,122.86 116.7,122.86 116.77,122.93 120.7,122.93 122.85,120.78 122.85,120.37 123.24,119.98 123.67,119.98 125.02,118.63 125.02,118.18 125.83,117.37 125.83,116.8 126.41,116.22 126.41,115.67 126.66,115.42 127.78,115.42 129.46,113.74 129.46,112.32 129.26,112.13 129.26,111.84 131.48,109.62 131.48,108.76 131.82,108.42 132.68,108.42 134.94,106.16 136.92,106.16 137.47,105.62 138.31,105.62 138.86,105.06 139.99,105.06 140.29,105.36 147.98,105.36 148.2,105.58 154.86,105.58 155.84,106.56 160.01,106.56 160.59,105.98 166.9,105.98 168.03,107.11 170.3,107.11 175.15,111.97 180.7,111.97 180.91,112.18 180.91,112.7 181.18,112.97 183.81,112.97 185.37,114.52 186.23,114.52 186.88,115.18 190.09,115.18 191.85,113.43 v1(195.27,113.43)
  BOTTOM w0.079: 103.23,132.25 U1.BT32
  BOTTOM w0.089: 103.23,132.25 103.47,132.01 v2(103.47,131.98)
  BOTTOM w0.114: R670.2 v1(195.27,113.43)
SUSCLK_32KHZ: length 3.6
  BOTTOM w0.114: R670.1 192.6,112.17 192.6,111.67 192.32,111.4 CN17.50
SUSD: length 10.6
  TOP w0.254: PR191.2 143.14,122.46 PC152.1 142.04,123.3 PQ25.3 142.42,126.37 141.91,126.88 140.88,126.88 140.05,127.71 v1(138.99,127.71) 138.98,127.7 PQ11.2
SUSLED#: length 113.6
  TOP w0.114: v1(203.91,107.74) 203.98,107.81 v1(203.98,108.42) ; v1(154.14,100.81) 153.1,99.77 153.1,98.94 152.78,98.62 152.38,98.62 152.26,98.74 U37.28 150.16,98.74 149.25,97.83 R67486.1
  IN1 w0.089: v1(225.27,120.2) 225.9,119.58 225.9,118.66 225.52,118.29 225.47,118.29 224.86,117.67 224.86,114.24 218.75,108.14 214.72,108.14 213.58,107 209.4,107 209.07,106.67 207.17,106.67 206.83,107 205.4,107 v1(203.98,108.42)
  IN3 w0.102: v1(203.98,108.42) 203.98,106.34 203.7,106.05 203.7,104.64 202.96,103.91 201.73,103.91 201.03,103.21 201.03,101.83 200.7,101.49 v1(200.7,99.96) 200.09,99.35 193.85,99.35 193.56,99.06 179.26,99.06 179.1,98.9 176.06,98.9 175.65,98.49 169.89,98.49 169.01,97.61 165.89,97.61 165.08,96.8 161.13,96.8 160.34,97.58 156.83,97.58 155.48,98.94 155.48,99.47 v1(154.14,100.81)
  BOTTOM w0.114: v1(200.7,99.96) 200.91,99.75 203.99,99.75 204.35,100.11 CN52.13 ; v1(203.98,108.42) 203.37,109.04 203.37,109.23 201.95,110.65 CN48.21 ; v1(225.27,120.2) 225.51,119.96 CN55.11
SUSON: length 428.6
  TOP w0.102: 155.95,112.35 R25320.1 155.44,113.17 v1(155.16,113.45)
  TOP w0.114: 155.95,112.35 156.16,112.14 U37.120 156.16,110.24 157.27,109.13 157.27,107.4 158.94,105.73 158.94,104.72 159.05,104.61 v1(159.05,103.88) ; v1(68.61,186.36) 69.2,185.77 PR5012.1
  IN1 w0.089: v1(68.61,186.36) 68.61,188.7 69.09,189.18 69.09,189.91 68.68,190.32 62.26,190.32 61.67,189.73 61.67,186.84 v1(62.44,186.08)
  IN2 w0.102: v1(95.71,107.36) 97.54,107.36 98.74,108.56 104.57,108.56 105.15,109.13 108.05,109.13 108.89,109.97 112.55,109.97 112.96,109.56 115.93,109.56 117.36,108.12 118.19,108.12 118.9,107.41 120.79,107.41 121.31,106.9 127.93,106.9 130.1,104.73 133.64,104.73 134.51,103.87 143.9,103.87 145.17,102.61 146.04,102.61 146.61,103.17 152.73,103.17 153.04,103.48 158.64,103.48 v1(159.05,103.88)
  IN3 w0.102: v1(155.16,113.45) 154.97,113.26 154.36,113.26 154.08,113.54 152.43,113.54 151.57,112.67 149.9,112.67 147.19,109.96 140.65,109.96 140.24,109.55 137.21,109.55 134.9,111.87 134.9,114.81 132.27,117.44 132.27,122.57 133.19,123.49 133.19,127.22 135.85,129.88 v1(135.85,130.17) ; v1(95.71,107.36) 95.27,106.92 93.31,106.92 92.87,107.36 87.89,107.36 87.79,107.46 85.52,107.46 84.86,106.8 v1(80.11,106.8) ; v1(167.31,122.61) 166.84,122.14 165.62,122.14 164.79,121.31 163.42,121.31 163.19,121.54 157.03,121.54 156.39,122.18 156.39,122.46 155.3,123.56 150.95,123.56 147.79,126.73 147.79,127.46 147.39,127.86 146.59,127.86 145.93,128.52 145.06,128.52 144.07,129.51 139.95,129.51 138,131.45 138,132.76 136.99,133.77 136.99,136.7 133.6,140.09 132.73,140.09 132.49,140.32 132.49,140.82 135.52,143.86 135.52,146.47 129.78,152.2 129.78,153.61 128.46,154.93 123.1,154.93 122.71,155.33 122.71,164.01 119.67,167.05 119.29,167.05 118.4,167.94 118.4,170.26 117.86,170.81 117.86,172.76 110.88,179.74 108.37,179.74 107.88,180.24 105.8,180.24 105,181.04 105,181.51 102.79,183.71 100.15,183.71 99.54,184.33 96.36,184.33 96.25,184.21 95.28,184.21 92.07,187.42 92.07,188.29 92.32,188.55 92.32,189.23 90.69,190.87 87,190.87 86.29,191.58 82.58,191.58 81.7,190.7 78.35,190.7 77.82,191.23 69.99,191.23 68.65,192.58 65.92,192.58 64.56,191.22 63.31,191.22 61.66,189.56 61.66,186.86 v1(62.44,186.08)
  IN4 w0.089: v1(68.61,186.36) 68.61,185.93 68.12,185.44 68.12,184.1 70.55,181.67 70.55,179.77 71.69,178.62 72.71,178.62 v1(73.38,177.95) ; v1(167.31,122.61) 167.31,123.28 166.81,123.78 166.81,124.71 167.95,125.86 167.95,128.87 169.45,130.37 169.45,132.69 v1(168.73,133.41)
  BOTTOM w0.114: v1(135.85,130.18) 135.65,130.38 PR9258.1 ; v1(95.71,107.36) 95.95,107.13 R215.2 96.37,107.56 96.27,107.66 C247.2 95.89,108.08 95.44,108.53 U3.3 ; v1(168.73,133.41) 169.19,132.95 PR9269.1 ; PR9271.1 61.87,186.73 61.45,186.31 TP13167.1 61.61,186.15 62.37,186.15 v1(62.44,186.08) ; v1(73.38,177.95) 73.1,177.66 73.1,177.1 74.43,175.76 74.93,175.76 77.06,173.63 77.06,130.07 77.16,129.98 77.16,128.18 73.55,124.56 73.55,113.37 v1(80.11,106.8)
SUSPWRDNACK: length 25.7
  TOP w0.114: R39.1 81.41,124.46 82.45,124.46 R31.2 83.5,124.35 84.29,124.35 84.41,124.23 86.44,124.23 86.88,123.78 88.59,123.78 89.62,124.81 90.02,124.81 90.5,125.29 91.63,125.29 92.39,126.05 93.6,126.05 94.22,126.67 96.1,126.67 96.41,126.97 97.13,126.97 98.45,128.29 v1(98.45,129)
  BOTTOM w0.079: U1.BV34 101.63,130.61 101.37,130.61 101.3,130.58 101.12,130.58 101.02,130.62 100.75,130.62 100.63,130.57 100.49,130.57 100.4,130.61 100.01,130.61 99.73,130.32 99.73,129.71 99.02,129 v1(98.45,129)
SW: length 8.9
  TOP w0.114: R764.1 33.36,118.74 32.65,119.44 R67597.2 32.27,120.16 30.98,120.16 R765.2 30.19,120.66 v1(29.54,121.31) 29.23,121.62 29.23,123.69 28.72,124.21 U30.45
SWP_PWR: length 3
  TOP w0.114: TP13164.1 66.32,98.32 v1(66.57,98.07)
  BOTTOM w0.114: CN58.4 65.7,98.94 v1(66.57,98.07)
SYS_HWPG: length 346.6
  TOP w0.114: U37.124 154.56,109.91 155.61,108.86 v1(155.61,108.74) 155.61,108.52 155.04,107.95 154.32,107.95 153.68,108.59 153.68,108.87 152.63,109.92 149.91,109.92 149.71,109.72 148.74,109.72 148.49,109.47 148.49,108.86 147.72,108.09 146.74,108.09 145.33,106.68 143.28,106.68 142.68,106.08 D60.1 142.68,105.09 143.34,104.44 143.34,103.26 142.42,102.35 142.42,101.79 142.56,101.65 142.56,100.04 141.91,99.39 141.76,99.39 v1(141.58,99.21) ; v1(186.58,123.66) 186.58,123.48 v1(186.13,123.03) 186.12,123.02 185.32,123.02 183.25,120.95 183.25,117.67 182.04,116.46 v1(182.04,112.47) ; PR8060.1 16.6,111.96 v1(16.41,112.15) ; PR8041.1 v1(31.41,115.53)
  IN3 w0.102: v1(172.03,129.11) 170.71,129.11 169.97,128.37 169.97,125.93 170.66,125.23 171.09,125.23 171.36,124.97 173.13,124.97 173.31,125.14 178.71,125.14 178.94,124.92 185.32,124.92 v1(186.58,123.66) ; v1(113.63,96.16) 114.64,97.18 119.61,97.18 120.71,98.27 122.29,98.27 123.87,99.85 130.44,99.85 130.95,100.36 139.64,100.36 139.95,100.05 140.74,100.05 v1(141.58,99.21) ; v1(182.04,112.47) 180.95,111.39 175.48,111.39 172.06,107.97 167.07,107.97 166.44,107.34 164.28,107.34 163.63,106.69 160.22,106.69 159.26,107.64 156.71,107.64 v1(155.61,108.74)
  IN4 w0.089: v1(113.63,96.16) 112.6,95.14 101.89,95.14 100.48,96.54 98.27,96.54 98.07,96.35 92.94,96.35 92.44,95.84 78.79,95.84 78.01,95.06 75.78,95.06 74.95,94.23 69.29,94.23 68.21,93.15 57.49,93.15 56.27,94.37 52.59,94.37 48.15,98.81 43.6,98.81 42.78,97.99 38.33,97.99 35.37,100.95 34.47,100.95 34.19,101.23 31.11,104.32 31.11,107.7 31.74,108.34 31.74,109.3 31.33,109.71 31.33,114.98 31.41,115.05 v1(31.41,115.53) 30.86,116.08 30.86,119.81 29.77,120.9 29.77,129.42 28.87,130.32 28.87,131.46 29.49,132.08 29.49,142.7 28.21,143.98 28.21,146.29 29.19,147.27 29.19,151.28 28.83,151.64 28.83,153.94 27.38,155.39 27.38,158.39 27.19,158.58 27.19,160.87 27.51,161.18 27.51,161.63 29.46,163.58 29.46,171.04 37.49,179.07 40.22,179.07 41.84,180.69 41.84,183.07 45.41,186.63 47.32,186.63 49.89,189.2 57.55,189.2 58.38,188.37 58.38,184.97 v1(58.02,184.6)
  BOTTOM w0.114: v1(16.41,112.15) 17.62,112.15 18.18,112.7 23.26,112.7 24.68,114.12 26.43,114.12 27.62,115.32 31.2,115.32 v1(31.41,115.53) ; v1(172.03,129.11) 172.03,129.14 PR6004.1 ; PR6022.1 58.5,184.18 58.06,184.61 58.02,184.61 v1(58.02,184.6)
SYS_PWROK: length 16.9
  BOTTOM w0.079: 118.36,118.41 118.26,118.41 117.33,119.35 117.33,119.92 117.19,120.06 117.19,121.05 U1.CR10
  BOTTOM w0.102: 118.36,118.41 118.52,118.26 118.52,116.02 118.22,115.72 C7.1
  BOTTOM w0.114: U6504.4 114.01,110.77 R25359.1 R25362.1 116.84,110.77 117.08,110.53 118.59,110.53 118.86,110.8 118.86,112.27 TP5.1 118.36,112.9 117.72,113.54 117.72,114.52 117.67,114.57 117.67,115.24 118.08,115.65 C7.1
SYS_RESET#: length 4.8
  BOTTOM w0.079: U1.CN10 117.16,122.13 116.98,121.95 116.98,120.96 117.02,120.91 117.02,119.99 117.16,119.85 117.16,119.21 117.96,118.41
  BOTTOM w0.102: 117.96,118.41 118.08,118.28 R43.1
SYS_SHDN#: length 380.2
  TOP w0.114: PR6002.1 173.58,134.04 v1(172.85,134.77) ; v1(209.42,127.64) 209.42,127.49 209.89,127.02 209.89,125.69 209.57,125.37 207.09,125.37 206.87,125.59 203.44,125.59 v1(202.72,124.86) 201.82,123.96 v1(201.82,123.72) 201.78,123.67 201.78,109.88 202.48,109.17 202.48,108.06 v1(201.66,107.24) ; Q86.3 113.83,109.86 113.83,106.86 114.07,106.61 114.07,105.99 v1(113.72,105.63) ; v1(164.47,104.82) 164.9,105.25 166.02,105.25 166.13,105.14 U37.85
  TOP w0.254: PR6002.1 175.06,133.4 175.29,133.18 PR6009.1
  IN1 w0.089: v1(113.72,105.63) 113.87,105.49 117.38,105.49 117.71,105.82 120.86,105.82 123.33,103.35 132.94,103.35 133.54,102.75 137.1,102.75 138.06,101.79 141.62,101.79 141.76,101.93 v1(142.94,101.93) ; v1(172.85,134.77) 172.85,136.01 170.97,137.89 170.97,138.76 169.94,139.79 169.94,140.12 170.28,140.45 170.28,145.51 172.35,147.59 172.35,148.46 171.21,149.6 171.21,150.18 170.58,150.82 170.58,152.4 169.44,153.54 169.44,154.35 168.38,155.41 168.38,155.94 167.58,156.73 167.58,158.74 166.08,160.24 166.08,166.13 165.28,166.93 160.83,166.93 158.27,169.49 154.75,169.49 154.27,169.01 153.68,169.01 153.2,169.49 151.48,169.49 151.1,169.86 142.65,169.86 139.92,172.58 139.92,174.82 138.75,176 135.82,176 133.97,177.84 129.03,177.84 128.13,178.75 121.3,178.75 120.45,179.59 115.65,179.59 115.38,179.33 111.75,179.33 111.36,179.72 110.22,179.72 109.79,180.14 105.78,180.14 104.45,181.48 100.13,181.48 98.38,183.23 97.44,183.23 v1(95.96,184.71)
  IN3 w0.102: v1(172.85,134.77) 172.57,134.77 171.34,136 170.74,136 170.38,135.64 170.38,134.79 171.14,134.03 171.53,134.03 171.84,133.73 171.84,133.28 173.48,131.63 173.48,128.79 175.5,126.77 178.31,126.77 179.3,125.78 188.14,125.78 191.5,129.14 195.29,129.14 196.74,130.59 199.17,130.59 199.51,130.25 201.25,130.25 201.37,130.13 206.92,130.13 v1(209.42,127.64) ; v1(201.66,107.24) 201.66,106.52 200.97,105.82 200.38,105.82 198.35,103.79 192.25,103.79 190.35,105.69 183.24,105.69 178.83,110.11 175.9,110.11 171.43,105.64 167.91,105.64 167.45,105.18 164.82,105.18 v1(164.47,104.82) 163.8,104.82 163.38,105.24 160.13,105.24 159.81,104.92 159.22,104.92 158.64,105.51 157.98,105.51 157.52,105.05 157.09,105.05 156.56,104.53 155.51,104.53 154.94,103.96 154.94,103.78 154.23,103.07 149.46,103.07 148.52,102.13 147.36,102.13 146.98,101.75 144.84,101.75 144.12,102.47 143.48,102.47 v1(142.94,101.93) ; v1(57.98,187.42) 58.46,187.9 58.46,190.89 64.88,197.31 71.66,197.31 72.34,196.63 73.98,196.63 74.08,196.53 76.94,196.53 77.79,197.38 88.65,197.38 89.7,196.33 89.7,192.43 93.17,188.96 93.17,186.89 95.35,184.71 v1(95.96,184.71)
  BOTTOM w0.114: PR3022.2 134.29,111.26 134.46,111.09 136.31,111.09 137.28,110.13 139.91,110.13 140.39,109.65 140.39,107.44 141.25,106.58 141.25,106.04 141.3,105.98 141.3,103.56 v1(142.94,101.93) ; PR6020.1 57.45,187.42 v1(57.98,187.42) ; R67418.1 94.08,185.34 94.71,184.71 v1(95.96,184.71) ; R67422.1 v1(201.82,123.72)
TABLET_MODE: length 365.8
  TOP w0.114: v1(136.46,205.95) 139.18,205.95 140.03,206.8 140.03,210.02 139.33,210.73 U6525.1 ; v1(198.94,94.87) 200.67,96.6 200.67,97.87 201.64,98.84 201.64,99.5 202.39,100.24 202.39,102.72 v1(202.13,102.97) 202.13,105.56 203.43,106.86 203.43,109.73 v1(209.35,115.64) 209.71,116 209.71,119.25 208.89,120.06 208.89,123.42 210.61,125.14 v1(210.61,127.16) ; v1(195.5,102.62) 195.5,102.4 194.37,101.27 191.19,101.27 190.63,101.83 185.65,101.83 185.1,101.27 R67885.2
  IN1 w0.089: v1(198.94,94.87) 198.3,95.51 175.38,95.51 174.44,96.45 171.36,96.45 170.77,95.86 169.62,95.86 168.83,96.65 166.09,96.65 165.13,95.7 154.76,95.7 153.02,97.44 139.31,97.44 138.62,98.13 134.28,98.13 133.21,99.2 114.63,99.2 113.54,98.11 100.08,98.11 99.37,97.4 98.37,97.4 97.97,96.99 91.47,96.99 v1(91.21,96.73) ; v1(202.13,102.97) 201.59,103.51 199.72,103.51 199.24,103.04 195.92,103.04 v1(195.5,102.62)
  IN3 w0.102: v1(210.61,127.16) 210.43,126.97 205.83,126.97 205.09,127.72 198.24,127.72 197.91,128.05 194.41,128.05 192.81,126.44 192.81,125.1 192.27,124.57 192.27,124.56 190.21,122.51 183.85,122.51 183.18,123.18 179.78,123.18 179.71,123.24 172.93,123.24 172.25,122.57 169.33,122.57 168.88,123.03 168.23,123.03 167.75,123.5 165.93,123.5 164.32,125.11 159.08,125.11 158.9,124.93 151.52,124.93 150.8,125.65 150.8,127.42 148.72,129.5 148.72,130.28 146.67,132.33 144.4,132.33 142.42,134.3 142.42,135.22 141.34,136.31 141.34,149.1 140.47,149.96 140.47,158.05 140.07,158.44 139.78,158.44 138.74,159.49 138.74,160.93 138.22,161.46 132.24,161.46 130.85,162.85 130.85,164.82 130.36,165.3 130.36,167.35 127,170.72 124.42,170.72 122.95,172.19 122.95,174.49 122.28,175.16 122.28,184.14 122.76,184.63 122.76,186.21 123.35,186.79 123.35,189.06 122.44,189.97 122.44,194.12 121.71,194.84 121.71,201.44 123.39,203.12 123.39,203.8 123.66,204.07 123.66,205.99 125.48,207.81 127.53,207.81 127.97,207.37 132.12,207.37 132.21,207.28 135.45,207.28 136.46,206.27 v1(136.46,205.95)
  BOTTOM w0.114: CN4.2 86.15,100.3 86.36,100.5 87.04,100.5 87.86,99.68 88.26,99.68 v1(91.21,96.73)
TCT1: length 16.7
  TOP w0.508: v1(29,180.86) 29,180.86 v1(32,180.86) v1(33.35,180.86) 35,180.86 v1(35,180.87) 36.22,180.87 C96313.1 37.78,180.84 v1(38,180.84) 38.98,179.86 C645.1
  BOTTOM w0.508: U25.10 v1(29,180.86) ; U25.7 v1(32,180.86) ; U25.4 v1(35,180.87) ; U25.1 v1(38,180.84)
TEMP_MBAT#: length 166.6
  TOP w0.114: v1(199.24,111.53) 198.9,111.19 198.9,106.54 199.55,105.89 199.55,104.72 198.33,103.49 198.33,98.68 195.76,96.11 192.87,96.11 v1(192.51,96.47) 192.34,96.63 183.35,96.63 182.83,96.11 175.48,96.11 173.99,97.59 v1(173.99,97.6) 173.99,98.11 173.63,98.48 173.63,99.8 173.06,100.36 168.88,100.36 168.72,100.21 168.03,100.21 167.9,100.34 U37.73
  IN1 w0.089: v1(105.1,104.91) 105.52,104.91 106.12,104.31 117.96,104.31 119.36,102.91 122.11,102.91 122.91,102.12 131.02,102.12 131.56,101.58 135.18,101.58 136.25,100.51 138.79,100.51 139.36,99.94 145.29,99.94 145.64,99.59 151.25,99.59 151.96,100.31 154.76,100.31 157.16,97.91 161.41,97.91 161.88,98.38 165.86,98.38 166.36,97.88 169.75,97.88 169.85,97.99 173.16,97.99 173.55,97.6 v1(173.99,97.6)
  IN3 w0.102: v1(161.19,116.44) 161.6,116.03 162.93,116.03 163.16,115.8 163.8,115.8 164.07,115.53 171.21,115.53 172.68,114.06 177.7,114.06 178.35,114.71 185.78,114.71 186.9,113.6 191.22,113.6 194.68,110.13 197.85,110.13 v1(199.24,111.53)
  BOTTOM w0.114: PR14.2 105.1,105.24 v1(105.1,104.91)
  BOTTOM w0.152: PR18.1 161.77,115.85 v1(161.19,116.44) 161.4,116.64 PR8.1
TESTMODE: length 15.9
  BOTTOM w0.114: U8.AD9 126.78,201.82 127.4,201.82 127.66,202.08 127.66,204.42 126.28,205.8 125.68,205.8 124.85,206.63 123.42,206.63 122.23,205.44 120.75,205.44 119.86,206.34 119.86,207.65 v1(119.76,207.74) 119.42,207.74 R311.1
THERM+: length 21.2
  TOP w0.102: 125.85,182.65 126.09,182.9 126.52,182.9 127.91,184.29 127.91,185.5 v2(128.46,186.05)
  TOP w0.114: 125.85,182.65 123.51,180.32 117.03,180.32 114.92,178.21 114.14,178.21 113.84,178.51 113.37,178.51 112.75,177.89 TP68.1
  BOTTOM w0.102: U8.F12 128.88,186.47 v2(128.46,186.05)
THERM-: length 9.9
  TOP w0.102: 128.81,182.65 128.81,183.03 129.31,183.53 v2(129.31,184.42)
  TOP w0.114: 128.81,182.65 128.81,181.91 128.53,181.63 128.53,180.74 128.83,180.44 128.83,179.09 TP69.1
  BOTTOM w0.102: U8.E12 129.31,185.22 v2(129.31,184.42)
THERMTRIP#: length 200.5
  TOP w0.114: v1(113.06,105.67) 111.38,107.35 R822.1 111.29,108.06 112.33,109.09 Q86.1 ; v1(197.34,123.32) 197.34,122.63 197.54,122.44 197.54,120.57 198.43,119.68 198.43,117.6 197.95,117.11 197.95,114.8 v1(197.77,114.63) 197.77,112.04 197.95,111.86 197.95,106.86 197.27,106.18 197.27,105.63 196.44,104.8 196.44,104.38 196.92,103.9 v1(196.92,100.75)
  IN1 w0.089: v1(197.34,123.32) 196.44,122.42 193,122.42 191.33,120.75 189.58,120.75 188.28,119.44 183.29,119.44 183.1,119.63 181.51,119.63 179.92,121.22 174.76,121.22 174.28,120.74 167.95,120.74 167.72,120.96 167.07,120.96 166.23,120.12 164.08,120.12 162.87,121.33 161.07,121.33 156.72,121.33 155.68,122.38 155.68,122.93 155,123.61 150.94,123.61 148.7,125.85 148.29,125.85 147.53,126.61 147.53,127.35 147.32,127.55 146.68,127.55 145.55,128.69 139.15,128.69 136.87,130.97 135.27,130.97 134.14,132.1 134.14,133.18 133.68,133.64 132.98,133.64 132.44,134.18 131.82,134.18 131.57,134.43 131.57,135.42 130.89,136.11 v1(130.66,136.11) ; v1(196.92,100.75) 196.92,100.48 195.77,99.33 194.49,99.33 192.46,97.3 184.11,97.3 183.09,98.31 181.74,98.31 180.86,99.19 168.7,99.19 168.68,99.22 161.96,99.22 160.61,100.56 155.86,100.56 154.55,101.88 152.39,101.88 151.97,101.46 151.65,101.46 150.81,100.62 147.71,100.62 147.62,100.52 145.93,100.52 145.44,101.01 141.84,101.01 141.46,101.39 137.9,101.39 136.93,102.36 133.38,102.36 132.78,102.96 123.16,102.96 122.43,103.69 120.97,103.69 119.24,105.42 117.87,105.42 117.54,105.09 113.64,105.09 v1(113.06,105.67)
  BOTTOM w0.114: v1(130.66,136.11) 129.88,136.11 128.8,137.18 R25479.2
THERMTRIP#_CPU: length 6.3
  BOTTOM w0.102: 125.81,137.57 123.3,137.57 122.86,137.14 U1.BJ1
  BOTTOM w0.114: 125.81,137.57 127.12,137.57 R25479.1 127.51,136.45 v1(127.38,136.32)
TMDS_CLK+: length 2.7
  TOP w0.089: R67378.1 19.14,128.39 19.22,128.46 19.62,128.46 19.82,128.27 20.88,128.27 20.94,128.21 U30.16
TMDS_CLK-: length 2.7
  TOP w0.089: R67377.1 19.13,128.83 19.23,128.73 19.73,128.73 19.93,128.54 20.83,128.54 20.9,128.61 U30.15
TMDS_D0+: length 2.8
  TOP w0.089: R67379.1 19.13,126.49 19.24,126.59 19.83,126.59 20.32,127.07 20.87,127.07 20.94,127.01 U30.19
TMDS_D0-: length 2.8
  TOP w0.089: R67380.1 19.14,126.97 19.25,126.86 19.72,126.86 20.21,127.34 20.84,127.34 20.9,127.41 U30.18
TMDS_D1+: length 3.3
  TOP w0.089: R67381.1 19.13,124.66 19.2,124.72 19.51,124.72 20.02,125.23 20.02,125.58 20.31,125.87 20.89,125.87 20.96,125.81 U30.22
TMDS_D1-: length 3.3
  TOP w0.089: U30.21 20.96,126.21 20.89,126.14 20.2,126.14 19.76,125.7 19.76,125.34 19.4,124.99 19.2,124.99 19.14,125.05 R67382.1
TMDS_D2+: length 3.9
  TOP w0.089: R67383.1 19.13,122.73 19.21,122.81 19.51,122.81 19.88,123.17 19.88,124.17 20.38,124.67 20.88,124.67 20.95,124.61 U30.25
TMDS_D2-: length 4
  TOP w0.089: U30.24 20.94,125.01 20.87,124.94 20.27,124.94 19.61,124.28 19.61,123.28 19.4,123.07 19.21,123.07 19.13,123.15 R67384.1
TMDS_DDCBUF: length 6.3
  TOP w0.114: R760.1 31.91,131.3 30.82,131.3 R761.2 29.88,130.37 29.1,130.37 28.89,130.58 27.58,130.58 27.02,130.02 U30.2
TMDS_HPD: length 6.2
  TOP w0.114: v1(19.77,129.44) 19.53,129.68 19.53,130.61 19.23,130.91 R67385.1 ; U30.17 v1(20.51,127.81)
  IN1 w0.089: v1(20.51,127.81) 19.77,128.54 v1(19.77,129.44)
TMDS_PRE: length 9.4
  TOP w0.114: v1(20.3,121.79) 20.57,121.52 v1(21.41,121.52) 21.8,121.13 R757.2 R756.1 ; U30.20 v1(20.49,126.61)
  IN1 w0.089: v1(20.3,121.79) 20.3,122.43 19.77,122.96 19.77,125.89 v1(20.49,126.61)
TMDS_RT: length 8.9
  TOP w0.114: v1(20.88,122.12) 20.73,122.28 20.03,122.28 19.37,121.62 18.83,121.62 18.7,121.48 R759.2 19.79,120.99 R758.1 ; U30.23 v1(20.48,125.41)
  IN1 w0.089: v1(20.88,122.12) 19.96,123.04 19.96,124.88 v1(20.48,125.41)
TMDS_SCL: length 4.2
  TOP w0.114: R67376.1 30.18,122.65 29.89,122.65 29.76,122.78 29.76,123.91 29.24,124.44 29.24,125 28.83,125.41 U30.48
