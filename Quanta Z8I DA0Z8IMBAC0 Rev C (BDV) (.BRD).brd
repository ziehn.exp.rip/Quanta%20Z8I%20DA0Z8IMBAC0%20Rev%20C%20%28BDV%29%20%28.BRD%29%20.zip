# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-1X0_6-0_55H
  rect 0.432x0.711 smd: 1(-0.34,0) 2(0.34,0)
D-1X0_6-2P-PJE24VM5FN2
  rect 0.432x0.61 smd: 1(-0.34,0) 2(0.34,0)
D-1X0_6-D24V0L1B2LPS
  rect 0.457x0.61 smd: 1(-0.375,0) 2(0.375,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
D-SOD523-1_2X0_8
  rect 0.406x0.406 smd: 1(-0.7,0) 2(0.7,0)
D-SOD523-1_2X0_8-1N4148WT-7
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
DCJK-30738-11202-001-3P
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.092x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AR0-26001-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN8-2X2-5-9P
  rect 0.305x0.94 smd: 1(-0.75,-1.125) 2(-0.25,-1.125) 3(0.25,-1.125) 4(0.75,-1.125) 5(0.75,1.125) 6(0.25,1.125) 7(-0.25,1.125) 8(-0.75,1.125)
  rect 1.118x0.533 smd: 9(0,0)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN14-3X2-4-15P-0_85H
  rect 0.203x0.711 smd: 1(-1.2,-1) 2(-0.8,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 7(1.2,-1) 8(1.2,1) 9(0.8,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1) 14(-1.2,1)
  rect 2.591x0.914 smd: 15(0,0)
DFN1006-3-1X0_6-0_55H-3P
  rect 0.356x0.254 smd: 1(0.325,0.225) 2(0.325,-0.225)
  rect 0.457x0.559 smd: 3(-0.275,0)
DFN2018-6-1_8X2-5-7P
  rect 0.356x0.254 smd: 1(0.975,-0.5) 2(0.975,0) 3(0.975,0.5) 4(-0.975,0.5) 5(-0.975,0) 6(-0.975,-0.5)
  rect 1.194x1.6 smd: 7(0,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
DSUB-DHR4U-15K1202-15P
  round 0.965 hole 0.711: 1(-4.58,-0.7) 2(-2.29,-0.7) 3(0,-0.7) 4(2.29,-0.7) 5(4.58,-0.7) 6(-5.725,-0.7) 7(-3.435,-0.7) 8(-1.145,-0.7) 9(1.145,-0.7) 10(3.435,-0.7)
  round 0.991 hole 0.711: 11(-4.58,0.7) 12(-2.29,0.7) 13(0,0.7) 14(2.29,0.7) 15(4.58,0.7)
  oval 1.194x3.099 hole 0.61x2.489: 16(-8.6,0) 17(8.6,0)
ESD10-2_5X1-5-9P-AZ1143
  rect 0.254x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.381x1.549 smd: 3(0,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
FPC-50506-0060N-V01-6P-L
  rect 0.305x0.889 smd: 1(-1.25,3.05) 2(-0.75,3.05) 3(-0.25,3.05) 4(0.25,3.05) 5(0.75,3.05) 6(1.25,3.05)
  rect 0.991x2.007 smd: 7(-3.35,0) 8(3.35,0)
FPC-51540-02201-V01-22P-L
  rect 0.305x0.838 smd: 1(-5.25,3.175) 2(-4.75,3.175) 3(-4.25,3.175) 4(-3.75,3.175) 5(-3.25,3.175) 6(-2.75,3.175) 7(-2.25,3.175) 8(-1.75,3.175) 9(-1.25,3.175) 10(-0.75,3.175) 11(-0.25,3.175) 12(0.25,3.175) 13(0.75,3.175) 14(1.25,3.175) 15(1.75,3.175) 16(2.25,3.175) 17(2.75,3.175) 18(3.25,3.175) 19(3.75,3.175) 20(4.25,3.175) 21(4.75,3.175) 22(5.25,3.175)
  rect 0.787x2.007 smd: 23(-6.95,0) 24(6.95,0)
H-C87D87N
  round 2.21 hole 2.21 unplated: (0,0)
H-C106X87D106X87N
  oval 2.692x2.21 hole 2.692x2.21 unplated: (0,0)
H-C315D118P2
  round 8.001 hole 2.997: 1(0,0)
H-C354D177P2
  round 8.992 hole 4.496: 1(0,0)
H-S157D157N
  rect 3.988x3.988 hole 3.988 unplated: (0,0)
H-TBC236IC166D126P2
  round 5.994 hole 3.2: 1(0,0)
H-TBC244IC166D126P2
  round 6.198 hole 3.2: 1(0,0)
H-TBC264IC146D146P2
  round 6.706 hole 3.708: 1(0,0)
H-TBC354IC158D118P2
  round 8.992 hole 2.997: 1(0,0)
H-TC354IC158BC315D118P2
  round 8.992 hole 2.997: 1(0,0)
H-Z8I-1P2
  custom 2x2 hole 2.997: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3_2X2_5-3_2
  rect 1.194x2.007 smd: 1(-1.6,0) 2(1.6,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3H
  rect 1.854x3.505 smd: 1(-2.775,0) 2(2.775,0)
LGA12-2X2-5-1H
  rect 0.279x0.406 smd: 1(-0.75,-0.815) 2(-0.25,-0.815) 3(0.25,-0.815) 4(0.75,-0.815) 7(0.75,0.815) 8(0.25,0.815) 9(-0.25,0.815) 10(-0.75,0.815)
  rect 0.406x0.279 smd: 5(0.815,-0.25) 6(0.815,0.25) 11(-0.815,0.25) 12(-0.815,-0.25)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
MSOP8-4_9-65-G547
  rect 0.356x1.397 smd: 1(-0.975,-2.5) 2(-0.325,-2.5) 3(0.325,-2.5) 4(0.975,-2.5) 5(0.975,2.5) 6(0.325,2.5) 7(-0.325,2.5) 8(-0.975,2.5)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-Z8I-1P2
  custom 1.925x1.925 hole 2.997: 1(0,0)
O-Z8I-2P2
  custom 1.925x1.925 hole 2.997: 1(0,0)
O-ZI8-3P2
  custom 3.13x3.13 hole 6.096: 1(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN17-4X4-5-14P
  rect 1.321x0.61 smd: 1(-1,-1.85) 15(-1,1.85)
  rect 0.305x0.61 smd: 4(0,-1.85) 5(0.5,-1.85) 6(1,-1.85) 12(1,1.85) 13(0.5,1.85) 14(0,1.85)
  rect 0.61x0.305 smd: 7(1.85,-1) 8(1.85,-0.5) 9(1.85,0) 10(1.85,0.5) 11(1.85,1)
  rect 2.972x2.591 smd: 18(-0.187,0)
QFN18-3X3-5
  custom 0.145x0.145 smd: 1(-1.25,-1.24) 6(1.25,-1.24) 10(1.25,1.24) 15(-1.25,1.24)
  custom 0.062x0.062 smd: 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 11(0.75,1.4) 12(0.25,1.4) 13(-0.25,1.4) 14(-0.75,1.4)
  custom 0.05x0.05 smd: 7(0.58,-0.45) 8(1.349,0) 9(0.58,0.45) 16(-1.405,0.65) 17(-0.583,0) 18(-1.405,-0.65)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-ALC5629
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.261x2.261 smd: 25(0,0)
QFN24-4X4-5-25P-RT8813D
  custom 0.075x0.075 smd: 1(-1.25,-1.975) 6(1.25,-1.975) 7(1.975,-1.25) 12(1.975,1.25) 13(1.25,1.975) 18(-1.25,1.975) 19(-1.975,1.25) 24(-1.975,-1.25)
  rect 0.305x0.838 smd: 2(-0.75,-1.975) 3(-0.25,-1.975) 4(0.25,-1.975) 5(0.75,-1.975) 14(0.75,1.975) 15(0.25,1.975) 16(-0.25,1.975) 17(-0.75,1.975)
  rect 0.838x0.305 smd: 8(1.975,-0.75) 9(1.975,-0.25) 10(1.975,0.25) 11(1.975,0.75) 20(-1.975,0.75) 21(-1.975,0.25) 22(-1.975,-0.25) 23(-1.975,-0.75)
  rect 2.54x2.54 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN32-5X5-5-37P-0_85H
  rect 0.279x0.838 smd: 1(-1.75,-2.55) 2(-1.25,-2.55) 3(-0.75,-2.55) 4(-0.25,-2.55) 5(0.25,-2.55) 6(0.75,-2.55) 7(1.25,-2.55) 8(1.75,-2.55) 17(1.75,2.55) 18(1.25,2.55) 19(0.75,2.55) 20(0.25,2.55) 21(-0.25,2.55) 22(-0.75,2.55) 23(-1.25,2.55) 24(-1.75,2.55)
  rect 0.838x0.279 smd: 9(2.55,-1.75) 10(2.55,-1.25) 11(2.55,-0.75) 12(2.55,-0.25) 13(2.55,0.25) 14(2.55,0.75) 15(2.55,1.25) 16(2.55,1.75) 25(-2.55,1.75) 26(-2.55,1.25) 27(-2.55,0.75) 28(-2.55,0.25) 29(-2.55,-0.25) 30(-2.55,-0.75) 31(-2.55,-1.25) 32(-2.55,-1.75)
  rect 3.759x3.759 smd: 33(0,0)
  round 0.508 hole 0.254: 34(-0.6,-0.6) 35(0.6,-0.6) 36(0.6,0.6) 37(-0.6,0.6)
QFN40-6X4-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-1.4,-2.975) 2(-1,-2.975) 3(-0.6,-2.975) 4(-0.2,-2.975) 5(0.2,-2.975) 6(0.6,-2.975) 7(1,-2.975) 8(1.4,-2.975) 9(1.975,-2.2) 10(1.975,-1.8) 11(1.975,-1.4) 12(1.975,-1) 13(1.975,-0.6) 14(1.975,-0.2) 15(1.975,0.2) 16(1.975,0.6) 17(1.975,1) 18(1.975,1.4) 19(1.975,1.8) 20(1.975,2.2) 21(1.4,2.975) 22(1,2.975) 23(0.6,2.975) 24(0.2,2.975) 25(-0.2,2.975) 26(-0.6,2.975) 27(-1,2.975) 28(-1.4,2.975) 29(-1.975,2.2) 30(-1.975,1.8) 31(-1.975,1.4) 32(-1.975,1) 33(-1.975,0.6) 34(-1.975,0.2) 35(-1.975,-0.2) 36(-1.975,-0.6) 37(-1.975,-1) 38(-1.975,-1.4) 39(-1.975,-1.8) 40(-1.975,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
QFN40-6X6-5-41P-0_6H
  rect 0.305x0.991 smd: 1(-2.25,-3.1) 2(-1.75,-3.1) 3(-1.25,-3.1) 4(-0.75,-3.1) 5(-0.25,-3.1) 6(0.25,-3.1) 7(0.75,-3.1) 8(1.25,-3.1) 9(1.75,-3.1) 10(2.25,-3.1) 21(2.25,3.1) 22(1.75,3.1) 23(1.25,3.1) 24(0.75,3.1) 25(0.25,3.1) 26(-0.25,3.1) 27(-0.75,3.1) 28(-1.25,3.1) 29(-1.75,3.1) 30(-2.25,3.1)
  rect 0.991x0.305 smd: 11(3.1,-2.25) 12(3.1,-1.75) 13(3.1,-1.25) 14(3.1,-0.75) 15(3.1,-0.25) 16(3.1,0.25) 17(3.1,0.75) 18(3.1,1.25) 19(3.1,1.75) 20(3.1,2.25) 31(-3.1,2.25) 32(-3.1,1.75) 33(-3.1,1.25) 34(-3.1,0.75) 35(-3.1,0.25) 36(-3.1,-0.25) 37(-3.1,-0.75) 38(-3.1,-1.25) 39(-3.1,-1.75) 40(-3.1,-2.25)
  rect 4.597x4.597 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-EXC7900-SG11
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.293x4.293 smd: 49(0,0)
QFN56-7X7-4-69P
  custom 0.05x0.05 smd: 1(-2.6,-3.475) 2(-2.2,-3.475) 3(-1.8,-3.475) 4(-1.4,-3.475) 5(-1,-3.475) 6(-0.6,-3.475) 7(-0.2,-3.475) 8(0.2,-3.475) 9(0.6,-3.475) 10(1,-3.475) 11(1.4,-3.475) 12(1.8,-3.475) 13(2.2,-3.475) 14(2.6,-3.475) 15(3.475,-2.6) 16(3.475,-2.2) 17(3.475,-1.8) 18(3.475,-1.4) 19(3.475,-1) 20(3.475,-0.6) 21(3.475,-0.2) 22(3.475,0.2) 23(3.475,0.6) 24(3.475,1) 25(3.475,1.4) 26(3.475,1.8) 27(3.475,2.2) 28(3.475,2.6) 29(2.6,3.475) 30(2.2,3.475) 31(1.8,3.475) 32(1.4,3.475) 33(1,3.475) 34(0.6,3.475) 35(0.2,3.475) 36(-0.2,3.475) 37(-0.6,3.475) 38(-1,3.475) 39(-1.4,3.475) 40(-1.8,3.475) 41(-2.2,3.475) 42(-2.6,3.475) 43(-3.475,2.6) 44(-3.475,2.2) 45(-3.475,1.8) 46(-3.475,1.4) 47(-3.475,1) 48(-3.475,0.6) 49(-3.475,0.2) 50(-3.475,-0.2) 51(-3.475,-0.6) 52(-3.475,-1) 53(-3.475,-1.4) 54(-3.475,-1.8) 55(-3.475,-2.2) 56(-3.475,-2.6)
  rect 4.699x3.912 smd: 57(0,0)
  round 0.508 hole 0.254: 58(-1.5,-1) 59(-0.5,-1) 60(0.5,-1) 61(1.5,-1) 62(1.5,0) 63(1.5,1) 64(0.5,1) 65(-0.5,1) 66(-1.5,1) 67(-1.5,0) 68(-0.5,0) 69(0.5,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC88-2_1-65-6P-1_1H
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SDCARD-156-1000302610-11P
  round 1.143 hole 1.143 unplated: (13.05,17)
  round 0.94 hole 0.94 unplated: (13.05,-2.6)
  rect 0.787x1.397 smd: 1(8.375,21.8) 2(5.875,21.8) 3(3.375,21.8) 4(0.875,21.8) 5(-1.625,21.8) 6(-4.125,21.8) 7(-6.625,21.8) 8(-8.125,21.8) 9(-9.625,21.8) 10(-11.125,21.8) 11(-12.625,21.8)
  rect 2.108x2.489 smd: 12(-14.65,0) 13(14.65,0)
SENSOR-1_3X0_9-5-4P
  rect 0.457x0.254 smd: 1(-0.625,0.25) 2(-0.625,-0.25) 3(0.625,-0.25) 4(0.625,0.25)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON8-8X6-1_27-9P
  rect 0.508x1.397 smd: 1(-1.905,-3.9) 2(-0.635,-3.9) 3(0.635,-3.9) 4(1.905,-3.9) 5(1.905,3.9) 6(0.635,3.9) 7(-0.635,3.9) 8(-1.905,3.9)
  rect 4.293x3.404 smd: 9(0,0)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-2_825-95-5P
  rect 0.991x0.711 smd: 1(1.3,-0.95) 2(1.3,0) 3(1.3,0.95) 4(-1.3,0.95) 5(-1.3,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SSOP28-7_8-65-2H
  rect 0.381x1.651 smd: 1(-4.225,-3.675) 2(-3.575,-3.675) 3(-2.925,-3.675) 4(-2.275,-3.675) 5(-1.625,-3.675) 6(-0.975,-3.675) 7(-0.325,-3.675) 8(0.325,-3.675) 9(0.975,-3.675) 10(1.625,-3.675) 11(2.275,-3.675) 12(2.925,-3.675) 13(3.575,-3.675) 14(4.225,-3.675) 15(4.225,3.675) 16(3.575,3.675) 17(2.925,3.675) 18(2.275,3.675) 19(1.625,3.675) 20(0.975,3.675) 21(0.325,3.675) 22(-0.325,3.675) 23(-0.975,3.675) 24(-1.625,3.675) 25(-2.275,3.675) 26(-2.925,3.675) 27(-3.575,3.675) 28(-4.225,3.675)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2075
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-UCF3M-01N01-0P53-24P
  round 0.813 hole 0.813 unplated: (-3.45,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.45,0)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,0.4) 6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,-1.935) 8(6.075,-1.935) 9(-6.075,-5.8) 10(6.075,-5.8)
  custom 0.064x0.064 smd: A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.254x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.61 hole 0.457: B2(2.5,-2.035) B3(1.7,-2.035) B4(1.3,-1.135) B5(0.85,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B8(-0.85,-2.035) B9(-1.3,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
unnamed
  round 1.016 smd: 1(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
WTB-GS12201-1011-7H-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(-4.75,2.325) 2(-4.25,2.325) 3(-3.75,2.325) 4(-3.25,2.325) 5(-2.75,2.325) 6(-2.25,2.325) 7(-1.75,2.325) 8(-1.25,2.325) 9(-0.75,2.325) 10(-0.25,2.325) 11(0.25,2.325) 12(0.75,2.325) 13(1.25,2.325) 14(1.75,2.325) 15(2.25,2.325) 16(2.75,2.325) 17(3.25,2.325) 18(3.75,2.325) 19(4.25,2.325) 20(4.75,2.325)
  rect 1.295x1.397 smd: 21(-5.8,2.2) 22(5.8,2.2) 23(-5.8,-1.8) 24(5.8,-1.8)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V8_AON_S: PC9057.1 PC9058.1 PR9068.1 PU9002.8 PU9002.9
1V8_MAIN_EN: PQ9083.2 PR9072.1 PR9105.1 R374.2 R403.1
1V8_MAIN_EN_N17: R374.1 U8.F9
5V_HSMBCK: D14.1 R490.1
5V_HSMBDT: D14.2 R491.1
8813VID: PR9015.2 PR9017.2 PU9000.5
8813VOUT1: PC9027.1 PC9028.1 PR9028.1 PU9000.11(VSNS)
8813VREF: PC9023.1 PR9021.1 PR9033.2 PU9000.8
+1.2VSUS: C74.2 C75.2 C76.2 C77.2 C87.2 C88.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.2 C131.2 C132.2 C133.2 C250.1 C252.1 C254.1 C256.1 C258.1 C260.1 C262.1 C263.1 C267.1 C268.1 C270.1 C272.1 C274.1 C276.1 C277.1 C279.1 C20104.1 C20107.1 C20110.1 C20113.1 C20116.1 C20118.1 C20120.1 C20121.1 C20122.1 C20123.1 C20124.1 C20125.1 C20126.1 C20127.1 C20128.1 C20129.1 EC5.2 EC6.2 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.96 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 JDIM02.12 JDIM02.33 JDIM02.54 JDIM02.75 JDIM02.96 JDIM02.111 JDIM02.112 JDIM02.117 JDIM02.118 JDIM02.123 JDIM02.124 JDIM02.129 JDIM02.130 JDIM02.135 JDIM02.136 JDIM02.141 JDIM02.142 JDIM02.147 JDIM02.148 JDIM02.153 JDIM02.154 JDIM02.159 JDIM02.160 JDIM02.163 JDIM02.178 JDIM02.199 JDIM02.220 JDIM02.241 PC9065.1 PC9066.1 PJ5000.1 PQ9008.5 R26.2 R71.1 R224.1 R231.2 R232.2 R233.1 R234.1 R235.1 R236.1 R237.1 R238.1 R239.1 R240.1 R241.1 R25602.1 R25603.1 R25604.1 R25605.1 R25606.1 R25607.1 R25608.1 R25609.1 R25610.1 R25611.1 R25612.1 U1.AD36 U1.AH32 U1.AH36 U1.AM36 U1.AN32 U1.AW32 U1.AY36 U1.BE32 U1.BH36 U1.R32 U1.Y36
+1.5V: PJ3008.2 Q21.2 R449.2 R462.2
+1.05V_DEEP_SUS: C226.2 C231.2 C244.1 C245.2 L2.1 PJ3005.2 PQ11.3 PQ35.5 R83.1 R1262.2 R1264.2 R1265.2 R1266.2 R1267.2 R1271.2 R1275.1 R1277.1 R1279.1 R1280.1 R2525.1 U1.BU15 U1.BU22 U1.BV15 U1.BV16 U1.BV18 U1.BV19 U1.BV20 U1.BV22 U1.BW20 U1.BW22 U1.CA12 U1.CA16 U1.CA18 U1.CA19 U1.CA20 U1.CB12 U1.CB14 U1.CB15
+1.05V_LAN: C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C96304.1 C96305.1 C96311.2 C96312.2 L4000.2 R67598.2 R67599.2 U6521.8 U6521.11 U6521.16 U6521.22 U6521.37 U6521.40 U6521.43
+1.05V_LAN_REGOUT: C20000.1 L4000.1 U6521.7
+1.8V: C20141.1 PQ9.1(S) PR9227.1 U6516.C1
+1.8V_DEEP_SUS: R153.2 R180.1 R662.1 R663.1 R664.1 R1253.1 R1272.2 R25466.1 U35.5(VCC) U36.5(VCC)
+1.8V_S5: CN49.16 PC9053.1 PC9054.1 PJ9005.1 PQ9.3 PU9002.1 PU9002.2 PU9002.6 PU9002.7 R25466.2
+1.8V_SM: C20046.1 C20047.2 U6509.15 U6509.16 U6509.17
+1.35V_GFX: C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.1 C485.1 C486.1 C487.1 C488.1 C489.1 C490.1 C491.2 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.1 C501.1 C502.1 C503.1 C504.1 PJ9002.2 PR9099.1 R314.2 R316.1 R318.1 R321.1 R322.1 R407.1 R25284.1 U8.B26 U8.C25 U8.E23 U8.E26 U8.F14 U8.F21 U8.G13 U8.G14 U8.G15 U8.G16 U8.G18 U8.G19 U8.G20 U8.G21 U8.H24 U8.H26 U8.J21 U8.K21 U8.L22 U8.L24 U8.L26 U8.M21 U8.N21 U8.R21 U8.T21 U8.V21 U8.W21 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14
+1V8_AON: C371.1 C376.1 C378.1 C433.2 PR9018.1 PR9068.2 PR9076.2 Q13.2 Q13.5 Q6512.2 R297.2 R326.2 R330.2 R339.1 R344.2 R345.2 R346.2 R347.2 R348.2 R349.2 R362.2 R364.2 R365.2 R382.2 R391.2 R395.2 R397.2 R399.2 R403.2 R404.2 R25322.2 R25490.2 R25492.2 U8.G10 U8.G12 U9.5(VCC)
+1V8_GFX_MAIN: C360.2 C362.1 C377.2 C379.2 C381.2 C383.2 C392.1 C394.1 C395.1 C398.1 C399.1 C401.1 C402.1 L4.1 L5.1 L6.1 L7.1 L8.1 PR9067.1 PR9085.1 PR9103.1 R299.1 U8.AA10 U8.AA12 U8.AA13 U8.AA16 U8.AA18 U8.AA19 U8.AA20 U8.AA21 U8.AB22 U8.AC23 U8.AD24 U8.AE25 U8.AF26 U8.AF27 U8.G8 U8.G9
+1V8_MAIN_EN_G: PQ9083.3 PQ9084.2 PR9102.2 PR9104.1
+1V_S5_ON: PR274.1 U37.95
+1V_SUS: PC83.2 PQ11.1(S) PR105.1 PR7102.2 R9261.1
+2.5V_SUS: C269.1 C271.1 C273.1 C275.1 C20106.2 C20109.2 C20112.1 C20115.1 JDIM1.257 JDIM1.259 JDIM02.257 JDIM02.259 PR5001.2
+3.3V_TYPEC_MUX1: C20058.1 C20059.1 C20060.1 C20061.1 C20062.1 C20063.1 C20065.2 R178.2 R208.1 R25561.1 R25565.2 R25567.2 R25569.2 R25570.1 R25571.1 R25572.2 R25573.2 U12.6 U12.17(VDD_DCI) U12.20 U12.28
+3V: C278.1 C280.1 C452.2 C546.2 C559.2 C618.2 C619.1 C628.2 C1687.1 C1688.1 C1689.1 C1690.1 C1691.1 C1692.1 C1693.1 C20011.2 C20099.2 C20100.1 CN49.29 CN49.30 EC10.1 EC11.1 JDIM1.255 JDIM02.255 L17.1 PR106.1 PR275.1 PR5006.2 PR6416.1 PR7068.1 PR9009.1 PR9075.1 PR9088.1 PR9245.2 PR9255.1 Q3.2 Q3.5 Q6531.2 Q6555.2 Q6556.2 Q6557.2 Q6558.2 Q6559.2 Q6564.2 Q6564.5 R43.2 R94.2 R96.2 R98.2 R100.2 R102.2 R114.1 R115.1 R120.2 R134.2 R154.2 R155.2 R159.2 R179.2 R212.2 R225.1 R226.1 R227.1 R378.2 R385.2 R386.2 R439.1 R440.1 R452.2 R455.1 R460.1 R494.1 R502.1 R509.1 R551.2 R554.2 R576.2 R732.2 R746.2 R747.2 R753.1 R772.1 R830.2 R1239.1 R2661.2 R2666.2 R10880.2 R25271.2 R25307.1 R25312.2 R25346.1 R25348.2 R25367.2 R25372.1 R25376.2 R25377.1 R25428.1 R25429.1 R25430.1 R25434.2 R25436.2 R25440.2 R25441.2 R25444.2 R25459.1 R25474.2 R25475.1 R25482.1 R25493.2 R25526.2 R25596.1 R25597.2 R25598.1 R25625.1 R67556.1 R67557.1 R67560.2 R67561.1 R67563.1 R67568.1 R67571.1 R67572.1 R67573.1 R67606.2 R67855.1 R67856.1 R67857.1 R67858.1 R67865.1 R67888.1 U11.5 U19.4 U19.5 U23.1 U23.18(VDD#2) U23.22 U67.14 U67.26
+3V3_TPM: C740.1 C741.1 C742.1 C744.1 R580.2 R25344.2 R25346.2 U33.8 U33.22
+3V3_TPM_VSB: C743.2 C745.2 R25347.1 R25348.1 U33.1(VSB)
+3V_CCD_PWR1_C: CN29.32 CN29.33 R25459.2
+3V_CR: C1650.1 C1652.2 R753.2 U40.4
+3V_DEEP_SUS: C246.2 C6609.1 Q6554.2 Q6554.5 Q6568.2 Q6568.5 R31.1 R32.1 R89.2 R95.2 R97.2 R103.1 R104.1 R117.2 R119.2 R123.2 R186.1 R213.2 R1251.1 R1252.2 R1260.2 R1273.2 R1274.2 R1276.1 R25336.2 R25343.1 R67529.2 R67530.2 U3.1(VOUT) U6504.5(VCC)
+3V_EC: C1189.1 R25307.2 R25317.2 U37.11
+3V_LAN: C641.1 C642.1 C96300.1 C96301.1 C96302.2 C96303.2 C96308.1 C96309.1 C96310.1 R4023.2 R4024.2 R9340.2 R25445.2 R25617.2 R25618.1 R67474.1 R67475.1 R67509.1 R67510.1 R67511.1 R67512.1 U6521.4 U6521.5(VDDREG) U6521.15 U6521.19 U6521.29
+3V_LDO_EC: D63.1(CATHODE) PD8004.1(CATHODE) PQ8014.1(S) PQ8016.4(E2) PR6017.1 PR8010.1 PR8020.2 R359.1 R361.2 R369.2 R25300.2 R25306.1 R25309.2 R25314.2 R67484.2 R67485.2 R67486.2 R67487.2 R67871.1
+3V_RTC: C1214.1 C96343.1 CN4.4 D72.3(CATHODE) R42.2 R210.2 R971.1 R979.1 R25310.1 U6525.3(VDD)
+3V_RTC_0: CN1.1 Q28.1(EMITTER) R953.1
+3V_RTC_1: D72.1 R953.2
+3V_RTC_2: D72.2 R978.2
+3V_S5: C242.1 C695.1 C2321.2 C2335.2 CN33.1 PC242.1 PC571.1 PC572.1 PR9244.1 PU3003.4(VIN) PU3004.3(VIN) Q27.2 Q27.5 Q29.2 R33.2 R35.2 R36.2 R37.2 R38.2 R40.2 R41.1 R60.2 R126.2 R144.2 R152.2 R215.1 R375.2 R559.2 R562.2 R566.2 R567.2 R574.2 R604.2 R605.2 R606.2 R607.2 R1270.2 R1281.1 R2667.2 R25317.1 R25330.1 R25336.1 R25381.2 R25382.2 R25383.2 R25384.2 R25388.2 R25389.2 R25390.2 R25395.2 R25396.2 R25397.2 R25398.2 R25399.2 R25413.1 R25415.1 R25437.2 R25438.2 R25439.2 R25472.2 R25477.2 R25520.2 R25570.2 R25618.2 R25622.1 R67413.2 R67481.1 R67482.1 R67483.2 R67853.1 R67854.1 R67859.1 R67860.1 R67883.2 R67884.2 R67889.1 U3.4 U3.5 U2014.5(VCC) U2015.5
+3V_SM: C20041.1 C20043.1 C20048.1 C20049.2 R25555.1 U6509.10 U6509.14 U6509.18
+3V_SSD: C785.2 C786.2 C2616.2 CN16.2 CN16.4 CN16.12 CN16.14 CN16.16 CN16.18 CN16.70 CN16.72 CN16.74 EC9.2 R649.1 R2661.1
+3V_WLAN_P: C800.1 C801.1 C802.1 C804.1 C805.2 C2609.1 C2611.1 C2612.1 C96344.1 CN17.2 CN17.4 CN17.72 CN17.74 Q33.2 Q63.2 R651.2 R652.2 R671.2 R672.2 R2666.1 R2667.1
+3VLCD_CON: C560.1 C561.1 C562.1 R25458.1 U19.1(VOUT)
+3VLCD_CON_R: C543.2 C544.1 CN29.34 CN29.35 CN29.36 R25456.1 R25458.2
+3VLCD_CON_R_C: CN29.37 R25456.2
+3VPCU: C212.1 C735.2 C20131.2 CN48.6 CN52.2 CN55.5 PC6015.1 PC6016.1 PJ6001.2 PR9.2 PR15.2 PR18.2 PR204.2 PR6003.1 PR8011.1 PR8019.1 PR8037.2 PR8038.1 PR8048.2 PR8058.1 PU6001.1 PU6001.2 PU6001.6 PU6001.7 Q23.1(S) Q6548.2 Q6566.2 R383.2 R736.1 R978.1 R25295.2 R25304.2 R25323.2 R25368.2 R25370.1 R25519.1 R25561.2 R25579.2 R25619.1 R67604.2
+3VPCU_EC: C6565.1 C6569.1 C6570.1 C6574.1 C6575.1 C6577.1 C6578.1 L29.1 L30.2 R25306.2 U37.26 U37.50 U37.92 U37.114 U37.121
+3VPCU_ECPLL: C6573.1 L30.1 U37.127
+3VSPI: C189.2 C190.1 CN59.8 CN60.8 R107.1 R112.2 R222.1 R583.2 R586.2 R25343.2 R25344.1 R25347.2 U6526.8 U6528.8
+4.6V_PD_C1: PC8009.1 PC8010.1 PQ8017.3 PR8053.1 PR8063.2 PU8001.5
+5V: C545.1 C550.1 C596.1 C597.2 C734.2 C770.1 C771.1 C772.1 C20039.1 C20044.1 C20045.2 C96247.1 C96248.1 C96249.2 CN50.1 CN50.2 L15.1 L16.1 PR126.1 PR9249.2 Q30.1(S) Q6508.3 Q6534.3 R575.2 R579.1 R25373.1 R25462.1 R25528.1 R25529.1 R67359.1 R67565.2 U6509.4 U6509.13
+5V_FAN: FAN3.1 R575.1
+5V_HDD: C669.1 C670.1 C680.1 C689.1 C20143.1 C96242.1 CN11.3 CN11.4 CN11.5 CN11.6 R67359.2
+5V_HDMIC: C6560.1 CN37.18 D14.3(COMMON ANODE) D50.2 Q6508.1(VOUT)
+5V_KB: C736.1 C737.2 CN13.2 CN13.4 Q30.3
+5V_PD: PD8005.1(CATHODE) PQ8018.4(E2) PR8051.2 R25589.1
+5V_PVDD: C574.1 C575.1 C576.1 C577.1 L15.2 U20.41 U20.46
+5V_S5: C512.1 C524.1 PR5003.1 PR7064.1 PR7065.1 PR7069.1 PR7080.1 PR7103.2 PR7108.1 PR7112.1 PR7116.1 PR9001.1 PR9013.1 PR9074.1 PR9087.1 PR9091.2 PR9100.1 PR9248.1 U15.5 U18.5
+5VA: C568.1 C569.1 C598.2 C599.1 L16.2 U20.26
+5VPCU: C508.1 C20081.2 C20082.1 C96326.2 C96329.1 C96348.1 C96349.1 CN46.1 CN49.1 CN49.2 CN49.3 CN49.4 PC6036.1 PC6037.1 PC9072.1 PJ6003.2 PR98.2 PR104.1 PR6013.1 PR6023.1 PR8049.1 PR9069.1 PU6002.1 PU6002.2 PU6002.6 PU6002.7 PU9003.1(VCC) R160.2 R417.1 R418.1 R67360.1 R67361.1 R67594.1 U14.1 U6510.2 U6523.1
+A3VPCU: C6566.1 L29.2 U37.74
+V3.3DX_1.5DX_ADO: C241.2 L3.2 R1278.1
+V3A_LX: PC6001.2 PL6000.1 PR6001.1 PU6000.2 PU6000.3
+V3A_LX_R: PC6006.1 PR6001.2
+V3A_OUT: PC6008.1 PC6009.1 PC6010.1 PC6011.1 PC6012.1 PC6013.1 PC6014.1 PJ6001.1 PL6000.2 PR6008.2
+V5P5A_LX: PC6035.2 PL6001.1 PR6019.1 PU6003.2 PU6003.3
+V5P5A_LX_R: PC6038.1 PR6019.2
+V5P5A_OUT: PC6044.1 PC6045.1 PC6046.1 PC6047.1 PC6048.1 PC6049.1 PC6050.1 PJ6003.1 PL6001.2 PR6026.2
+VCC_CORE: C11.2 C12.2 C13.1 C14.2 C15.1 C16.2 C17.2 C18.2 C19.1 C20.2 C21.1 C22.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.1 C29.1 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.1 C45.2 C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C55.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C65.1 C66.2 C67.2 C68.1 C69.2 C70.2 C71.2 C72.2 C73.1 PC7039.2 PC7040.1 PC7041.1 PC7042.1 PC7043.1 PC7044.1 PC7045.1 PC7057.2 PC7058.1 PC7059.1 PC7060.1 PC7061.1 PC7062.1 PL7000.2 PL7001.2 PR7043.2 PR7074.1 PR7083.1 R77.1 R78.1 R80.1 U1.AN9 U1.AN10 U1.AN24 U1.AN26 U1.AN27 U1.AP2 U1.AP9 U1.AP24 U1.AP26 U1.AR5 U1.AR6 U1.AR7 U1.AR8 U1.AR10 U1.AR25 U1.AR27 U1.AT9 U1.AT24 U1.AT26 U1.AU5 U1.AU6 U1.AU7 U1.AU8 U1.AU9 U1.AU24 U1.AU25 U1.AU26 U1.AU27 U1.AV2 U1.AV5 U1.AV7 U1.AV10 U1.AV27 U1.AW5 U1.AW6 U1.AW7 U1.AW8 U1.AW9 U1.AW10 U1.AW24 U1.AW25 U1.AW26 U1.AW27 U1.AY24 U1.AY26 U1.BA5 U1.BA7 U1.BA8 U1.BA25 U1.BA27 U1.BB2 U1.BB26 U1.BC5 U1.BC6 U1.BC7 U1.BC9 U1.BC10 U1.BC26 U1.BC27 U1.BD5 U1.BD8 U1.BD10 U1.BD25 U1.BD27 U1.BE9 U1.BE24 U1.BE25 U1.BE26 U1.BE27 U1.BF2 U1.BF9 U1.BF24 U1.BF26 U1.BG27
+VCC_V3A: PC6022.1 PU6000.9
+VCC_V5P5A: PC6058.1 PU6003.11
+VCC_XD: C1653.2 C96319.1 C96320.1 F1.1 U40.5
+VCCGT: C134.1 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C145.1 C146.1 C147.1 C148.1 C149.1 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.1 C166.2 C167.2 C168.2 C169.1 C177.2 C178.1 C179.1 C180.1 C181.1 C182.1 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 PC7087.2 PC7088.1 PC7089.1 PC7090.1 PC7091.1 PC7092.1 PC7093.1 PC7094.1 PC7095.1 PL7003.2 PR7050.2 PR7097.1 R79.1 R81.1 U1.A5 U1.A6 U1.A8 U1.A11 U1.A12 U1.A14 U1.A15 U1.A17 U1.A18 U1.A20 U1.B3 U1.B4 U1.B6 U1.B8 U1.B11 U1.B14 U1.B17 U1.B20 U1.C2 U1.C3 U1.C6 U1.C7 U1.C8 U1.C11 U1.C12 U1.C14 U1.C15 U1.C17 U1.C18 U1.C20 U1.D4 U1.D7 U1.D11 U1.D12 U1.D14 U1.D15 U1.D17 U1.D18 U1.D20 U1.E4 U1.F5 U1.F6 U1.F7 U1.F8 U1.F11 U1.F14 U1.F17 U1.F20 U1.G11 U1.G12 U1.G14 U1.G15 U1.G17 U1.G18 U1.G20 U1.H5 U1.H6 U1.H7 U1.H8 U1.H11 U1.H12 U1.H14 U1.H15 U1.H17 U1.H18 U1.H20 U1.J7 U1.J8 U1.J11 U1.J14 U1.J17 U1.J20 U1.K2 U1.K11 U1.L7 U1.L8 U1.L10 U1.M9 U1.N7 U1.N8 U1.N9 U1.N10 U1.P2 U1.P8 U1.R9 U1.T8 U1.T9 U1.T10 U1.U8 U1.U10 U1.V9 U1.W8 U1.W9
+VCCGT_+VCORE: C142.2 C143.2 C144.2 C162.2 C163.2 C164.2 C165.2 C170.1 C171.1 C172.2 C173.2 C174.2 C175.2 C176.1 R77.2 R78.2 R79.2 R80.2 R81.2 U1.AA9 U1.AB2 U1.AB8 U1.AB9 U1.AB10 U1.AC8 U1.AD9 U1.AE8 U1.AE9 U1.AE10 U1.AF2 U1.AF8 U1.AF10 U1.AG8 U1.AG9 U1.AH9 U1.AJ8 U1.AJ10 U1.AK2 U1.AK9 U1.AL8 U1.AL9 U1.AL10 U1.AM8 U1.V2 U1.Y8 U1.Y10
+VCCIO: C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C89.2 PC236.2 PC756.1 PQ35.1 PQ35.2 PQ35.3(S3) PR22.2 PR111.1 PR7011.2 R2.1 R23.2 R69.1 R72.2 U1.AK24 U1.AK26 U1.AL24 U1.AL25 U1.AL26 U1.AL27 U1.AM25 U1.AM27 U1.BH24 U1.BH25 U1.BH26 U1.BH27 U1.BJ24 U1.BJ26 U1.BP16 U1.BP18
+VCCLDOSRAM_1P24: R211.2 U1.BY23 U1.BY24 U1.CA23 U1.CA24
+VCCPLL: C57.1 C123.2 R70.2 U1.BR11 U1.BT11
+VCCPLL_OC: C117.1 R71.2 U1.BL27 U1.BM26
+VCCRTC: C239.2 C240.2 R210.1 U1.BR23
+VCCSA: C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 PC7072.1 PC7073.1 PC7074.1 PC7075.1 PC7076.1 PC7077.1 PL7002.2 PR7057.2 PR7089.1 U1.BG8 U1.BG10 U1.BH9 U1.BJ8 U1.BJ9 U1.BJ10 U1.BK8 U1.BK25 U1.BK27 U1.BL8 U1.BL9 U1.BL10 U1.BL24 U1.BL26 U1.BM24 U1.BN25
+VCCST: C56.2 C118.1 C119.1 C122.2 Q85.3 R10.1 R11.1 R12.1 R13.1 R14.1 R15.1 R19.1 R22.2 R63.2 R65.1 R67.1 R70.1 R822.2 R2229.2 R9261.2 U1.BP2 U1.BP11
+VCCSTG: C116.1 R69.2 U1.BG1 U1.BG2 U1.BG3
+VDD_IO: CN58.2 CN58.3 CN58.15 R67560.1 R67562.1
+VDD_SIM: CN58.10 R67562.2
+VDDD_SUPPLY: C20088.1 C20089.2 C20090.2 R135.1 R197.2 R25580.1 R25589.2 R67478.2 TP9059.1 U6511.31 U6511.32
+VDDQ: PR5014.2 R67574.2 R67575.2
+VDDQ_BOOT1: PC5011.1 PR5004.1
+VDDQ_P: PC5000.1 PC5013.1 PC5014.1 PC5015.1 PC5016.1 PC5017.1 PJ5000.2 PL5000.2 PR5005.1 PR5008.1
+VDDQ_SR: PC5018.1 PR5007.2
+VDDQ_VTT: C251.1 C253.1 C255.1 C257.1 C259.1 C261.1 C20105.1 C20108.1 C20111.1 C20114.1 C20117.1 C20119.1 JDIM1.258(VTT) JDIM02.258(VTT) PR5011.2
