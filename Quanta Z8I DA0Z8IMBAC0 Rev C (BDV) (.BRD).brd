# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ30: length 65.4
  IN4 w0.089: v2(95.66,157.95) 95.35,157.95 94.49,158.82 92.29,158.82 91.34,159.77 75.92,159.77 68.25,152.1 64.42,152.1 63.91,151.59 61.08,151.59 60.96,151.47 60.96,151.12 60.87,151.03 60.5,151.03 60.41,151.12 60.41,151.49 60.31,151.59 57.82,151.59 57.3,151.07 54.23,151.07 54.03,150.87 54.03,150.52 52.62,149.11 52.04,149.11 51.95,149.21 51.95,149.72 51.65,150.02 49.85,150.02 49.73,149.9 49.73,149.56 49.61,149.44 49.3,149.44 49.2,149.53 49.2,150.27 49.36,150.42 v1(49.36,150.84)
  BOTTOM w0.079: v2(95.66,157.95) 96.04,158.33 97.09,158.33 97.24,158.19 97.24,157.82 97.66,157.4 99.23,157.4 99.45,157.62 100.32,157.62 100.34,157.62 100.53,157.69 100.7,157.69 U1.R36
  BOTTOM w0.114: JDIM1.79 51.69,152.07 51.19,151.57 50.09,151.57 v1(49.36,150.84)
M_A_DQ31: length 64.3
  IN4 w0.089: v2(96.88,157.95) 96.48,158.36 95.45,158.36 94.74,159.07 92.44,159.07 91.4,160.11 75.78,160.11 68.11,152.44 64.28,152.44 63.98,152.15 63.66,152.15 63.36,152.44 63.09,152.44 62.98,152.33 62.98,152.05 62.86,151.93 62.56,151.93 62.46,152.03 62.46,152.35 62.37,152.44 62.08,152.44 61.98,152.34 61.98,152.05 61.87,151.93 61.54,151.93 61.46,152.02 61.46,152.35 61.37,152.44 61.06,152.44 60.97,152.35 60.97,152.07 60.84,151.93 57.68,151.93 57.16,151.41 54.09,151.41 53.72,151.04 52.97,151.04 52.85,150.92 52.85,149.82 52.69,149.67 52.38,149.67 52.29,149.76 52.29,150.92 52.17,151.04 51.95,151.04 51.82,150.91 51.82,150.47 51.72,150.36 50.81,150.36 50.68,150.49 v1(50.68,150.82)
  BOTTOM w0.079: U1.R35 101.18,157.52 100.56,157.52 100.34,157.45 99.5,157.45 99.28,157.22 97.46,157.22 96.88,157.8 v2(96.88,157.95)
  BOTTOM w0.114: JDIM1.83 51.95,151.07 51.77,150.9 51.77,150.57 51.57,150.36 51.13,150.36 v1(50.68,150.82)
M_A_DQ32: length 70.7
  IN4 w0.089: v2(92.45,145.28) 91.88,145.28 91.52,144.93 89.99,144.93 88.96,143.89 85.55,143.89 73.81,132.15 73.68,132.15 73.52,132.31 73.4,132.31 73.21,132.12 73.21,131.99 73.37,131.83 73.37,131.71 73.18,131.52 73.03,131.52 72.88,131.67 72.76,131.67 68.68,127.59 66.02,127.59 65.55,127.12 64.48,127.12 63.79,126.42 61.04,126.42 60.94,126.52 60.94,127.01 60.84,127.12 60.56,127.12 60.47,127.03 60.47,126.52 60.37,126.42 57.59,126.42 57.47,126.55 57.47,127.05 57.4,127.12 57.1,127.12 57.01,127.03 57.01,126.53 56.9,126.42 56.6,126.42 56.49,126.53 56.49,127.01 56.38,127.12 56.19,127.12 55.97,126.9 55.67,126.9 55.28,127.29 53.29,127.29 53.07,127.5 v1(51.26,127.5)
  BOTTOM w0.079: U1.AN35 101.22,146.9 100.64,146.9 100.35,147.01 99.75,147.01 99.28,146.55 95.59,146.55 95.2,146.94 94.8,146.94
  BOTTOM w0.114: v2(92.45,145.28) 90.38,145.28 90.2,145.47 90.2,146.76 90.37,146.94 94.8,146.94 ; v1(51.26,127.5) 51.26,127.15 51.84,126.57 JDIM1.173
M_A_DQ33: length 68.1
  IN4 w0.089: v1(48,127.91) 49.36,129.27 52.76,129.27 53.71,128.32 55.71,128.32 55.88,128.15 65.12,128.15 65.59,128.62 68.25,128.62 74.89,135.25 75.46,135.25 85.12,144.92 88.54,144.92 89.33,145.72 91.17,145.72 91.56,146.11 94.86,146.11 97.89,145.79 v2(98.26,145.42)
  BOTTOM w0.079: U1.AN34 102.18,145.77 102.07,145.66 101.79,145.66 101.67,145.71 101.4,145.71 101.34,145.68 101.08,145.68 101.03,145.71 100.76,145.71 100.69,145.68 100.48,145.68 100.39,145.71 100.02,145.71 99.64,145.33 99.37,145.33 99.19,145.14 98.72,145.14 v2(98.26,145.42)
  BOTTOM w0.114: v1(48,127.91) 46.41,126.32 JDIM1.174
M_A_DQ34: length 70.2
  IN4 w0.089: v2(94.58,144.04) 94.58,143.99 94.23,143.65 90.62,143.65 88.97,142 86.34,142 68.87,124.53 62.98,124.53 62.33,123.88 57.59,123.88 57.12,124.34 54.19,124.34 53.79,124.75 50.62,124.75 49.51,123.63 49.17,123.63 49.03,123.77 49.03,124.36 48.94,124.44 48.65,124.44 48.56,124.36 48.56,123.72 48.47,123.63 48.15,123.63 48.03,123.75 v1(48.03,125.08)
  BOTTOM w0.079: U1.AR35 101.18,144.93 100.56,144.93 100.49,144.91 100.24,144.66 99.65,144.66 99.46,144.47 94.93,144.47 94.58,144.11 v2(94.58,144.04)
  BOTTOM w0.114: v1(48.03,125.08) 46.19,123.25 45.62,123.25 45.55,123.32 JDIM1.186
M_A_DQ35: length 70.5
  IN4 w0.089: v2(97.62,145.38) 96.45,144.21 95.21,144.21 95.02,144.01 95.02,143.72 94.73,143.43 90.75,143.43 88.97,141.65 86.48,141.65 69.01,124.19 64.87,124.19 64.8,124.11 64.8,123.57 64.71,123.47 64.42,123.47 64.33,123.57 64.33,124.1 64.24,124.19 63.95,124.19 63.85,124.09 63.85,123.16 63.76,123.07 60.92,123.07 60.81,123.18 60.81,123.45 60.72,123.54 60.4,123.54 60.33,123.47 60.33,123.17 60.23,123.07 59.96,123.07 59.87,123.16 59.87,123.45 59.78,123.54 59.52,123.54 59.43,123.45 59.43,123.18 59.32,123.07 57.91,123.07 56.98,124 54.05,124 53.65,124.4 53.43,124.4 53.34,124.32 53.34,123.73 53.24,123.63 52.96,123.63 52.87,123.72 52.87,124.3 52.77,124.4 52.51,124.4 52.43,124.33 52.43,123.9 52.35,123.81 52.1,123.81 52.01,123.9 52.01,124.31 51.91,124.4 50.98,124.4 50.83,124.26 v1(50.83,123.68)
  BOTTOM w0.079: U1.AR34 102.18,145.37 102.07,145.49 101.76,145.49 101.63,145.54 101.44,145.54 101.37,145.51 101.05,145.51 100.99,145.54 100.79,145.54 100.72,145.51 100.46,145.51 100.37,145.54 100.09,145.54 99.71,145.16 99.44,145.16 99.26,144.98 98.02,144.98 v2(97.62,145.38)
  BOTTOM w0.114: v1(50.83,123.68) 50.83,123.87 51.26,124.3 51.72,124.3 51.95,124.07 JDIM1.183
M_A_DQ36: length 69.2
  IN4 w0.089: v1(46.72,127.79) 47.04,127.48 47.04,126.7 47.11,126.63 47.49,126.63 47.61,126.74 47.61,127.36 47.73,127.48 48.01,127.48 48.15,127.34 48.15,126.76 48.24,126.67 48.61,126.67 48.69,126.76 48.69,127.3 49.15,127.75 49.15,128.57 49.5,128.92 52.62,128.92 53.57,127.97 55.57,127.97 55.74,127.8 65.27,127.8 65.74,128.27 68.39,128.27 74.12,134 74.69,134 74.88,134.19 74.88,134.31 74.71,134.47 74.71,134.59 74.9,134.78 75.03,134.78 75.19,134.62 75.31,134.62 85.27,144.58 88.68,144.58 89.54,145.44 91.27,145.44 91.72,145.89 93.71,145.89 v2(94.28,145.32)
  BOTTOM w0.079: v2(94.28,145.32) 95.18,146.21 99.42,146.21 99.8,146.59 U1.AN37
  BOTTOM w0.114: v1(46.72,127.79) 46.25,127.32 JDIM1.170
M_A_DQ37: length 70.2
  IN4 w0.089: v2(93.67,145.3) 93.31,145.67 91.88,145.67 91.39,145.18 89.82,145.18 88.87,144.23 85.41,144.23 74.54,133.37 74.42,133.37 74.26,133.53 74.13,133.53 73.94,133.34 73.94,133.21 74.1,133.05 74.1,132.93 73.95,132.77 73.38,132.77 68.54,127.93 65.88,127.93 65.41,127.46 55.59,127.46 55.42,127.63 53.43,127.63 53.21,127.85 52.68,127.85 52.55,127.98 52.55,128.48 52.45,128.58 52.2,128.58 52.09,128.48 52.09,127.94 52,127.85 51.76,127.85 51.66,127.95 51.66,128.48 51.56,128.58 50.33,128.58 v1(49.94,128.19)
  BOTTOM w0.079: 94.88,146.38 99.35,146.38 99.82,146.84 100.32,146.84 100.61,146.74 100.74,146.74 U1.AN36
  BOTTOM w0.114: v1(49.94,128.19) 50.4,128.65 51.51,128.65 51.74,128.43 51.74,127.82 51.98,127.57 JDIM1.169 ; 94.88,146.38 91.88,146.38 91.71,146.21 91.71,145.92 91.89,145.74 93.52,145.74 93.67,145.59 v2(93.67,145.3)
M_A_DQ38: length 70.5
  IN4 w0.089: v1(46.64,125.12) 47.2,125.68 48.4,125.68 48.64,125.43 54.07,125.43 54.48,125.03 57.41,125.03 57.87,124.57 62.04,124.57 62.69,125.22 64.29,125.22 64.98,125.91 66.54,125.91 66.62,126 66.62,126.29 66.71,126.38 66.98,126.38 67.07,126.29 67.07,126 67.16,125.91 67.42,125.91 67.51,126 67.51,126.29 67.6,126.38 67.87,126.38 67.96,126.29 67.96,126 68.05,125.91 68.31,125.91 68.4,126 68.4,126.29 68.49,126.38 69.18,126.38 70.46,127.67 70.59,127.67 70.75,127.51 70.88,127.51 71.06,127.7 71.06,127.82 70.9,127.98 70.9,128.11 71.09,128.3 71.22,128.3 71.38,128.14 71.5,128.14 71.69,128.33 71.69,128.45 71.53,128.61 71.53,128.74 71.72,128.92 71.85,128.92 72.01,128.77 72.13,128.77 72.32,128.95 72.32,129.08 72.16,129.24 72.16,129.36 72.35,129.55 72.48,129.55 72.64,129.39 72.76,129.39 72.95,129.58 72.95,129.71 72.79,129.87 72.79,129.99 72.98,130.18 73.11,130.18 73.27,130.02 73.39,130.02 86.05,142.68 88.94,142.68 90.43,144.17 92.16,144.17 92.42,144.42 92.97,144.42 v2(93.36,144.04)
  BOTTOM w0.079: U1.AR36 100.7,145.1 100.53,145.1 100.4,145.06 100.17,144.83 99.58,144.83 99.4,144.64 93.89,144.64 93.36,144.11 v2(93.36,144.04)
  BOTTOM w0.114: JDIM1.182 46.02,124.32 46.64,124.94 v1(46.64,125.12)
M_A_DQ39: length 70.5
  IN4 w0.089: v1(50.04,124.81) 50.32,125.09 53.93,125.09 54.33,124.69 57.27,124.69 57.73,124.22 62.18,124.22 62.83,124.87 65.12,124.87 65.21,124.96 65.21,125.48 65.3,125.57 65.57,125.57 65.66,125.48 65.66,124.96 65.75,124.87 66.01,124.87 66.1,124.96 66.1,125.48 66.19,125.57 66.46,125.57 66.55,125.48 66.55,124.96 66.64,124.87 66.9,124.87 66.99,124.96 66.99,125.48 67.08,125.57 67.35,125.57 67.44,125.48 67.44,124.96 67.52,124.87 67.8,124.87 67.9,124.97 67.9,125.49 67.99,125.57 68.24,125.57 68.31,125.49 68.31,124.99 68.43,124.87 68.73,124.87 69.12,125.26 69.12,125.39 68.79,125.71 68.79,125.85 68.98,126.04 69.1,126.04 69.43,125.7 69.56,125.7 69.75,125.89 69.75,126.02 69.58,126.19 69.58,126.3 69.77,126.49 69.91,126.49 70.06,126.33 70.19,126.33 70.38,126.52 70.38,126.65 70.21,126.81 70.21,126.93 70.4,127.12 70.53,127.12 70.69,126.96 70.82,126.96 86.19,142.34 89,142.34 90.59,143.94 92.64,143.94 v2(92.75,144.04)
  BOTTOM w0.079: v2(92.75,144.04) 92.8,144.09 92.8,144.12 93.48,144.81 99.33,144.81 99.51,145 99.94,145 U1.AR37
  BOTTOM w0.114: JDIM1.187 50.74,123.07 50.04,123.77 v1(50.04,124.81)
M_A_DQ40: length 73.9
  IN4 w0.089: v2(95.39,143.79) 94.81,143.22 90.88,143.22 88.99,141.33 87.76,141.33 87.48,141.06 86.73,141.06 82.44,136.77 82.44,136.46 79.34,133.35 79.02,133.35 69.26,123.59 65.67,123.59 64.55,122.47 57.67,122.47 57.1,123.03 49.08,123.03 48.93,122.89 48.93,122.09 48.84,122.01 48.55,122.01 48.46,122.1 48.46,122.94 48.37,123.03 48.1,123.03 47.98,122.92 47.98,122.39 47.86,122.27 47.56,122.27 47.43,122.39 47.43,124.35 47.32,124.47 46.67,124.47 46.52,124.32 46.52,122.86 46.59,122.79 v1(46.59,121.88)
  BOTTOM w0.079: v2(95.39,143.79) 95.9,144.31 99.53,144.31 99.72,144.49 100.35,144.49 100.64,144.39 101.22,144.39 U1.AU35
  BOTTOM w0.114: v1(46.59,121.88) 46.15,122.32 JDIM1.190
M_A_DQ41: length 74.8
  IN4 w0.089: v2(97.22,143.76) 96.25,142.79 91.15,142.79 89,140.63 87.89,140.63 87.54,140.29 86.93,140.29 83.13,136.49 83.13,136.17 79.62,132.67 79.31,132.67 68.42,121.79 61.01,121.79 60.29,121.07 57.57,121.07 56.29,122.35 51.11,122.35 50.04,121.28 48.49,121.28 v1(47.91,121.86)
  BOTTOM w0.079: 96.48,142.85 96.57,142.85 96.82,143.1 97.73,143.1 98.43,143.8 99.8,143.8 99.82,143.82 100.36,143.82 100.44,143.84 100.71,143.84 100.81,143.81 100.99,143.81 101.07,143.85 101.27,143.85 101.41,143.82 101.63,143.82 101.74,143.87 101.98,143.87 U1.AU34
  BOTTOM w0.114: JDIM1.194 47.37,121.32 v1(47.91,121.86) ; 96.48,142.85 94.76,142.85 94.61,143 94.61,143.23 94.76,143.38 96.84,143.38 v2(97.22,143.76)
M_A_DQ42: length 75.7
  IN4 w0.089: v1(95.76,141.78) 95.26,141.28 91.61,141.28 89.5,139.18 88.78,139.18 87.95,138.34 87.66,138.34 85.24,135.92 85.24,134.06 82.86,131.68 81.84,131.68 81.59,131.44 81.59,131.31 81.98,130.93 81.98,130.8 81.79,130.61 81.66,130.61 81.28,131 81.16,131 80.97,130.81 80.97,130.68 81.35,130.3 81.35,130.17 81.16,129.98 81.04,129.98 80.65,130.37 80.53,130.37 80.34,130.18 80.34,130.05 80.72,129.67 80.72,129.54 80.53,129.36 80.41,129.36 80.02,129.74 79.9,129.74 79.71,129.55 79.71,129.43 80.09,129.04 80.09,128.92 79.9,128.73 79.78,128.73 79.39,129.11 79.27,129.11 79.08,128.92 79.08,128.8 79.46,128.41 79.46,128.29 79.27,128.1 79.15,128.1 78.76,128.48 78.64,128.48 76.26,126.11 75.42,126.11 68.05,118.74 56.71,118.74 56.19,119.26 52.58,119.26 52.16,119.68 51.01,119.68 49.78,118.46 48.08,118.46 v1(47.94,118.32)
  BOTTOM w0.079: v1(95.76,141.78) 96.11,141.44 98.03,141.44 98.57,141.97 98.74,141.97 99.29,142.52 99.85,142.52 100.02,142.35 100.34,142.35 100.56,142.42 101.18,142.42 U1.AW35
  BOTTOM w0.114: v1(47.94,118.32) 47.44,117.82 JDIM1.208
M_A_DQ43: length 74.5
  IN4 w0.089: v1(49.07,118.96) 49.14,118.96 50.2,120.02 52.31,120.02 52.72,119.61 56.33,119.61 56.86,119.08 67.6,119.08 67.83,119.31 67.83,119.63 67.69,119.76 67.69,119.91 67.89,120.11 68.06,120.11 68.33,119.83 68.66,119.83 75.28,126.45 76.12,126.45 82.04,132.37 82.21,132.37 82.55,132.02 82.72,132.02 82.96,132.27 82.96,132.39 82.56,132.79 82.56,132.89 82.75,133.08 82.9,133.08 83.27,132.71 83.4,132.71 83.59,132.9 83.59,133.02 83.45,133.16 83.45,133.29 83.64,133.48 83.76,133.48 83.9,133.34 84.03,133.34 84.22,133.53 84.22,133.65 83.83,134.05 83.83,134.16 84.04,134.37 84.17,134.37 84.53,134 84.69,134 84.9,134.2 84.9,134.35 84.53,134.71 84.53,134.86 84.9,135.22 84.9,136.06 87.52,138.69 87.73,138.69 88.23,139.18 88.53,139.48 89.46,139.48 91.71,141.74 v1(92.59,141.74)
  BOTTOM w0.079: U1.AW34 102.18,143.49 101.98,143.7 101.78,143.7 101.67,143.65 101.39,143.65 101.35,143.66 101.25,143.68 101.11,143.68 101.02,143.65 100.78,143.65 100.69,143.68 100.47,143.68 100.39,143.65 99.89,143.65 99.87,143.63 98.5,143.63 97.63,142.76 96.81,142.76 96.62,142.57 93.45,142.57 92.62,141.74 v1(92.59,141.74)
  BOTTOM w0.114: v1(49.07,118.96) 49.54,119.43 51.63,119.43 51.98,119.07 JDIM1.203
M_A_DQ44: length 73.7
  IN4 w0.089: v2(97.83,143.75) 96.65,142.57 91.38,142.57 89.18,140.37 88.13,140.37 87.71,139.95 87.07,139.95 83.47,136.34 83.47,136.03 82.95,135.51 82.95,135.39 83.09,135.25 83.09,135.12 82.85,134.89 82.73,134.89 82.59,135.03 82.46,135.03 82.27,134.84 82.27,134.71 82.41,134.57 82.41,134.45 82.22,134.26 82.1,134.26 81.96,134.4 81.83,134.4 81.65,134.21 81.65,134.08 81.78,133.94 81.78,133.82 81.59,133.63 81.47,133.63 81.33,133.77 81.21,133.77 81.02,133.58 81.02,133.45 81.15,133.32 81.15,133.19 80.97,133 80.84,133 80.7,133.14 80.58,133.14 80.39,132.95 80.39,132.82 80.53,132.69 80.53,132.56 80.34,132.37 80.21,132.37 80.07,132.51 79.95,132.51 79.76,132.32 79.76,132.2 79.9,132.06 79.9,131.93 79.71,131.74 79.58,131.74 79.29,132.04 79.16,132.04 78.97,131.85 78.97,131.72 79.27,131.43 79.27,131.3 79.08,131.11 78.95,131.11 78.67,131.4 78.52,131.4 78.33,131.21 78.33,131.11 78.64,130.8 78.64,130.67 78.45,130.49 78.32,130.49 78.03,130.78 77.9,130.78 77.71,130.59 77.71,130.47 78.01,130.17 78.01,130.05 77.82,129.86 77.7,129.86 77.4,130.16 77.28,130.16 77.09,129.97 77.09,129.83 77.38,129.54 77.38,129.42 77.14,129.17 77,129.17 76.73,129.43 76.56,129.43 68.57,121.44 64.52,121.44 63.8,120.72 61.54,120.72 61.14,121.12 60.84,121.12 60.43,120.72 57.43,120.72 56.84,121.31 56.34,121.31 56.24,121.4 56.24,121.91 56.14,122.01 55.8,122.01 55.72,121.93 55.72,121.38 55.62,121.28 53.85,121.28 53.73,121.4 53.73,121.88 53.61,122.01 53.38,122.01 53.25,121.88 53.25,121.39 53.14,121.28 52.92,121.28 52.82,121.37 52.82,121.91 52.72,122.01 52.47,122.01 52.36,121.9 52.36,121.36 52.28,121.28 52.01,121.28 51.94,121.35 51.94,121.9 51.84,122.01 51.25,122.01 50.88,121.64 v1(50.88,121.55)
  BOTTOM w0.079: v2(97.83,143.75) 98.05,143.97 99.67,143.97 99.77,144.07 U1.AU37
  BOTTOM w0.114: JDIM1.191 51.41,122.07 v1(50.88,121.55)
M_A_DQ45: length 73.6
  IN4 w0.089: v2(96,143.78) 95.23,143 91.05,143 88.94,140.89 87.73,140.89 87.55,140.71 86.87,140.71 82.78,136.63 82.78,136.32 79.48,133.01 79.16,133.01 69.4,123.25 68.55,123.25 68.46,123.16 68.46,122.31 68.37,122.22 68.11,122.22 68.02,122.31 68.02,123.16 67.93,123.25 67.66,123.25 67.57,123.16 67.57,122.22 67.49,122.13 67.22,122.13 67.13,122.22 67.13,123.16 67.04,123.25 66.77,123.25 66.69,123.16 66.69,122.22 66.6,122.13 66.33,122.13 66.24,122.22 66.24,123.16 66.15,123.25 65.81,123.25 65.1,122.54 65.1,122.33 64.9,122.13 60.87,122.13 60.15,121.41 57.71,121.41 56.43,122.69 50.25,122.69 50.16,122.6 50.16,122.24 50.05,122.13 49.82,122.13 49.72,122.23 49.72,122.62 49.65,122.69 49.4,122.69 49.27,122.57 49.27,121.72 v1(49.26,121.7)
  BOTTOM w0.079: v2(96,143.78) 96.36,144.14 99.6,144.14 99.79,144.33 100.32,144.33 100.61,144.22 100.74,144.22 U1.AU36
  BOTTOM w0.114: v1(49.26,121.7) 49.89,121.07 JDIM1.195
M_A_DQ46: length 74.1
  IN4 w0.089: v2(97.66,141.8) 97.66,141.46 96.91,140.71 91.79,140.71 89.64,138.55 89.26,138.55 88.36,137.66 87.95,137.66 85.93,135.64 85.93,133.78 75.38,123.23 75.25,123.23 74.47,124 74.35,124 74.16,123.81 74.16,123.69 74.94,122.91 74.94,122.79 74.75,122.6 74.62,122.6 73.84,123.37 73.72,123.37 73.53,123.19 73.53,123.06 74.31,122.28 74.31,122.16 74.12,121.97 73.99,121.97 73.22,122.75 73.03,122.75 67.83,117.54 56.94,117.54 56.36,118.11 48.49,118.11 48.29,117.92 46.99,117.92 v1(46.59,118.32)
  BOTTOM w0.079: v2(97.66,141.8) 98.16,141.8 98.49,142.13 98.68,142.13 99.24,142.69 99.92,142.69 100.09,142.51 100.32,142.51 100.53,142.58 100.7,142.58 U1.AW36
  BOTTOM w0.114: v1(46.59,118.32) 46.09,118.82 JDIM1.204
M_A_DQ47: length 73.6
  IN4 w0.089: v2(97.01,141.81) 97.01,141.34 96.65,140.99 91.71,140.99 89.58,138.86 89.02,138.86 88.16,138 87.8,138 85.58,135.78 85.58,133.92 79.21,127.55 79.09,127.55 78.7,127.93 78.58,127.93 78.39,127.74 78.39,127.62 78.77,127.23 78.77,127.11 78.58,126.92 78.46,126.92 78.07,127.3 77.95,127.3 77.76,127.11 77.76,126.99 78.14,126.61 78.14,126.48 77.95,126.29 77.83,126.29 77.45,126.67 77.32,126.67 77.13,126.49 77.13,126.36 77.51,125.98 77.51,125.85 77.32,125.66 77.2,125.66 76.82,126.05 76.69,126.05 76.5,125.86 76.5,125.73 76.89,125.35 76.89,125.22 76.7,125.03 76.57,125.03 75.84,125.76 75.68,125.76 75.49,125.57 75.49,125.48 76.26,124.72 76.26,124.59 76.07,124.4 75.94,124.4 75.14,125.21 75.01,125.21 74.82,125.02 74.82,124.9 75.48,124.23 75.48,124.13 75.29,123.94 75.15,123.94 74.51,124.58 74.38,124.58 74.19,124.39 74.19,124.39 68.19,118.39 56.57,118.39 56.04,118.92 52.44,118.92 52.02,119.34 51.26,119.34 v1(50.86,118.94)
  BOTTOM w0.079: v2(97.01,141.81) 97.18,141.81 97.52,142.15 98.27,142.15 98.41,142.29 98.61,142.29 99.18,142.86 100.15,142.86 U1.AW37
  BOTTOM w0.114: v1(50.86,118.94) 51.73,118.07 JDIM1.207
M_A_DQ48: length 73.5
  IN4 w0.089: v1(50.76,116.69) 51.24,117.17 52.29,117.17 52.56,116.9 56.25,116.9 56.55,116.6 68.22,116.6 70.42,118.8 70.54,118.8 71.23,118.12 71.37,118.12 71.56,118.31 71.56,118.42 70.86,119.12 70.86,119.24 71.05,119.43 71.17,119.43 71.98,118.63 72.1,118.63 72.29,118.82 72.29,118.94 71.49,119.75 71.49,119.87 71.68,120.06 71.8,120.06 72.61,119.26 72.73,119.26 72.92,119.44 72.92,119.57 72.12,120.37 72.12,120.5 72.31,120.69 72.43,120.69 73.24,119.88 73.36,119.88 84.99,131.51 85.89,131.51 86.86,132.48 86.86,135.12 88.32,136.58 88.32,136.72 89.46,137.86 89.65,137.86 91.71,139.93 v2(91.97,139.93)
  BOTTOM w0.079: U1.BA35 101.22,141.87 100.64,141.87 100.35,141.98 99.73,141.98 99.55,141.8 98.63,141.8 98.1,141.27 93.32,141.27 91.98,139.93 v2(91.97,139.93)
  BOTTOM w0.114: v1(50.76,116.69) 51.38,116.07 JDIM1.215
M_A_DQ49: length 73.2
  IN4 w0.089: v1(47.84,116.8) 48.01,116.8 48.73,117.52 52.43,117.52 52.7,117.24 56.39,117.24 56.69,116.94 68.07,116.94 72.36,121.23 72.5,121.23 73.07,120.67 73.22,120.67 73.4,120.86 73.4,120.96 72.79,121.57 72.79,121.66 72.98,121.85 73.14,121.85 73.93,121.06 74.05,121.06 84.84,131.85 85.75,131.85 86.52,132.62 86.52,135.39 89.4,138.27 89.74,138.27 91.82,140.35 97.17,140.35 v2(97.43,140.09)
  BOTTOM w0.079: v2(97.43,140.09) 97.74,140.4 99.48,140.4 99.75,140.68 100.39,140.68 100.48,140.65 100.69,140.65 100.77,140.68 101.02,140.68 101.08,140.65 101.34,140.65 101.42,140.68 101.66,140.68 101.79,140.62 102.07,140.62 102.18,140.74 U1.BA34
  BOTTOM w0.114: v1(47.84,116.8) 47.71,116.92 45.84,116.92 45.74,116.82 JDIM1.212
M_A_DQ50: length 73.5
  IN4 w0.089: v1(49.54,113.06) 49.95,112.66 51.73,112.66 51.98,112.91 57.17,112.91 57.42,112.65 63.93,112.65 65.29,114.02 69.29,114.02 70.56,115.29 72.42,115.29 79.98,122.86 80.16,122.86 80.37,122.64 80.51,122.64 80.7,122.83 80.7,122.95 80.48,123.16 80.48,123.27 80.67,123.46 80.81,123.46 81.51,122.77 81.63,122.77 81.82,122.95 81.82,123.08 81.64,123.26 81.64,123.38 81.83,123.57 81.96,123.57 82.35,123.18 82.47,123.18 82.66,123.37 82.66,123.5 82.3,123.86 82.3,123.99 82.48,124.18 82.61,124.18 82.98,123.81 83.1,123.81 84.92,125.63 84.92,125.8 90.02,130.9 90.02,134.61 90.47,135.05 90.47,135.95 92.39,137.88 94.37,137.88 94.65,138.16 v2(94.65,138.32)
  BOTTOM w0.079: U1.BC35 101.21,139.93 100.64,139.93 100.34,139.83 99.86,139.83 99.76,139.73 98.27,139.73 97.72,139.18 95.51,139.18 v2(94.65,138.32)
  BOTTOM w0.114: v1(49.54,113.06) 50.06,113.57 JDIM1.225
M_A_DQ51: length 73.7
  IN4 w0.089: v1(47.98,113.38) 49.04,112.32 51.87,112.32 52.12,112.57 57.03,112.57 57.28,112.31 64.07,112.31 65.43,113.68 69.43,113.68 70.7,114.95 72.56,114.95 74.14,116.53 75.18,116.53 81.07,122.42 82.19,122.42 83.23,123.46 83.94,123.46 85.26,124.78 85.26,125.66 90.37,130.76 90.37,134.47 90.64,134.74 90.72,134.82 90.72,135.83 92.48,137.59 94.56,137.59 v2(96.86,139.89)
  BOTTOM w0.079: v2(96.86,139.89) 97.06,139.68 97.51,139.68 98.06,140.23 99.55,140.23 99.82,140.51 100.37,140.51 100.46,140.48 100.72,140.48 100.8,140.51 100.98,140.51 101.05,140.48 101.37,140.48 101.45,140.51 101.62,140.51 101.76,140.45 102.07,140.45 102.18,140.34 U1.BC34
  BOTTOM w0.114: v1(47.98,113.38) 47.53,113.82 JDIM1.224
M_A_DQ52: length 72.1
  IN4 w0.089: v1(49.3,116.69) 50.06,115.93 51.33,115.93 51.43,115.84 51.43,115.27 51.52,115.17 51.83,115.17 51.94,115.28 51.94,115.99 52.03,116.08 52.3,116.08 52.4,115.99 52.4,115.35 52.48,115.27 52.71,115.27 52.81,115.37 52.81,116.07 52.93,116.19 53.16,116.19 53.26,116.09 53.26,115.44 53.34,115.35 53.62,115.35 53.69,115.42 53.69,116.09 53.82,116.21 55.96,116.21 56.26,115.91 68.5,115.91 69.77,117.18 71.63,117.18 84.08,129.63 84.99,129.63 87.55,132.19 87.55,134.84 89.03,136.32 89.03,136.6 91.75,139.32 93.22,139.32 v2(93.81,139.92)
  BOTTOM w0.079: v2(93.81,139.92) 94.83,140.93 98.24,140.93 98.77,141.46 99.69,141.46 99.78,141.55 U1.BA37
  BOTTOM w0.114: v1(49.3,116.69) 49.97,117.36 51.59,117.36 51.87,117.07 JDIM1.211
M_A_DQ53: length 72.5
  IN4 w0.089: v2(93.2,139.91) 92.83,139.54 91.63,139.54 88.69,136.6 88.69,136.47 87.21,134.98 87.21,132.34 84.84,129.97 83.94,129.97 71.49,117.53 71.34,117.53 70.54,118.32 70.42,118.32 68.74,116.64 68.36,116.26 56.41,116.26 56.11,116.56 51.96,116.56 51.69,116.28 50.55,116.28 50.36,116.47 50.36,116.95 50.14,117.17 49.18,117.17 48.9,116.89 48.9,116.55 48.38,116.04 47.22,116.04 47.09,115.91 47.09,115.55 46.96,115.42 46.66,115.42 46.57,115.51 v1(46.57,116.35)
  BOTTOM w0.079: U1.BA36 100.74,141.7 100.61,141.7 100.32,141.81 99.8,141.81 99.62,141.63 98.7,141.63 98.17,141.1 94.39,141.1 v2(93.2,139.91)
  BOTTOM w0.114: JDIM1.216 46.3,115.82 46.57,116.1 v1(46.57,116.35)
M_A_DQ54: length 72.1
  IN4 w0.089: v1(46.65,113.37) 46.65,114.17 46.77,114.28 47.1,114.28 47.47,113.92 53.77,113.92 54.09,113.59 57.45,113.59 57.71,113.34 63.64,113.34 65.01,114.71 69,114.71 70.27,115.98 72.13,115.98 81.02,124.87 83.19,124.87 84.23,125.91 84.23,127.17 86.7,129.64 87.13,129.64 88.76,131.26 88.76,134.31 90.01,135.57 90.01,136.38 92.3,138.67 93.06,138.67 v2(93.43,138.3)
  BOTTOM w0.079: v2(93.43,138.3) 94.48,139.35 97.65,139.35 98.2,139.9 99.69,139.9 99.79,140 100.32,140 100.61,140.09 100.73,140.09 U1.BC36
  BOTTOM w0.114: JDIM1.228 46.11,112.82 v1(46.65,113.37)
M_A_DQ55: length 71.5
  IN4 w0.089: v2(92.82,138.29) 92.35,138.29 90.25,136.19 90.25,135.32 89.1,134.17 89.1,130.47 88.46,129.82 88.33,129.82 88.16,129.99 88.03,129.99 87.84,129.8 87.84,129.68 88.02,129.51 88.02,129.38 87.83,129.19 87.7,129.19 87.53,129.36 87.4,129.36 87.22,129.17 87.22,129.05 87.39,128.88 87.39,128.75 87.2,128.56 87.07,128.56 86.9,128.73 86.78,128.73 86.59,128.55 86.59,128.42 86.76,128.25 86.76,128.12 86.57,127.94 86.44,127.94 86.03,128.35 85.89,128.35 85.7,128.16 85.7,128.04 86.13,127.62 86.13,127.5 85.94,127.31 85.81,127.31 85.41,127.71 85.26,127.71 85.07,127.52 85.07,127.42 85.5,126.99 85.5,126.87 85.31,126.68 85.19,126.68 84.9,126.96 84.76,126.96 84.57,126.77 84.57,126.66 84.87,126.36 84.87,126.24 84.57,125.94 84.57,125.77 83.33,124.53 81.17,124.53 72.27,115.63 70.41,115.63 69.14,114.36 65.15,114.36 63.78,113 57.57,113 57.31,113.25 53.95,113.25 53.62,113.57 51.4,113.57 v1(50.89,113.06)
  BOTTOM w0.079: U1.BC37 99.8,140.25 99.62,140.07 98.13,140.07 97.58,139.52 94.04,139.52 v2(92.82,138.29)
  BOTTOM w0.114: JDIM1.229 51.38,112.57 v1(50.89,113.06)
M_A_DQ56: length 76.7
  IN4 w0.089: v1(50.89,110.84) 51.49,110.24 53.21,110.24 54.04,111.07 56.79,111.07 57.55,110.31 64.15,110.31 66.24,112.4 71.28,112.4 72.46,113.58 74.04,113.58 81.02,120.56 83.22,120.56 84.29,121.62 84.29,121.8 86.54,124.05 86.54,124.76 87.73,125.95 87.87,125.95 88.33,125.49 88.47,125.49 88.65,125.67 88.65,125.79 88.18,126.27 88.18,126.39 88.37,126.58 88.49,126.58 88.97,126.11 89.09,126.11 89.28,126.3 89.28,126.42 88.79,126.91 88.79,127.01 88.98,127.2 89.14,127.2 89.6,126.74 89.72,126.74 89.91,126.93 89.91,127.05 89.44,127.53 89.44,127.66 89.61,127.82 89.77,127.82 90.23,127.37 90.35,127.37 90.88,127.89 90.88,128.06 90.44,128.51 90.44,128.65 90.65,128.87 90.77,128.87 91.03,128.61 91.21,128.61 91.65,129.05 91.65,134.73 92.37,135.45 v2(92.37,136.01)
  BOTTOM w0.079: v2(92.37,136.01) 92.37,136.74 93.54,137.91 94.8,137.91 95.89,139.01 97.79,139.01 98.34,139.56 100.06,139.56 100.64,139.35 101.22,139.35 U1.BE35
  BOTTOM w0.114: JDIM1.237 51.86,110.57 51.7,110.42 51.31,110.42 v1(50.89,110.84)
M_A_DQ57: length 76.6
  IN4 w0.089: v1(47.98,111.34) 48.36,111.34 48.43,111.28 52.01,111.28 52.16,111.14 52.16,110.68 52.26,110.58 52.57,110.58 52.68,110.69 52.68,111.3 52.79,111.41 56.93,111.41 57.69,110.65 64.01,110.65 66.1,112.74 70.33,112.74 70.43,112.84 70.43,113.35 70.53,113.45 70.82,113.45 70.91,113.36 70.91,112.98 71,112.89 71.29,112.89 71.4,113 71.4,113.82 71.5,113.92 73.9,113.92 81.46,121.48 82.58,121.48 82.73,121.63 83.64,121.63 86.2,124.19 86.2,124.9 91.31,130.01 91.31,135.55 92.79,137.03 95.4,137.03 96.39,138.01 v2(96.39,138.11)
  BOTTOM w0.079: U1.BE34 101.98,138.83 101.75,138.83 101.64,138.78 101.44,138.78 101.35,138.82 101.08,138.82 100.99,138.78 100.81,138.78 100.7,138.81 100.46,138.81 100.36,138.78 100.09,138.78 99.84,139.04 98.53,139.04 98,138.51 96.73,138.51 96.59,138.37 96.59,138.31 v2(96.39,138.11)
  BOTTOM w0.114: v1(47.98,111.34) 47.5,111.82 JDIM1.232
M_A_DQ58: length 77.1
  IN4 w0.089: v1(47.91,107.78) 48.77,107.78 49.33,108.33 53.88,108.33 55.08,107.13 60.61,107.13 61.11,107.64 64.16,107.64 65.24,108.72 67.43,108.72 69.21,110.5 72.07,110.5 73.25,111.69 74.82,111.69 80.03,116.9 80.22,117.08 80.34,117.08 81.49,115.94 81.61,115.94 81.8,116.13 81.8,116.25 81.16,116.89 81.16,117.01 81.35,117.2 81.48,117.2 82.11,116.57 82.24,116.57 93.56,127.89 93.56,133.73 v2(96.47,136.64)
  BOTTOM w0.079: U1.BG35 101.22,137.42 100.68,137.42 100.34,137.31 100.02,137.31 99.93,137.4 99.14,137.4 98.57,136.84 97.55,136.84 97.33,137.05 96.87,137.05 v2(96.47,136.64)
  BOTTOM w0.114: JDIM1.246 47.37,108.32 v1(47.91,107.78)
M_A_DQ59: length 77.4
  IN4 w0.089: v1(50.89,107.92) 51.51,107.29 52,107.29 52.14,107.43 52.14,107.76 52.25,107.87 52.59,107.87 52.74,107.72 52.74,107.46 52.91,107.29 53.99,107.29 54.49,106.79 60.75,106.79 61.25,107.29 64.3,107.29 65.38,108.38 67.57,108.38 69.35,110.16 72.21,110.16 73.39,111.34 74.96,111.34 79.52,115.9 79.65,115.9 80.79,114.76 80.92,114.76 81.11,114.95 81.11,115.08 79.96,116.23 79.96,116.34 80.15,116.52 80.29,116.52 81.42,115.39 81.55,115.39 93.9,127.74 93.9,130.85 94.64,131.59 94.64,133.52 97.64,136.52 97.64,138 v2(97.55,138.09)
  BOTTOM w0.079: U1.BG34 102.18,138.5 102.01,138.67 101.79,138.67 101.68,138.61 101.4,138.61 101.32,138.65 101.12,138.65 101.02,138.61 100.78,138.61 100.67,138.65 100.48,138.65 100.39,138.61 100.02,138.61 99.77,138.87 98.6,138.87 98.07,138.34 97.8,138.34 v2(97.55,138.09)
  BOTTOM w0.114: v1(50.89,107.92) 51.54,108.57 JDIM1.245
M_A_DQ60: length 75
  IN4 w0.089: v1(95.77,137.98) 95.77,137.8 95.31,137.33 92.74,137.33 91.01,135.61 91.01,134.27 90.96,134.22 90.96,130.15 85.86,125.04 85.86,124.33 84.39,122.86 83.48,122.86 82.44,121.83 81.31,121.83 75.01,115.52 74.89,115.52 74.52,115.89 74.37,115.89 74.18,115.7 74.18,115.6 74.57,115.21 74.57,115.08 74.38,114.89 74.26,114.89 73.87,115.28 73.73,115.28 73.54,115.09 73.54,114.98 73.94,114.58 73.94,114.45 73.75,114.26 73.63,114.26 73.23,114.66 73.12,114.66 72.75,114.29 70.89,114.29 69.68,113.08 65.68,113.08 63.6,110.99 57.83,110.99 57.07,111.75 52.57,111.75 52.44,111.62 48.66,111.62 48.14,112.13 47.45,112.13 v1(46.65,111.34)
  BOTTOM w0.079: U1.BE37 100.07,139.2 98.46,139.2 97.93,138.68 96.47,138.68 v1(95.77,137.98)
  BOTTOM w0.114: v1(46.65,111.34) 46.14,110.82 JDIM1.236
M_A_DQ61: length 76.1
  IN4 w0.089: v1(49.57,110.85) 50.52,109.9 53.35,109.9 54.18,110.72 56.65,110.72 57.4,109.97 60.73,109.97 61.42,109.28 63.6,109.28 66.38,112.05 71.42,112.05 72.61,113.24 74.18,113.24 80.49,119.55 80.72,119.55 80.97,119.3 81.15,119.3 81.35,119.5 81.35,119.61 81.05,119.9 81.05,120.03 81.24,120.21 81.37,120.21 82.3,119.28 82.43,119.28 82.62,119.47 82.62,119.59 82.29,119.92 82.29,120.04 82.47,120.21 82.63,120.21 82.93,119.91 83.06,119.91 84.63,121.48 84.63,121.65 86.55,123.57 87.04,123.57 91.99,128.52 91.99,134.62 92.86,135.48 v2(92.86,136.38)
  BOTTOM w0.079: U1.BE36 100.74,139.19 100.61,139.19 100.03,139.4 98.41,139.4 97.86,138.85 96.01,138.85 94.92,137.75 93.66,137.75 92.86,136.95 v2(92.86,136.38)
  BOTTOM w0.114: v1(49.57,110.85) 50.29,111.57 JDIM1.233
M_A_DQ62: length 76.3
  IN4 w0.089: v2(95.86,136.67) 93.21,134.02 93.21,128.03 82.93,117.75 82.81,117.75 82.48,118.07 82.35,118.07 82.17,117.88 82.17,117.76 82.49,117.43 82.49,117.31 82.3,117.12 82.18,117.12 81.22,118.07 81.09,118.07 80.9,117.88 80.9,117.77 81.1,117.57 81.1,117.43 80.9,117.24 80.71,117.24 80.38,117.57 80.22,117.57 74.68,112.03 73.11,112.03 71.93,110.85 69.07,110.85 67.28,109.06 65.1,109.06 64.01,107.98 60.97,107.98 60.47,107.48 55.22,107.48 54.02,108.68 49.18,108.68 48.99,108.49 47.3,108.49 v1(46.59,107.78)
  BOTTOM w0.079: v2(95.86,136.67) 96.42,137.23 97.54,137.23 97.75,137.01 98.44,137.01 99,137.57 100,137.57 100.09,137.48 100.32,137.48 100.66,137.59 100.74,137.59 U1.BG36
  BOTTOM w0.114: v1(46.59,107.78) 46.13,107.32 JDIM1.250
M_A_DQ63: length 75.2
  IN4 w0.089: v2(98.13,137.36) 98.13,136.52 94.98,133.38 94.98,131.45 94.24,130.71 94.24,127.6 80.86,114.21 80.73,114.21 79.57,115.37 79.48,115.37 79.29,115.18 79.29,115.03 80.21,114.1 80.21,113.98 80.02,113.79 79.9,113.79 78.96,114.73 78.84,114.73 75.11,111 73.53,111 72.35,109.82 69.49,109.82 67.71,108.03 65.52,108.03 64.44,106.95 61.4,106.95 60.89,106.45 54.35,106.45 53.85,106.95 50.51,106.95 v1(49.55,107.91)
  BOTTOM w0.079: U1.BG37 98.51,137.74 v2(98.13,137.36)
  BOTTOM w0.114: JDIM1.249 51.86,107.57 51.42,107.13 50.33,107.13 v1(49.55,107.91)
M_A_DQSN0: length 72.6
  IN4 w0.102: v1(100.81,170.78) 101.06,171.02 101.06,171.17 100.98,171.24 95.56,171.24 93.66,173.14 66.56,173.14 64.54,171.13 57.75,171.13 57.53,170.9 53.79,170.9 53.12,170.23 52.77,170.23 52.57,170.03 52.57,169.68 52.26,169.38 51.3,169.38 50.97,169.71 49.48,169.71 49.34,169.57 49.34,169.35 49.44,169.25 v1(50.01,169.25)
  BOTTOM w0.079: v1(100.81,170.78) 100.95,170.78 101.09,170.64 101.09,170.36 101.28,170.17 104.91,170.17 105.8,169.29 105.8,168.24 105.93,168.11 105.93,167.07 106.39,166.61 106.7,166.61 106.87,166.44 106.87,166.08 106.74,165.94 106.74,165.59 106.76,165.52 106.76,165.3 106.74,165.19 106.74,164.94 106.78,164.84 106.78,164.68 106.75,164.6 106.68,164.53 106.57,164.53 106.5,164.6 U1.C27
  BOTTOM w0.102: v1(50.01,169.25) 49.83,169.43 49.41,169.43 49.25,169.27 49.25,168.87 49.34,168.78 51.57,168.78 51.87,169.07 JDIM1.11
M_A_DQSN1: length 68.7
  IN4 w0.102: v2(102.13,166.56) 102.13,166.88 102.25,167 102.25,167.32 101.53,168.04 95.67,168.04 94.45,169.26 91.22,169.26 91,169.48 72.22,169.48 69.15,166.41 57.7,166.41 57.08,165.79 53.96,165.79 51.4,163.24 47.79,163.24 47.62,163.41 47.62,163.72 47.77,163.86 v1(48.11,163.86)
  BOTTOM w0.079: U1.D31 103.98,164.27 103.9,164.35 103.75,164.35 103.62,164.48 103.55,164.65 103.55,164.91 103.59,164.99 103.59,165.21 103.56,165.29 103.56,165.54 103.6,165.64 103.6,165.87 103.22,166.26 103.22,166.32 102.68,166.86 102.21,166.86 102.13,166.79 v2(102.13,166.56)
  BOTTOM w0.102: JDIM1.32 45.5,163.82 45.67,163.65 45.82,163.65 45.92,163.75 45.92,164.13 46.4,164.61 47.17,164.61 47.57,164.21 47.57,163.96 47.67,163.86 v1(48.11,163.86)
M_A_DQSN2: length 66.2
  IN4 w0.102: v1(93.83,163.72) 94.07,163.96 94.07,164.06 93.98,164.16 93.58,164.16 92.54,165.2 73.69,165.2 68.63,160.14 63.62,160.14 63.22,160.55 60.74,160.55 60.49,160.3 54.5,160.3 51.83,157.63 50.86,157.63 50.35,157.11 48.74,157.11 48.52,157.34 48.52,157.71 48.4,157.83 v1(48.05,157.83)
  BOTTOM w0.079: U1.J35 101.44,161.04 101.51,161.1 101.51,161.17 101.44,161.24 101.31,161.31 101.11,161.31 101.02,161.28 100.78,161.28 100.69,161.3 100.47,161.3 100.39,161.28 99.97,161.28 99.79,161.45 99.25,161.45 98.54,162.16 98.54,162.54 98.4,162.69 98.37,162.69
  BOTTOM w0.102: v1(48.05,157.83) 48.24,157.83 48.44,158.02 48.44,158.29 48.85,158.7 50.24,158.7 50.49,158.45 51.77,158.45 51.89,158.57 JDIM1.53
  BOTTOM w0.114: v1(93.83,163.72) 94.12,163.43 94.12,162.98 94.41,162.69 98.37,162.69
M_A_DQSN3: length 64.4
  IN4 w0.102: v2(99.08,157.96) 98.87,158.17 98.87,158.38 97.44,159.81 96.67,159.81 96.32,160.16 93.13,160.16 91.75,161.54 75.2,161.54 68.07,154.41 65.83,154.41 65.27,153.85 61.23,153.85 61.09,153.99 57.44,153.99 57.03,153.58 54.22,153.58 53.46,152.83 47.77,152.83 47.5,153.1 46.48,153.1 46.4,153.19 v1(46.4,153.63)
  BOTTOM w0.079: U1.P34 101.66,158.52 101.62,158.48 101.62,158.28 101.49,158.15 101.37,158.1 101.04,158.1 100.99,158.13 100.79,158.13 100.72,158.1 100.46,158.1 100.37,158.13 99.72,158.13 99.51,158.34 98.98,158.34 98.9,158.26 98.9,158.14 v2(99.08,157.96)
  BOTTOM w0.102: JDIM1.74 45.57,153.32 45.66,153.24 46.19,153.24 46.4,153.45 v1(46.4,153.63)
M_A_DQSN4: length 69.7
  IN4 w0.102: v2(96.32,145.39) 96.14,145.39 96.01,145.27 96.01,144.82 95.83,144.63 92.02,144.63 91.83,144.45 90.25,144.45 88.99,143.18 85.84,143.18 73.47,130.81 72.9,130.81 68.97,126.88 66.31,126.88 65.84,126.41 64.77,126.41 64.08,125.72 55.63,125.72 55.29,126.06 52.95,126.06 52.73,126.28 52.73,126.66 52.62,126.77 52.28,126.77 52.19,126.68 52.19,126.2 51.93,125.93 51.45,125.93 51.2,126.18 51.2,126.63 51.06,126.77 50.56,126.77 50.28,127.05 49.79,127.05 49.41,126.67 49.41,126.16 49.58,125.99 49.86,125.99 v1(50.08,126.21)
  BOTTOM w0.079: v2(96.32,145.39) 96.21,145.39 96.06,145.55 96.06,145.71 96.24,145.89 99.57,145.89 99.85,146.17 100.39,146.17 100.47,146.2 100.69,146.2 100.78,146.17 101.02,146.17 101.11,146.21 101.31,146.21 101.44,146.14 101.51,146.07 101.51,146 101.44,145.94 U1.AP35
  BOTTOM w0.102: JDIM1.177 49.77,125.57 49.52,125.83 49.52,126.08 49.64,126.21 v1(50.08,126.21)
M_A_DQSN5: length 73.8
  IN4 w0.102: v1(47.16,120.73) 47.16,120.27 47.28,120.15 48.29,120.15 48.51,119.93 48.51,119.76 48.62,119.64 48.82,119.64 49.04,119.86 49.04,120.47 49.34,120.77 56.16,120.77 57.15,119.78 60.95,119.78 61.38,120.22 62.06,120.22 62.5,119.78 62.94,119.78 63.37,120.22 64.03,120.22 64.47,119.78 64.82,119.78 64.96,119.93 64.96,120.74 65.16,120.94 65.73,120.94 65.95,120.72 65.95,119.94 66.11,119.78 66.57,119.78 67.73,120.94 68.77,120.94 74.99,127.15 75.83,127.15 83.97,135.3 83.97,136.14 87.23,139.39 87.65,139.39 88.26,140 89.2,140 91.55,142.35 94.13,142.35 94.34,142.14 94.34,141.89 v2(94.52,141.71)
  BOTTOM w0.079: U1.AV34 101.69,143.42 101.64,143.37 101.64,143.19 101.5,143.05 101.37,143 101.04,143 100.96,143.04 100.82,143.04 100.72,143 100.46,143 100.37,143.03 99.09,143.03 98.57,142.51 98.36,142.51 98.22,142.37 96.97,142.37 96.75,142.16 94.52,142.16 94.36,142 94.36,141.87 v2(94.52,141.71)
  BOTTOM w0.102: JDIM1.198 45.64,120.32 45.73,120.23 46.93,120.23 47.16,120.46 v1(47.16,120.73)
M_A_DQSN6: length 72.6
  IN4 w0.102: v2(95.64,139.91) 95.64,139.9 95.63,139.9 95.58,139.9 95.45,139.77 95.45,139.58 94.78,138.91 92.06,138.91 89.58,136.42 89.58,135.87 88.26,134.55 88.26,131.9 83.63,127.28 83.63,126.03 82.97,125.37 80.82,125.37 71.92,116.48 70.06,116.48 68.79,115.21 63.86,115.21 63.26,114.6 56.42,114.6 56.24,114.42 49.68,114.42 49.41,114.68 49.41,115.04 49.31,115.15 v1(48.92,115.15)
  BOTTOM w0.079: U1.BB35 101.45,140.9 101.51,140.95 101.51,141.03 101.44,141.1 101.31,141.18 101.11,141.18 101.02,141.14 100.78,141.14 100.67,141.17 100.48,141.17 100.38,141.14 98.9,141.14 98.38,140.61 95.54,140.61 95.39,140.45 95.39,140.17 v2(95.64,139.91)
  BOTTOM w0.102: v1(48.92,115.15) 49.63,115.86 51.01,115.86 51.79,115.07 JDIM1.219
M_A_DQSN7: length 76.9
  IN4 w0.102: v2(94.64,136.61) 94.45,136.42 94.45,136.13 92.71,134.39 92.71,128.24 86.68,122.21 86.19,122.21 85.34,121.36 85.34,121.19 82.72,118.57 80.52,118.57 74.47,112.53 72.9,112.53 71.72,111.35 68.86,111.35 67.08,109.56 64.89,109.56 63.81,108.48 60.68,108.48 59.96,109.19 48.85,109.19 48.64,108.99 47.57,108.99 47.24,109.32 47.24,109.61 47.13,109.71 v1(46.91,109.71)
  BOTTOM w0.079: v2(94.64,136.61) 94.42,136.83 94.42,137.32 94.51,137.41 97.59,137.41 98.11,137.93 99.76,137.93 99.82,137.99 100.37,137.99 100.5,137.95 100.69,137.95 100.84,138.01 100.95,138.01 101.04,137.96 101.37,137.96 101.49,138.02 101.63,138.16 101.63,138.35 101.67,138.39 U1.BF34
  BOTTOM w0.102: v1(46.91,109.71) 47.16,109.71 47.43,109.45 47.43,109.22 47.32,109.12 46.67,109.12 46.26,109.53 45.8,109.53 45.5,109.82 JDIM1.240
M_A_DQSN8: length 3.8
  TOP w0.114: R232.1 50.2,147.74 50.89,148.43 v1(50.89,148.55)
  BOTTOM w0.114: v1(50.89,148.55) 51.37,148.07 JDIM1.95
M_A_DQSP0: length 72.6
  IN4 w0.102: v1(48.74,169.25) 49.01,169.25 49.14,169.37 49.14,169.65 49.39,169.91 51.05,169.91 51.38,169.58 52.18,169.58 52.37,169.77 52.37,170.11 52.69,170.43 53.03,170.43 53.7,171.1 57.44,171.1 57.67,171.33 64.46,171.33 66.47,173.34 93.75,173.34 95.64,171.45 101.07,171.45 101.26,171.25 101.26,171.02 v1(101.49,170.78)
  BOTTOM w0.079: U1.D27 106.5,164.27 106.6,164.37 106.75,164.37 106.89,164.52 106.94,164.66 106.94,164.87 106.89,164.97 106.89,165.17 106.92,165.29 106.92,165.56 106.89,165.62 106.89,165.88 107.03,166.02 107.03,166.51 106.77,166.77 106.46,166.77 106.09,167.14 106.09,168.17 105.95,168.31 105.95,169.35 104.98,170.33 101.35,170.33 101.25,170.43 101.25,170.54 v1(101.49,170.78)
  BOTTOM w0.102: v1(48.74,169.25) 49.05,168.93 49.05,168.78 49.26,168.57 JDIM1.13
M_A_DQSP1: length 68.7
  IN4 w0.102: v1(46.84,163.86) 46.96,163.98 47.27,163.98 47.42,163.83 47.42,163.33 47.7,163.04 51.49,163.04 54.04,165.59 57.16,165.59 57.78,166.21 69.24,166.21 72.3,169.28 90.92,169.28 91.14,169.06 94.36,169.06 95.58,167.84 101.44,167.84 102.05,167.23 102.05,167.09 101.93,166.97 v2(101.68,166.97)
  BOTTOM w0.079: v2(101.68,166.97) 101.73,167.02 102.74,167.02 103.38,166.39 103.38,166.32 103.76,165.94 103.76,165.61 103.72,165.51 103.72,165.32 103.74,165.23 103.74,164.95 103.71,164.87 103.71,164.68 103.75,164.57 103.81,164.51 103.89,164.51 103.98,164.6 U1.C31
  BOTTOM w0.102: JDIM1.34 45.5,163.32 45.62,163.45 45.9,163.45 46.12,163.67 46.12,164.05 46.49,164.41 47.09,164.41 47.37,164.13 47.37,163.96 47.27,163.86 v1(46.84,163.86)
M_A_DQSP2: length 66.2
  IN4 w0.102: v1(94.54,163.72) 94.28,163.98 94.28,164.14 94.06,164.36 93.66,164.36 92.62,165.4 73.6,165.4 68.55,160.34 63.71,160.34 63.3,160.75 60.66,160.75 60.4,160.5 54.41,160.5 51.75,157.83 50.78,157.83 50.26,157.32 48.83,157.32 48.72,157.43 48.72,157.69 48.85,157.83 v1(49.32,157.83)
  BOTTOM w0.079: 98.43,162.88 98.7,162.61 98.7,162.23 99.32,161.61 99.86,161.61 100.03,161.43 100.37,161.43 100.44,161.46 100.71,161.46 100.81,161.43 100.99,161.43 101.07,161.47 101.35,161.47 101.53,161.37 101.66,161.24 101.66,161.09 101.71,161.04 U1.J34
  BOTTOM w0.102: JDIM1.55 51.93,158.07 51.75,158.25 50.41,158.25 50.16,158.5 48.93,158.5 48.64,158.2 48.64,157.97 48.79,157.83 v1(49.32,157.83)
  BOTTOM w0.114: 98.43,162.88 94.49,162.88 94.31,163.06 94.31,163.49 v1(94.54,163.72)
M_A_DQSP3: length 64.5
  IN4 w0.102: v2(98.47,157.96) 98.66,158.16 98.66,158.3 97.35,159.6 96.59,159.6 96.23,159.96 93.04,159.96 91.66,161.34 75.29,161.34 68.16,154.21 65.91,154.21 65.35,153.65 61.14,153.65 61,153.79 57.52,153.79 57.12,153.38 54.3,153.38 53.55,152.63 47.69,152.63 47.42,152.9 46.5,152.9 46.4,152.79 v1(46.4,152.36)
  BOTTOM w0.079: U1.P35 101.41,158.52 101.46,158.47 101.46,158.34 101.4,158.28 101.34,158.26 101.08,158.26 101.02,158.28 100.76,158.28 100.69,158.26 100.48,158.26 100.39,158.28 99.79,158.28 99.57,158.5 98.92,158.5 98.74,158.32 98.74,158.23 v2(98.47,157.96)
  BOTTOM w0.102: v1(46.4,152.36) 46.4,152.86 46.22,153.04 45.69,153.04 45.48,152.82 JDIM1.76
M_A_DQSP4: length 69.8
  IN4 w0.102: v2(95.65,145.39) 95.81,145.24 95.81,144.91 95.74,144.84 91.94,144.84 91.75,144.65 90.16,144.65 88.9,143.39 85.76,143.39 73.38,131.01 72.81,131.01 68.89,127.09 66.23,127.09 65.76,126.62 64.69,126.62 64,125.92 55.71,125.92 55.37,126.26 53.04,126.26 52.94,126.36 52.94,126.74 52.71,126.97 52.2,126.97 51.99,126.76 51.99,126.29 51.84,126.14 51.53,126.14 51.4,126.27 51.4,126.72 51.15,126.97 50.64,126.97 50.36,127.25 49.7,127.25 49.2,126.75 49.2,126.31 49.1,126.21 v1(48.81,126.21)
  BOTTOM w0.079: U1.AP34 101.71,145.94 101.66,145.98 101.66,146.13 101.53,146.26 101.35,146.37 101.07,146.37 100.99,146.33 100.81,146.33 100.71,146.36 100.44,146.36 100.36,146.33 99.79,146.33 99.5,146.04 96.17,146.04 95.9,145.77 95.9,145.64 v2(95.65,145.39)
  BOTTOM w0.102: JDIM1.179 51.99,125.07 51.69,125.37 49.69,125.37 49.31,125.74 49.31,126.08 49.12,126.27 48.87,126.27 v1(48.81,126.21)
M_A_DQSP5: length 73.8
  IN4 w0.102: v1(47.16,119.46) 47.16,119.82 47.29,119.95 48.2,119.95 48.3,119.85 48.3,119.67 48.54,119.44 48.91,119.44 49.24,119.77 49.24,120.38 49.43,120.57 56.07,120.57 57.06,119.58 61.03,119.58 61.47,120.02 61.97,120.02 62.41,119.58 63.02,119.58 63.46,120.02 63.94,120.02 64.38,119.58 64.9,119.58 65.17,119.85 65.17,120.66 65.25,120.74 65.65,120.74 65.75,120.64 65.75,119.86 66.03,119.58 66.66,119.58 67.82,120.74 68.86,120.74 75.07,126.95 75.91,126.95 84.18,135.22 84.18,136.06 87.31,139.19 87.73,139.19 88.34,139.8 89.28,139.8 91.63,142.15 94.04,142.15 94.14,142.06 94.14,141.87 93.97,141.71 v2(93.89,141.71)
  BOTTOM w0.079: v2(93.89,141.71) 94.01,141.71 94.2,141.9 94.2,142.06 94.45,142.31 96.69,142.31 96.91,142.53 98.16,142.53 98.29,142.66 98.51,142.66 99.02,143.18 100.39,143.18 100.48,143.15 100.69,143.15 100.79,143.2 101,143.2 101.08,143.15 101.34,143.15 101.41,143.18 101.48,143.25 101.48,143.36 101.42,143.42 U1.AV35
  BOTTOM w0.102: JDIM1.200 45.54,119.82 45.75,120.03 47.03,120.03 47.16,119.9 v1(47.16,119.46)
M_A_DQSP6: length 72.6
  IN4 w0.102: v2(95.03,139.92) 95.04,139.91 95.15,139.91 95.25,139.81 95.25,139.67 94.7,139.11 91.98,139.11 89.37,136.51 89.37,135.95 88.05,134.63 88.05,131.99 83.43,127.36 83.43,126.11 82.89,125.57 80.73,125.57 71.84,116.68 69.98,116.68 68.71,115.41 63.78,115.41 63.17,114.8 56.34,114.8 56.16,114.62 49.76,114.62 49.62,114.76 49.62,115.06 49.71,115.15 v1(50.19,115.15)
  BOTTOM w0.079: U1.BB34 101.71,140.9 101.66,140.95 101.66,141.1 101.53,141.23 101.35,141.33 101.07,141.33 100.99,141.3 100.81,141.3 100.7,141.33 100.46,141.33 100.35,141.29 98.84,141.29 98.31,140.77 95.48,140.77 95.23,140.52 95.23,140.11 v2(95.03,139.92)
  BOTTOM w0.102: v1(50.19,115.15) 49.68,115.15 49.57,115.26 49.57,115.51 49.71,115.66 50.92,115.66 52.01,114.57 JDIM1.221
M_A_DQSP7: length 77
  IN4 w0.102: v2(94.03,136.57) 94.25,136.36 94.25,136.21 92.51,134.47 92.51,128.33 86.6,122.42 86.11,122.42 85.13,121.45 85.13,121.27 82.64,118.78 80.43,118.78 74.39,112.73 72.82,112.73 71.63,111.55 68.78,111.55 66.99,109.77 64.8,109.77 63.72,108.68 60.76,108.68 60.05,109.39 48.76,109.39 48.56,109.19 47.65,109.19 47.44,109.4 47.44,109.61 47.56,109.72 v1(48.19,109.72)
  BOTTOM w0.079: U1.BF35 101.43,138.39 101.47,138.34 101.47,138.23 101.39,138.15 101.33,138.12 101.08,138.12 100.98,138.17 100.81,138.17 100.66,138.11 100.52,138.11 100.39,138.15 99.76,138.15 99.7,138.09 98.05,138.09 97.52,137.56 94.44,137.56 94.26,137.38 94.26,136.81 v2(94.03,136.57)
  BOTTOM w0.102: v1(48.19,109.72) 47.81,109.72 47.63,109.55 47.63,109.14 47.4,108.91 46.59,108.91 46.18,109.32 JDIM1.242
M_A_DQSP8: length 3.6
  TOP w0.114: v1(50.23,148.51) 50.2,148.48 R231.1
  BOTTOM w0.114: v1(50.23,148.51) 51.16,147.57 JDIM1.97
M_A_PARITY: length 68.2
  IN4 w0.102: v2(103.6,155.66) 103.6,155.94 103.48,156.06 102.15,156.06 101.39,155.29 101.39,154.12 100.04,152.78 100.04,151.01 99.42,150.39 98.59,150.39 98.26,150.72 93.81,150.72 93.19,150.11 89.46,150.11 89.35,149.99 82.45,149.99 69.72,137.26 65.42,137.26 65.32,137.16 65.32,136.66 65.22,136.56 65.02,136.56 64.92,136.66 64.92,137.16 64.81,137.26 64.61,137.26 64.51,137.16 64.51,136.55 64.41,136.45 64.21,136.45 64.1,136.55 64.1,137.16 64,137.26 60.86,137.26 59.61,136.01 58.35,136.01 58.04,135.71 51.63,135.71 v1(51.44,135.51)
  BOTTOM w0.102: U1.W31 103.88,155.38 v2(103.6,155.66)
  BOTTOM w0.14: v1(51.44,135.51) 51.28,135.66 51.28,135.95 51.41,136.07 JDIM1.143
M_A_RAS#: length 69.7
  IN4 w0.102: v2(102.98,154.76) 102.89,154.76 100.69,152.56 100.69,150.78 99.69,149.77 98.2,149.77 98.09,149.88 94.19,149.88 93.57,149.27 90.15,149.27 89.65,148.77 82.96,148.77 68.59,134.41 60.79,134.41 60.65,134.27 57.27,134.27 57,134.01 49.09,134.01 48.78,133.7 v1(48.78,133.3)
  BOTTOM w0.102: U1.Y32 103.23,154.51 v2(102.98,154.76)
  BOTTOM w0.14: JDIM1.152 45.62,131.82 46.79,132.99 48.47,132.99 v1(48.78,133.3)
M_A_WE#: length 73
  IN4 w0.102: v2(103.6,152.98) 103.6,153.25 103.42,153.43 102.82,153.43 102.24,152.85 102.24,152.06 101.48,151.31 101.48,150.66 99.92,149.09 98.97,149.09 98.46,148.59 97.92,148.59 97.77,148.43 90.83,148.43 90.07,147.67 88.23,147.67 88.12,147.55 83.46,147.55 68.24,132.33 66.05,132.33 65.64,131.92 61.59,131.92 61.49,132.02 61.49,132.43 61.39,132.53 61.18,132.53 61.08,132.43 61.08,132.02 60.98,131.92 60.78,131.92 60.68,132.02 60.68,132.43 60.57,132.53 60.37,132.53 60.27,132.43 60.27,132.02 60.17,131.92 59.9,131.92 59.8,132.02 59.8,132.43 59.69,132.53 59.49,132.53 59.39,132.43 59.39,132.13 59.29,132.03 59.09,132.03 58.98,132.13 58.98,132.43 58.88,132.53 58.68,132.53 58.58,132.43 58.58,132.13 58.48,132.03 58.19,132.03 58.14,132.08 58.14,132.46 58.06,132.53 57.78,132.53 57.66,132.42 57.66,132.11 57.58,132.03 57.02,132.03 56.72,132.33 55.01,132.33 54.71,132.04 54.36,132.04 54.25,132.14 54.25,132.52 54.14,132.64 53.92,132.64 53.82,132.54 53.82,132.14 53.72,132.04 53.49,132.04 53.39,132.14 53.39,132.54 53.29,132.64 53.01,132.64 52.91,132.53 52.91,132.14 52.81,132.04 52.61,132.04 52.51,132.14 52.51,132.53 52.4,132.64 52.2,132.64 52.1,132.53 52.1,132.14 52,132.04 51.79,132.04 51.69,132.14 51.69,132.53 51.59,132.64 v1(51.18,132.64)
  BOTTOM w0.102: v2(103.6,152.98) 103.88,152.7 U1.AC31
  BOTTOM w0.14: JDIM1.151 51.75,132.07 v1(51.18,132.64)
M_B_A0: length 57.2
  IN3 w0.102: v2(92,152.09) 91.57,151.67 91.15,151.67 90.07,150.59 79.22,150.59 71.43,142.8 71.43,142.66 71.79,142.29 71.79,142.15 71.65,142 71.51,142 71.14,142.37 71,142.37 70.85,142.22 70.85,142.08 71.22,141.72 71.22,141.57 68.4,138.75 66.03,138.75 65.68,138.4 61.14,138.4 60.47,137.73 59.96,137.73 59.55,137.32 57.95,137.32 57.48,136.86 57.48,135.85 57.84,135.49 v1(58.58,135.49)
  BOTTOM w0.079: U1.AG36 100.69,150.32 100.54,150.17 100.34,150.06 99.87,150.06 99.79,149.98 98.5,149.98 97.95,150.53 93.56,150.53 93.4,150.69 v2(92,152.09)
  BOTTOM w0.14: v1(58.58,135.49) 57.98,135.49 57.65,135.82 JDIM02.144
M_B_A1: length 59.4
  IN3 w0.079: v2(93.82,152.13) 93.82,152.34 93.68,152.49 92.39,152.49 92.16,152.72 91.16,152.72
  IN3 w0.102: 91.16,152.72 89.89,151.45 78.9,151.45 67.97,140.53 66.56,140.53 66.49,140.47 66.49,139.66 66.39,139.56 66.19,139.56 66.09,139.66 66.09,140.44 65.99,140.53 65.76,140.53 65.68,140.45 65.68,139.66 65.58,139.56 65.35,139.56 65.27,139.64 65.27,140.43 65.17,140.53 64.08,140.53 64,140.46 64,140.1 63.9,140 63.55,140 63.16,139.61 62.03,139.61 61.82,139.82 61.61,139.82 61.44,139.65 61.18,139.65 61.11,139.73 61.11,140.23 60.88,140.46 60.74,140.46 60.64,140.36 60.64,138.77 60.71,138.7 60.86,138.7 61.28,139.12 v1(61.36,139.12)
  BOTTOM w0.079: U1.AG35 101.37,150.32 101.14,150.55 101.12,150.55 101,150.58 100.8,150.58 100.69,150.55 100.42,150.55 100.33,150.58 99.94,150.58 99.68,150.32 98.64,150.32 97.94,151.01 94.24,151.01 93.82,151.43 v2(93.82,152.13)
  BOTTOM w0.14: v1(61.36,139.12) 61.36,138.49 61.63,138.22 61.83,138.22 62.18,138.57 JDIM02.133
M_B_A2: length 60.1
  IN3 w0.102: v1(59.46,139.08) 59.28,139.27 59.28,139.79 59.38,139.89 59.75,139.89 59.83,139.97 59.83,141.34 59.96,141.47 60.48,141.47 60.58,141.57 60.58,142.16 60.67,142.24 60.93,142.24 61.03,142.14 61.03,141.59 61.15,141.47 61.35,141.47 61.43,141.55 61.43,142.14 61.54,142.24 66.96,142.24 77.9,153.18 90.2,153.18 90.53,153.51 92.28,153.51 92.66,153.13 94.21,153.13 94.49,152.85 95.81,152.85 96.35,152.32 v2(96.35,152.15)
  BOTTOM w0.079: v2(96.35,152.15) 96.35,151.85 96.76,151.44 100.03,151.44 100.1,151.36 100.36,151.36 100.49,151.4 100.7,151.4 100.79,151.37 101.46,151.37 U1.AF34
  BOTTOM w0.14: v1(59.46,139.08) 59.27,138.89 59.27,138.45 59.74,137.99 59.74,137.73 59.55,137.55 59.33,137.55 59.01,137.87 58.84,137.87 58.75,137.96 58.75,138.48 58.51,138.73 58.29,138.73 58.18,138.61 58.18,137.93 58.04,137.8 57.83,137.8 57.68,137.94 57.68,138.68 57.54,138.82 JDIM02.132
M_B_A3: length 58.6
  IN3 w0.079: v2(92.61,152.12) 92.54,152.12 92.14,152.52 91.31,152.52
  IN3 w0.102: v1(62.68,139.12) 63.12,139.12 63.22,139.01 63.22,138.91 63.32,138.81 63.52,138.81 63.62,138.91 63.62,139.5 63.71,139.59 63.92,139.59 64.03,139.48 64.03,138.91 64.13,138.81 64.34,138.81 64.44,138.91 64.44,140.02 64.54,140.12 64.74,140.12 64.84,140.02 64.84,138.91 64.94,138.81 65.15,138.81 65.25,138.91 65.25,139.07 65.34,139.15 66.97,139.15 67.05,139.23 67.05,140.02 67.15,140.12 67.38,140.12 67.48,140.02 67.48,139.29 67.62,139.15 68.08,139.15 68.22,139.3 68.22,139.45 67.92,139.75 67.92,139.9 68.06,140.04 68.2,140.04 68.58,139.66 68.73,139.66 68.87,139.81 68.87,139.95 68.49,140.33 68.49,140.47 68.64,140.62 68.78,140.62 69.16,140.24 69.3,140.24 69.45,140.38 69.45,140.52 69.07,140.9 69.07,141.05 69.21,141.19 69.35,141.19 69.73,140.81 69.88,140.81 70.02,140.96 70.02,141.1 69.64,141.48 69.64,141.62 69.79,141.77 69.93,141.77 70.31,141.39 70.45,141.39 70.6,141.53 70.6,141.67 70.22,142.06 70.22,142.16 79.08,151.02 89.81,151.02 91.31,152.52
  BOTTOM w0.079: U1.AG37 100.14,150.23 99.82,150.23 99.74,150.15 98.57,150.15 97.99,150.73 94,150.73 93.72,151.01 92.61,152.12 v2(92.61,152.12)
  BOTTOM w0.14: v1(62.68,139.12) 62.89,139.12 63.05,139.27 63.05,139.48 63.15,139.58 63.52,139.58 63.6,139.5 63.6,139.16 63.69,139.07 JDIM02.131
