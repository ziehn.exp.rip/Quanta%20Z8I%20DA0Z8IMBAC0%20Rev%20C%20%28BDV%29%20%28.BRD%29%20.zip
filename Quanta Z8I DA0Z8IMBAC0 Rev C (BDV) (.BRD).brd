# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3.3_CCG4: length 32.8
  IN2 w0.508: v1(24.41,63.73) 24.41,62.95 23.56,62.09 23.56,59.78 23.39,59.61 23.39,53.34 25.35,51.38 25.35,50.27 26.3,49.32 v1(27.5,49.32) 27.5,48.39 v1(27.38,48.26) 27.44,48.2 27.44,46.96 v1(27.33,46.86)
  BOTTOM w0.305: R25575.1 R25576.1 v1(27.38,48.26) 27.76,48.26 28.86,47.16 28.86,46.6 29.2,46.25 Q6535.2 Q6535.5 ; Q19.2 28.92,49.36 28.76,49.2 R25574.1 27.63,49.2 v1(27.5,49.32) ; v1(27.33,46.86) 27.64,46.55 v1(27.64,45.71) 28.45,44.9 R67890.2
  BOTTOM w0.508: v1(24.41,63.73) 24.22,63.73 R25579.1 23.76,64.77 23.86,64.87 R375.1
V3A_BOOT:
  vias: v1(176.36,133.37)
V3A_BOOT_R: length 2.7
  BOTTOM w0.508: PR6000.1 179.5,134.85 179.84,134.85 179.95,134.96 ; 179.95,134.96 v1(180.06,135.07) ; 179.95,134.96 PC6001.1
V3A_EN: length 10.9
  TOP w0.114: v1(176.74,134.03) 176.05,134.03 v1(176.02,134.06)
  TOP w0.203: PC6007.2 175.08,128.98 v1(174.48,128.98) ; v1(176.02,134.06) 175.89,134.06 175.87,134.04 PR6002.2
  IN4 w0.254: v1(176.02,134.06) 175.89,134.06 174.21,132.38 174.21,130.53 173.83,130.14 173.83,129.63 v1(174.48,128.98)
  BOTTOM w0.203: PR6006.2 173.85,128.67 174.15,128.98 v1(174.48,128.98) 175.36,128.98 175.53,129.15 PU6000.6
V3A_PWRGD: length 1.3
  BOTTOM w0.203: PU6000.7 174.93,129.53 174.92,129.51 173.94,129.51 PR6005.2
V3A_VBYP: length 296.7
  TOP w0.114: v1(27.33,116.41) 25.82,116.41 PR8046.2 ; v1(16.4,112.9) 16.84,113.34 PR8034.2
  TOP w0.203: v1(173.54,133.48) 174.09,133.48 v1(174.25,133.32) 174.25,133.04 173.93,132.73 PR6017.2 173.93,131.65 174.4,131.19 175.28,131.19 PC6023.1 175.38,131.79 175.29,131.89 PR6009.2
  IN3 w0.102: v1(175.52,120.58) 177.43,118.68 180.91,118.68 181.85,117.74 191.71,117.74 192.48,116.97 204.5,116.97 207.95,113.52 207.95,111.26 208.59,110.62 208.59,104.23 207.48,103.12 207.48,102.41 204.27,99.2 204.27,98.63 200.93,95.3 197.28,95.3 196.59,94.61 153.17,94.61 152.48,95.3 150.77,95.3 150.08,94.61 143,94.61 137.94,99.67 131.23,99.67 130.73,99.17 124.15,99.17 122.57,97.59 120.99,97.59 119.9,96.49 116.01,96.49 v1(115.61,96.08)
  IN4 w0.089: v1(175.52,120.58) 175.52,121.96 177.96,124.39 177.96,125.23 177.71,125.49 176.46,125.49 172.76,129.19 172.76,130.58 173.15,130.97 173.15,133.09 v1(173.54,133.48) ; v1(27.33,116.41) 27.33,116.06 27.91,115.49 29.66,115.49 30.38,114.77 30.38,109.85 30.16,109.63 30.16,103.92 33.24,100.84 34.08,100 34.98,100 37.94,97.04 45.4,97.04 45.82,96.62 48.95,96.62 50.9,94.66 50.9,92.95 51.46,92.39 68.43,92.39 68.59,92.24 74.04,92.24 76.09,94.29 78.33,94.29 79.11,95.08 92.75,95.08 93.26,95.58 97.54,95.58 98.55,94.57 114.09,94.57 v1(115.61,96.08)
  BOTTOM w0.114: v1(27.33,116.41) 27.33,115.8 26.73,115.21 25.93,115.21 25.11,114.39 24.57,114.39 23.19,113.01 18.1,113.01 17.99,112.9 v1(16.4,112.9)
  BOTTOM w0.203: v1(173.54,133.48) 174.5,132.52 174.5,131.55 174.73,131.33 PU6000.11
V3A_VOUT: length 35.6
  TOP w0.203: v1(194.23,127.15) v1(192.95,128.43) 191.59,129.79 188.6,129.79 188.42,129.97 188.42,132.48 184.28,134.87 178.74,134.87 178.11,134.74 177.39,134.73 174.97,134.73 174.75,134.51 173.91,134.51 172.97,135.45 172.43,135.45 172.12,135.14 172.12,134.63 172.84,133.91 v1(172.84,133.51)
  BOTTOM w0.203: PR6010.2 174.15,133.67 173.64,134.17 PR6011.2 173.23,133.9 v1(172.84,133.51) 172.84,133.28 173.9,132.22 PC6017.2 174.09,131.98 174.09,131.38 174.57,130.91 174.72,130.91 174.76,130.88 PU6000.10 ; PR6008.1 v1(194.23,127.15)
V5P5A_BOOT_R: length 2.5
  BOTTOM w0.114: PR6018.1 55.32,178 v1(55.1,177.77)
  BOTTOM w0.508: PR6018.1 54.67,178.77 54.5,178.6 PC6035.1
V5P5A_EN: length 4.4
  BOTTOM w0.203: PR6020.2 PR6021.2 57,186.1 56.6,186.5 PC6039.2 56.21,186.01 56.09,185.88 v1(56.09,185.7) 55.79,185.4 PU6003.6
V5P5A_PWRGD: length 1.5
  BOTTOM w0.203: PU6003.7 56.95,184.2 56.98,184.24 57.66,184.24 57.8,184.1 57.92,184.1 PR6022.2
V5P5A_VOUT: length 25.7
  BOTTOM w0.203: PR6026.1 44.84,177.16 45.35,176.65 59.58,176.65 60.81,177.88 v1(60.81,178.79) 60.81,179.06 60.55,179.33 PR6029.2 60.38,180.96 PR6030.2 59.5,180.96 58.74,181.72 PC6055.2 58.46,181.72 57.32,182.85 PU6003.10
V18: length 5.9
  BOTTOM w0.114: v1(21.75,60.96) 21.8,60.96 C1649.2 23.42,62.58 24.01,62.58 24.16,62.73 25.62,62.73 25.74,62.61 U40.24
VCC2_CORE: length 5.1
  BOTTOM w0.114: v1(155.68,147.24) 155.3,147.62 154.11,147.62 153.43,146.94 PR7080.2
  BOTTOM w0.254: PR7080.2 153.2,146.7 PC7063.2 153.47,145.44 PU7001.8
VCC_GT: length 2.5
  BOTTOM w0.508: PC7102.2 156.27,164.04 PR7112.2 156.27,161.89 v1(156.42,161.74)
VCC_SA: length 1
  TOP w0.114: v1(164.49,128.88) 164.49,129.55 PC7104.2
VCCA_19P2_1P05: length 17.6
  TOP w0.254: v1(129.06,129) 129.06,128.45 v1(129.26,128.24)
  TOP w0.381: v1(129.06,129) 129.06,129.01 R1271.1
  IN2 w0.254: v2(116.29,133.31) 116.34,133.31 117.22,134.2 121.54,134.2 123.21,132.53 124.33,132.53 127.28,129.59 128.47,129.59 v1(129.06,129)
  BOTTOM w0.254: v2(116.29,133.31) 116.28,133.31 116.27,133.29 116.11,133.29 U1.BR12
VCCA_OC_1P05: length 19.6
  TOP w0.254: v1(129.29,129.89) 129.29,130.34 v1(129.06,130.58) 129.04,130.59 R1265.1
  IN2 w0.254: v2(114.53,133.9) 114.4,134.03 114.4,134.74 114.86,135.2 121.27,135.2 123.42,133.04 124.71,133.04 127.15,130.6 129.03,130.6 v1(129.06,130.58)
  BOTTOM w0.254: U1.BP14 114.69,133.9 v2(114.53,133.9)
VCCA_SRC_1P05: length 16.4
  TOP w0.381: R1266.1 128.43,128.2 v1(128.25,128.02)
  IN2 w0.254: v2(116.2,132.63) 116.41,132.63 117.11,133.33 117.48,133.33 117.59,133.22 120.8,133.22 121.15,132.88 122.15,132.88 123,132.02 124.08,132.02 128.07,128.04 128.21,128.04 128.23,128.02 v1(128.25,128.02)
  BOTTOM w0.254: U1.BU12 116.2,132.09 v2(116.2,132.63)
VCCA_XTAL_1P05: length 9.5
  TOP w0.254: v2(121.69,119.55) 122.23,119.55 122.68,119.1 v1(122.68,119.08) 122.68,118.77 123.04,118.4 123.82,118.4 124.03,118.19 124.03,117.16 124.8,116.39 124.8,116.1 124.95,115.95 C227.2 125.25,115.6 125.31,115.53 R1267.1
  BOTTOM w0.254: v2(121.69,119.55) 120.96,119.55 120.6,119.91 120.6,120.75 120.52,120.82 120.52,121.29 U1.CP5
VCCAMPHYPLL_1P05: length 1.5
  BOTTOM w0.152: U1.BV2 122.9,131.22 123.15,131.22 123.33,131.4 v2(123.94,131.4)
  vias: v1(124.87,131.44)
VCCAPLL_1.05V: length 2.7
  BOTTOM w0.254: v2(115.31,133.3) 115,132.98 U1.BR14 114.84,132.98 v2(114.55,133.27) 114.27,132.98 U1.BR15 ; U1.BU14 114.96,131.72 115.25,132.01 v2(115.46,132.01) 115.46,132.06 115.73,132.33 U1.BT12
  vias: v1(126.19,129.84)
VCCDPHY_1P24: length 5.1
  BOTTOM w0.254: U1.CP25 107.77,120.91 108.15,120.52 108.15,120.08
  BOTTOM w0.508: R211.1 C228.2 107.41,118.02 107.55,118.17 107.55,119.19 108.15,119.79 108.15,120.08
VCCDSW_1P05: length 1.1
  TOP w0.203: C229.2 108.75,132.69 v2(108.73,132.66)
  BOTTOM w0.191: v2(108.73,132.66) 108.4,132.33 U1.BT24
VCCDSW_3P32: length 15.8
  TOP w0.254: R1270.1 109.58,118.17 109.58,120.12 109.65,120.2 109.65,120.61 108.99,121.27 108.99,126.16 108.72,126.43 108.72,127.2 108.25,127.67 108.25,131.77 108.49,132.01 v2(108.73,132.01)
  BOTTOM w0.254: U1.BT23 108.76,132.01 v2(108.73,132.01)
VCCDSW_GPIO: length 28.7
  TOP w0.508: v1(93.68,110.33) 93.53,110.49 93.53,111.38 93.43,111.48 93.43,111.73 92.71,112.45 92.71,115.22 92.92,115.43 92.92,116.26 95.76,119.1 99.48,119.1 100.94,120.56 v1(101.44,120.56)
  IN2 w0.508: 101.9,130.7 101.23,130.03 101.23,129.54 101.34,129.43 101.34,127.72 101.08,127.46 101.08,125.57 100.23,124.72 100.23,122.56 101.44,121.35 v1(101.44,120.56)
  BOTTOM w0.254: v2(107.77,132.67) 107.93,132.67 U1.BR24
VCCDUSB_1P05: length 4
  IN2 w0.508: v2(128.47,123.15) 127.25,123.15 125.88,124.52 125.88,124.89
  BOTTOM w0.254: U1.CC12 115.79,127.78 v2(115.46,127.46)
VCCGT_SENSE: length 7.8
  TOP w0.114: PR7051.1 127.68,165.17 127.27,165.17 PR7050.1 127.03,165.27 126.77,165.02 v1(126.39,165.02)
  BOTTOM w0.102: U1.E3 121.84,163.79 121.84,164.14 122.02,164.32 122.39,164.32 122.55,164.49 123.08,164.49 123.23,164.64 126.01,164.64 v1(126.39,165.02)
VCCHDA: length 0.5
  BOTTOM w0.254: U1.BT20 110.77,132.33 111.11,132 v2(111.12,132)
  vias: v1(113.16,121.03)
VCCIO_VCCSENSE: length 1.4
  TOP w0.203: R72.1 105.92,133.07 v2(106.1,132.89)
  BOTTOM w0.203: U1.BP28 106.07,133.16 106.07,132.91 v2(106.1,132.89)
VCCIO_VSSSENSE: length 1.5
  TOP w0.203: R74.1 104.95,133.46 105.46,132.96 v2(105.46,132.91)
  BOTTOM w0.203: U1.BP29 105.18,133.18 v2(105.46,132.91)
VCCK_V12: length 7.7
  IN3 w0.508: v1(33.97,152.14) 33.97,151.59 32.16,149.78 28.06,149.78 v1(27.73,150.11)
  vias: v1(33.96,152.75)
VCCMPHYGTAON_1P05:
  vias: v1(126.47,123.95) v1(128.93,117.23) v1(129.14,116.58) v2(115.31,130.7) v2(115.3,130.06) v2(116.28,130.71) v2(116.28,130.05)
VCCPRIM_1P05: length 5
  BOTTOM w0.254: U1.BU18 112.47,131.68 v2(112.79,132) 112.46,132.33 U1.BT18 ; U1.BT19 111.78,132.33 v2(112.1,132.01) 111.95,132.01 111.63,131.68 U1.BU19 ; U1.BR20 110.76,132.98 111.1,132.65 v2(111.11,132.65) ; v2(110.38,133.96) 110.23,133.96 109.92,133.65 U1.BP22 ; v2(114.46,128.76) 114.49,128.76 114.5,128.77 114.65,128.77 U1.CA14 ; U1.BP20 110.76,133.65 v2(111.1,133.98) ; v2(110.38,132.66) 110.05,132.33 U1.BT22
  vias: v1(126.5,126.31) v1(126.52,125.64) v1(126.66,124.99) v1(127.12,124.51) v1(127.31,125.85) v2(111.1,130.06) v2(112.1,130.06) v2(112.88,130.09)
VCCPRIM_1P8: length 3.5
  TOP w0.203: C224.2 122.36,118.26 122.07,118.54 v1(122.07,118.94)
  BOTTOM w0.152: U1.CP23 109.03,120.58 v2(109.19,120.42)
  BOTTOM w0.203: U1.CP17 112.98,121.36 v2(112.98,120.36)
  vias: v1(121.39,118.94) v2(112.03,127.46) v2(112.01,126.86) v2(112.85,127.48) v2(112.85,126.87)
VCCPRIM_3P3: length 9.3
  IN2 w0.381: v1(111.41,118.7) 111.05,118.34 109.75,118.34 109.48,118.61 105.8,118.61 v2(105.77,118.64)
  BOTTOM w0.254: v2(105.77,118.64) 106.08,118.95 106.08,120.05 105.25,120.89 U1.CP29
  vias: v1(111.8,119.26) v1(112.05,118.67) v1(111.99,117.42) v1(112.44,119.23) v2(109.5,128.04) v2(109.5,127.45)
VCCPRIM_3P33: length 0.5
  BOTTOM w0.254: v2(112.9,128.13) 112.98,128.13 U1.CB16
  vias: v1(124.78,122.81)
VCCRTC_3: length 1.5
  TOP w0.508: Q28.3 5.87,12.74 R310.2
VCCRTC_4: length 1
  TOP w0.508: R67360.2 8.4,13.52 7.43,13.52 R310.1
VCCSA_SENSE: length 34.6
  TOP w0.114: v1(142.62,131.91) 142.74,131.91 143.2,132.37 143.79,132.37 PR7057.1 144.59,131.91 144.69,132.01 PR7058.1 ; v1(130.84,140.51) 130.63,140.3 122.97,140.3 122.61,140.66 121.13,140.66 120.21,139.74 118.91,139.74 118.72,139.54 118.72,138.92 119.23,138.42 119.23,138.29 v2(119.22,138.28)
  IN1 w0.089: v1(130.84,140.51) 131.07,140.28 131.38,140.28 134.35,137.3 135.93,137.3 136.71,136.52 136.71,134.09 137.18,133.62 140.37,133.62 141.65,132.34 142.2,132.34 v1(142.62,131.91)
  BOTTOM w0.203: v2(119.22,138.28) 119.22,138.23 U1.BG7
VCCSPI: length 10.7
  TOP w0.508: 109.46,126.75 109.48,126.74 109.48,121.47 110.13,120.81 110.13,120 110.06,119.92 110.06,118.71 110.58,118.19 110.58,117.68 R1276.2
  BOTTOM w0.254: U1.BV23 109.05,131.03 108.73,130.71 v2(108.73,130.71)
VCCST_PWRGD_EN: length 3.6
  TOP w0.114: U2014.2 88.86,107.25 89.3,106.8 90.94,106.8 91.2,106.54 R2257.1
VCCST_PWRGD_EN_L: length 8.6
  TOP w0.114: U2014.4 88.21,105.48 88.03,105.31 87.33,105.31 87.2,105.44 C2337.1 87.41,105.99 87.69,106.27 87.69,107.41 87.42,107.68 C2336.1 87.07,107.68 86.17,106.78 85.73,106.78 85.55,106.6 U2015.2 85.55,105.33 v1(84.97,104.75)
VCCST_PWRGD_R: length 239.8
  TOP w0.114: v1(88.47,104.14) 89.32,104.14 89.46,103.99 91.28,103.99 92.83,105.55 92.83,106.79 91.97,107.66 91.24,107.66 90.58,108.31 90.58,109.06 90.29,109.34 86.72,109.34 86.2,108.82 U2015.4 ; v1(196.67,123.31) 196.67,122.71 197.12,122.26 197.12,120.4 198.01,119.51 198.01,117.77 197.53,117.29 197.53,115.21 197,114.68 197,112.03 197.53,111.5 197.53,107.03 196.85,106.36 196.85,105.8 196.02,104.97 196.02,104.2 196.5,103.72 196.5,102.09 194.41,100 v1(194.41,99.81)
  IN1 w0.089: v1(129.81,137.37) 130.33,137.37 132.75,134.95 132.75,134.43 133.14,134.03 133.84,134.03 134.54,133.34 134.54,132.26 135.44,131.36 137.03,131.36 139.31,129.08 145.71,129.08 146.85,127.94 147.49,127.94 147.92,127.51 147.92,126.78 148.45,126.24 148.86,126.24 151.1,124 155.16,124 156.07,123.09 156.07,122.54 156.89,121.73 160.9,121.73 160.91,121.73 163.03,121.73 164.25,120.51 166.06,120.51 166.91,121.36 167.89,121.36 168.11,121.13 174.11,121.13 174.6,121.61 180.09,121.61 181.68,120.03 183.26,120.03 183.45,119.83 188.11,119.83 189.42,121.14 191.16,121.14 192.83,122.81 196.18,122.81 v1(196.67,123.31) ; v1(194.41,99.81) 192.97,98.36 183.68,98.36 183.23,98.81 182.02,98.81 181.51,99.33 181.51,99.79 181.28,100.02 168.78,100.02 168.37,99.61 162.12,99.61 160.78,100.95 156.03,100.95 154.71,102.27 152.22,102.27 151.8,101.85 151.49,101.85 150.65,101.01 147.88,101.01 147.43,101.46 144.59,101.46 144.14,101.91 143.73,102.33 138.08,102.33 137.26,103.15 133.71,103.15 133.11,103.74 129.89,103.74 127.08,106.56 120.45,106.56 117.49,109.52 112.08,109.52 111.23,108.67 109.77,108.67 109.06,109.38 106.95,109.38 105.7,110.63 103.31,110.63 101.21,108.53 97.73,108.53 96.04,106.84 90.01,106.84 88.47,105.3 v1(88.47,104.14)
  BOTTOM w0.114: R2228.2 130.5,138.15 R2229.1 130.51,137.78 130.09,137.37 v1(129.81,137.37)
VDDQ_BOOT: length 2.6
  TOP w0.114: v1(76.28,181.66) 76.28,181.93 v1(75.76,182.44)
  TOP w0.508: PR5004.2 v1(75.76,182.44)
  BOTTOM w0.203: PU5000.18 75.6,182.61 v1(75.76,182.44)
VDDQ_PG: length 1.6
  TOP w0.203: v1(71.56,183.26) 72.37,183.26 PR5009.2
  BOTTOM w0.203: PU5000.8 v1(71.56,183.26)
VDDQ_PVIN:
  vias: v1(67.87,182.95) v3(68,181.23) v3(68.46,181.84) v3(68.94,181.23) v3(69.42,181.84)
VDDQ_SLP_S4: length 3.9
  TOP w0.203: PR5010.2 PR5012.2 71.91,185.77 v1(71.99,185.7) 72.33,185.36 v1(72.74,185.36) 72.74,185.26 72.83,185.17 PC5022.1
  BOTTOM w0.203: v1(72.74,185.36) 72.91,185.18 PU5000.11
VDDQ_SW: length 3
  TOP w0.114: v1(76.46,183.66) 76.38,183.66 v1(75.83,183.11)
  TOP w0.508: PR5007.1 75.32,184.73 PC5011.2 75.47,183.66 75.83,183.3 v1(75.83,183.11)
VDDQ_SW_VPP:
  vias: v1(75.09,185.67)
VDDQ_VCC: length 1
  TOP w0.508: PR5003.2 PC5009.1
  vias: v1(74.78,187.78) v3(74.03,187.84)
VDDQ_VDDQSNS: length 16
  TOP w0.203: PR5008.2 85.34,179.12 v1(84.78,179.12) v1(84.3,178.64)
  IN2 w0.203: v1(84.3,178.64) 83.24,178.64 82.35,177.76 76.04,177.76 72.8,181 v1(72.8,181.15)
  BOTTOM w0.203: v1(72.8,181.15) 72.8,181.17 72.91,181.29 PU5000.5
VDDQ_VLDOIN: length 3.4
  TOP w0.114: PR5005.2 74.83,179 v1(74.83,178.03)
  TOP w0.508: PR5005.2 74.74,179.51 75.27,180.04 PC5012.1 75.27,181.14 v3(75.26,181.15)
VDDQ_VTT: length 2.5
  BOTTOM w0.114: v1(74.5,178.28) 74.4,178.39 PC5019.1
  BOTTOM w0.203: PU5000.2 74.41,181.42 74.48,181.36 74.48,180.47 PC5020.1
VDDQ_VTT_CNTL: length 1.1
  BOTTOM w0.114: PC5023.1 71.06,185.9 v1(69.98,185.9)
VDDQ_VTTSNS: length 1.2
  BOTTOM w0.203: PU5000.4 73.41,181.4 73.41,181.39 73.41,180.97 73.41,180.96 PR5013.1
VSSGT_SENSE: length 8.2
  TOP w0.114: PR7053.1 128.03,164.7 127.91,164.82 127.37,164.82 PR7052.1 126.91,164.35 v1(126.37,164.35)
  BOTTOM w0.102: U1.D2 122.03,163.84 122.03,163.59 122.1,163.52 122.43,163.52 122.76,163.85 123.06,163.85 123.17,163.75 123.72,163.75 123.9,163.93 123.9,164.23 124.05,164.38 124.24,164.38 124.35,164.28 124.35,164.03 124.45,163.93 124.65,163.93 124.75,164.03 124.75,164.28 124.82,164.35 v1(126.37,164.35)
VSSSA_SENSE: length 34.4
  TOP w0.114: PR7062.1 144.81,132.99 144.67,133.13 PR7061.1 144.25,132.73 144.16,132.65 143.1,132.65 142.88,132.43 142.47,132.43 v1(141.94,131.89) ; v1(130.86,139.77) 130.86,139.95 130.78,140.04 122.83,140.04 122.53,140.33 121.23,140.33 120.91,140.01 120.91,138.94 120.75,138.78 119.65,138.78 v2(119.18,139.25)
  IN1 w0.089: v1(141.94,131.89) 141.94,132.02 141.81,132.15 141.57,132.15 140.29,133.43 137.1,133.43 136.52,134.01 136.52,136.44 135.85,137.11 134.27,137.11 131.3,140.09 130.92,140.09 130.86,140.02 v1(130.86,139.77)
  BOTTOM w0.203: v2(119.18,139.25) 119.17,139.25 119.16,139.25 118.87,138.96 U1.BE7
1-AUXN: length 2.6
  TOP w0.102: U12.25 15.31,68.78 14.9,69.19 14.52,69.19 C20078.2 R208.2
1-AUXP: length 2.5
  TOP w0.102: R25563.2 C390.2 14.24,69.55 14.4,69.39 14.99,69.39 15.19,69.18 U12.24
1-CDE: length 6.1
  TOP w0.114: U12.14 18.92,71.49 19.06,71.64 19.06,73.17 19.09,73.2 19.09,74.38 19.23,74.52 19.23,74.95 18.6,75.59 R25567.1 R25566.2
1-CE_USB: length 2.3
  TOP w0.114: U12.35 18.92,65.98 19.02,65.88 v1(19.02,65.83) 19.02,65.48 R178.1
1-DCICFG: length 2.6
  TOP w0.114: U12.3 22.91,68.38 R25568.2 R25569.1
1-MASTER_SCL: length 41.9
  TOP w0.114: U12.21 15.51,70.38 14.85,71.05 14.85,71.66 14.72,71.79 R25572.1 14.96,72.34 15.36,71.94 v1(15.36,71.53)
  IN2 w0.102: v1(19.94,43.25) 19.94,43.63 17.48,46.1 17.48,54.29 19.27,56.08 19.94,56.08 20.2,55.83 20.2,55.83 20.37,55.65 v1(20.88,55.65)
  IN4 w0.089: v1(15.36,71.53) 15.36,71.16 16.05,70.47 16.05,67.43 16.62,66.86 16.62,64.85 17.32,64.15 17.32,56 18.07,55.24 20.27,55.24 v1(20.88,55.65)
  BOTTOM w0.114: v1(20.88,55.65) R67892.1 ; R67894.1 v1(19.94,43.25)
1-MASTER_SDA: length 42.2
  TOP w0.114: v1(13.35,72.54) 13.56,72.34 R25573.1 13.95,71.93 14.37,71.52 14.37,71.04 14.79,70.62 14.79,70.19 15,69.98 U12.22
  IN2 w0.102: v1(20.63,43.25) 20.63,43.3 17.71,46.22 17.71,54.2 19.16,55.65 v1(19.71,55.65)
  IN4 w0.089: v1(19.71,55.65) 17.98,55.65 17.51,56.12 17.51,64.23 16.81,64.93 16.81,66.94 16.24,67.51 16.24,70.69 15.83,71.11 15.83,71.87 15.15,72.54 v1(13.35,72.54)
  BOTTOM w0.114: v1(19.71,55.65) 19.87,55.5 R67891.1 ; R67893.1 20.96,43.58 v1(20.63,43.25)
1-ML0N: length 3.2
  TOP w0.102: U12.10 20.52,71.36 20.62,71.45 20.62,71.67 21.59,72.64 21.59,73.3 C20067.2
1-ML0P: length 3.2
  TOP w0.102: C20066.2 21.8,73.29 21.8,72.56 20.82,71.58 20.82,71.47 20.92,71.37 U12.9
1-ML1N: length 3
  TOP w0.102: U12.13 19.32,71.35 19.42,71.45 19.42,72.61 19.87,73.06 19.87,73.29 C20077.2
1-ML1P: length 3
  TOP w0.102: U12.12 19.72,71.36 19.62,71.45 19.62,72.53 20.07,72.98 20.07,73.3 C20076.2
1-ML2N: length 3.1
  TOP w0.102: C20075.2 18.11,73.3 18.11,73.06 18.53,72.64 18.53,71.78 18.12,71.38 U12.16
1-ML2P: length 3
  TOP w0.102: C20074.2 18.32,73.3 18.32,73.14 18.73,72.73 18.73,71.7 18.52,71.49 U12.15
1-ML3N: length 3.3
  TOP w0.102: U12.19 16.92,71.39 17.17,71.64 17.17,72.1 16.59,72.69 16.59,72.83 16.46,72.96 16.46,73.51 C20069.2
1-ML3P: length 3.3
  TOP w0.102: U12.18 17.32,71.5 17.38,71.56 17.38,72.19 16.79,72.77 16.79,72.91 16.66,73.04 16.66,73.6 16.83,73.77 C20068.2
1-REXT: length 3.7
  TOP w0.114: R25562.2 23.63,66.72 22.71,66.72 v1(22.61,66.82) 22.61,67.86 22.48,67.98 U12.2
1-SSDE: length 6.8
  TOP w0.114: U12.11 20.12,71.6 20.83,72.31 v1(20.83,72.72) 20.83,74.27 21.06,74.49 21.06,75 20.86,75.21 20.86,75.66 20.65,75.87 R25564.2 R25565.1
1-SSRXN: length 1.8
  TOP w0.102: C20071.2 23.07,68.98 22.99,68.98 22.92,68.91 22.28,68.91 22.15,68.78 U12.4
1-SSRXP: length 1.8
  TOP w0.102: C20070.2 23.02,69.19 22.91,69.19 22.84,69.11 22.25,69.11 22.18,69.18 U12.5
1-SSTXN: length 2
  TOP w0.102: C20073.2 23.06,70.52 22.97,70.52 22.53,70.08 22.28,70.08 22.18,69.98 U12.7
1-SSTXP: length 2
  TOP w0.102: C20072.2 23.03,70.72 22.88,70.72 22.45,70.28 22.29,70.28 22.19,70.38 U12.8
1-TX1N: length 2.9
  TOP w0.102: C20055.1 18.42,64.64 18.42,64.77 18.6,64.95 18.6,66.17 18.43,66.34 18.43,66.45 18.52,66.54 U12.34
1-TX1P: length 2.9
  TOP w0.102: U12.33 18.12,66.55 18.23,66.45 18.23,66.26 18.4,66.09 18.4,65.04 18.21,64.85 18.21,64.65 C361.1
1-TX2N: length 3.4
  TOP w0.102: C20057.1 20.7,64.71 20.7,64.83 20.58,64.94 20.26,64.94 19.42,65.78 19.42,66.51 19.32,66.61 U12.36
1-TX2P: length 3.4
  TOP w0.102: U12.37 19.72,66.61 19.62,66.51 19.62,65.87 20.35,65.15 20.66,65.15 20.9,64.91 20.9,64.71 C20056.1
1.03_GFX_PGD: length 89.7
  IN1 w0.089: v1(105.97,180.67) 105.99,180.69 107.02,180.69 107.6,181.27 107.86,181.27 108.02,181.11 112.17,181.11 112.93,180.35 127.08,180.35 129.19,178.24 134.14,178.24 135.98,176.39 138.91,176.39 140.32,174.99 140.32,173.39 143.45,170.26 151.27,170.26 151.64,169.88 158.43,169.88 160.22,168.09 166.14,168.09 166.45,168.41 166.9,168.41 167.74,167.56 167.74,165.85 166.78,164.89 166.78,160.53 168.4,158.91 168.4,156.9 169.08,156.23 169.08,155.7 169.93,154.85 v2(170.34,154.85)
  BOTTOM w0.114: v1(105.97,180.67) 105.62,181.03 105.62,181.49 105.66,181.54 105.66,181.68 105.82,181.83 105.82,182.65 105.82,182.66 105.82,183.29 105.66,183.45 105.66,183.75 PR9076.1 PR9078.1
  BOTTOM w0.203: v2(170.34,154.85) v1(170.34,154.2) 170.3,154.2 170.17,154.07 PR9096.1
2ND_MBCLK: length 191.8
  TOP w0.114: v1(114.33,116.82) 114.48,116.97 115.28,116.97 115.52,117.21 115.52,117.62 115.77,117.87 R67881.2 116.16,117.87 116.5,117.53 116.5,117.05 116.88,116.67 117.07,116.67 117.21,116.52 117.21,114.68 Q6568.3 ; v1(146.38,109.07) 146.96,109.07 147.41,109.52 R383.1 146.79,109.9 R67448.1 ; U37.115 158.16,112.3 157.92,112.54 v1(157.92,113.2)
  IN1 w0.089: v1(92.96,180.42) 92.96,180.04 93.49,179.52 94.57,179.52 95.06,180.01 99.01,180.01 100.79,178.22 103.89,178.22 104.21,177.9 110.58,177.9 111.5,176.98 116.31,176.98 117.7,175.59 121.21,175.59 122.36,174.45 122.36,172.15 124.13,170.38 125.38,170.38 125.95,169.8 v1(125.95,169.4)
  IN2 w0.102: v1(157.92,113.2) 157.51,113.62 156.94,113.62 155.7,112.38 154.71,112.38 152.51,110.18 147.76,110.18 146.65,109.07 v1(146.38,109.07) 146.04,109.07 144.92,110.18 141.29,110.18 140.1,108.98 137.42,108.98 135.18,111.23 132.77,111.23 131.85,110.31 129.33,110.31 128.48,111.16 125.31,111.16 121.08,115.39 116.89,115.39 115.51,116.77 114.38,116.77 v1(114.33,116.82)
  IN4 w0.089: v1(157.92,113.2) 158.85,114.13 160.07,114.13 162.23,116.29 162.23,116.91 162.62,117.3 162.62,120.42 161.33,121.7 156.6,121.7 156.21,122.09 156.21,122.68 155.19,123.7 151.15,123.7 149.01,125.84 148.39,125.84 147.87,126.37 147.87,127.55 147.13,128.29 146.21,128.29 145.68,128.82 144.79,128.82 143.81,129.8 139.61,129.8 138.5,130.9 138.5,132.37 137.01,133.87 137.01,137.29 135.07,139.23 133.7,139.23 132.31,140.62 132.31,141.06 130.84,142.53 130.17,142.53 128.31,144.39 127.72,144.39 126.95,145.17 126.95,146.89 128.66,148.6 128.66,151.51 129.41,152.27 129.41,154.25 128.12,155.53 128.12,157.66 130.43,159.97 130.43,161.36 127.46,164.34 127.46,165.62 126.23,166.85 126.23,169.12 v1(125.95,169.4)
  BOTTOM w0.114: v1(92.96,180.42) 92.96,180.72 92.24,181.44 Q6564.3
2ND_MBDATA: length 188.7
  TOP w0.114: U37.116 157.76,112.18 157.25,112.68 v1(157.25,113.18) ; Q6568.6 115.53,115.38 114.98,114.83 R67882.2 114.46,115.28 v2(114.94,115.76) ; R67447.1 144.84,107.49 144.84,108.43 145,108.59 R25304.1 145.26,108.93 v1(145.41,109.08)
  IN1 w0.089: v1(93.79,179.1) 94.66,179.1 95.22,179.66 98.86,179.66 100.65,177.88 103.74,177.88 104.07,177.56 110.44,177.56 111.36,176.63 116.17,176.63 117.55,175.25 121.07,175.25 122.01,174.31 122.01,172.01 124.16,169.86 125.26,169.86 v1(125.35,169.77)
  IN2 w0.102: v2(114.94,115.76) 115.67,115.03 120.94,115.03 125.16,110.81 128.33,110.81 129.18,109.95 132,109.95 132.92,110.87 135.03,110.87 137.27,108.63 140.24,108.63 141.44,109.83 144.67,109.83 v1(145.41,109.08) 145.86,108.64 146.72,108.64 147.91,109.83 152.66,109.83 154.85,112.02 155.85,112.02 157.01,113.18 v1(157.25,113.18)
  IN4 w0.089: v1(157.25,113.18) 158.54,114.48 159.93,114.48 161.89,116.43 161.89,117.06 162.27,117.44 162.27,120.28 161.19,121.36 156.45,121.36 155.87,121.95 155.87,122.54 155.05,123.36 151.01,123.36 148.87,125.5 148.25,125.5 147.53,126.23 147.53,127.41 146.99,127.95 146.07,127.95 145.54,128.48 144.65,128.48 143.67,129.46 139.47,129.46 138.16,130.76 138.16,132.23 136.66,133.73 136.66,137.15 134.93,138.89 133.56,138.89 131.96,140.49 131.96,140.93 130.7,142.19 130.03,142.19 128.17,144.05 127.58,144.05 126.61,145.03 126.61,147.03 128.32,148.75 128.32,151.81 129.07,152.56 129.07,154.1 127.78,155.39 127.78,157.8 130.09,160.11 130.09,161.22 127.11,164.19 127.11,165.48 125.89,166.71 125.89,168.69 125.35,169.23 125.35,169.77 v1(125.35,169.77)
  BOTTOM w0.114: Q6564.6 94.24,183.32 94.57,183 94.57,181.65 95.09,181.12 95.09,180.19 94,179.1 v1(93.79,179.1)
27M_XTAL_IN: length 10.7
  BOTTOM w0.102: U8.C11 127.66,183.67 127.66,183.16 127.75,183.07 127.75,182.12 127.43,181.81 127.43,181.42 127.69,181.17
  BOTTOM w0.114: Y3.3 126.35,175.86 126.35,177.64 C463.1 126.69,178.62 126.69,179.48 127.69,180.47 127.69,181.17
27M_XTAL_OUT: length 7.8
  BOTTOM w0.102: U8.B10 127.54,182.9 127.54,182.25 127.15,181.86 127.15,180.63 127.08,180.55
  BOTTOM w0.114: Y3.1 125.73,177.3 125.73,178.01 C464.1 126.02,178.32 126.19,178.49 126.19,179.66 127.08,180.55
3602_ALERT#: length 3.8
  BOTTOM w0.114: PR7020.1 167.32,148.06 166.74,147.48 166.3,147.48 166.3,147.48 165.75,147.48 165.1,146.83 PU7000.33
3602_CLK: length 5.6
  BOTTOM w0.114: PU7000.34 165.5,146.71 165.9,147.11 166.92,147.11 167.4,147.6 167.84,147.6 168.28,148.04 PR7015.2 v1(169.29,149.04)
3602_DRON: length 62.8
  TOP w0.254: v1(166.54,133.09) 166.65,133.19 168.18,133.19 168.49,132.88 169.25,132.88 169.93,132.2 169.93,129.59 v1(169.47,129.13) 168.25,129.13 PR7115.1
  IN1 w0.203: v1(160.07,150.38) 161.36,150.38 161.88,149.86 161.88,148.86 162.4,148.34 166.45,148.34 v2(167.65,147.14)
  IN4 w0.203: v1(160.07,150.38) 160.07,151.33 160.2,151.46 160.2,157.63 159.28,158.56 157.67,158.56 156.91,159.32 156.91,160.75 156.57,161.09 v1(156.13,161.09)
  IN4 w0.254: v2(167.65,147.14) 167.99,147.14 168.33,146.8 168.33,145.68 167,144.36 167,138.24 166.64,137.88 166.64,136.24 165.44,135.04 165.44,134.2 v1(166.54,133.09)
  BOTTOM w0.203: PR7111.1 154.17,164.09 154.69,163.57 155.4,163.57 155.6,163.37 155.6,162.06 155.58,162.03 PR7107.1 155.58,161.36 155.85,161.09 v1(156.13,161.09) ; PR7079.1 156.27,145.89 156.27,147.12 156.55,147.39 156.55,148.85 157.64,149.94 159.11,149.94 159.54,150.38 v1(160.07,150.38) ; v2(167.65,147.14) 167.45,147.14 167.05,146.74 166.08,146.74 165.9,146.55 PU7000.35
3602_PSYS: length 6
  TOP w0.114: PC7006.1 170,140.42 v1(170.16,140.59)
  TOP w0.203: PC7006.1 168.57,140.42 168.57,140.42 ; 168.57,140.42 168.22,140.42 168,140.2 167.78,140.2 PR7042.2 167.6,140.56 167.98,140.93 168.55,140.93 v2(168.67,141.06) ; 168.57,140.42 PR7039.2
  BOTTOM w0.203: v2(168.67,141.06) 168.36,141.06 168,141.41 PU7000.46
3602_SET1: length 4.2
  TOP w0.203: v1(166.4,139.42) 165.99,139.01 v2(165.99,138.68) 166.06,138.61 PR7027.2 167.3,138.81 168.06,138.81 PR7035.2
  BOTTOM w0.203: PU7000.2 165.9,139.06 165.99,138.96 v2(165.99,138.68)
3602_SET2: length 4.1
  TOP w0.203: v2(164.47,137.45) 164.59,137.45 165,137.86 PR7028.2 165.08,137.84 PR7036.1
  BOTTOM w0.203: PU7000.5 164.7,138.66 164.7,138.65 164.7,138.25 164.47,138.02 v2(164.47,137.45)
3602_SET3: length 3.1
  TOP w0.203: PR7037.1 163.18,137.83 163.24,137.76 163.71,137.76 163.77,137.83 PR7029.2 163.9,138.04 164.08,138.22 164.08,138.31 v2(164.22,138.45)
  BOTTOM w0.203: v2(164.22,138.45) 164.3,138.53 PU7000.6
3602_TSENSE_CORE: length 23.8
  TOP w0.114: v1(161,138.77) 160.96,138.73 v1(160.96,138.07)
  IN3 w0.203: v1(156.84,155.42) 156.83,155.42 156.27,154.86 156.27,149.35 158.8,146.82 158.8,145.18 159.99,143.99 160.13,143.99 160.68,143.44 160.68,140.2 161.26,139.63 161.26,139.02 v1(161,138.77)
  BOTTOM w0.152: PU7000.11 162.3,139.19 161.8,138.69 161.64,138.69 161.06,138.11 PR7026.2
  BOTTOM w0.203: PR7026.2 160.89,138.2 160.89,138.65 v1(161,138.77) ; PR7032.1 156.28,155.97 v1(156.84,155.42)
3602_TSENSE_GT: length 39.4
  TOP w0.203: v1(160.1,145.03) 160.36,145.29 160.36,146.98 159.57,147.77 159.57,148.05 PR7018.2
  IN1 w0.203: v1(160.1,145.03) 160.44,145.38 160.44,146.7 159.14,148 159.14,149.09 158.75,149.48 158.75,150.01 160.43,151.69 160.43,157.31 159.58,158.17 157.68,158.17 157.17,158.67 157.17,163.72 155.97,164.93 155.97,166.7 154.74,167.92 151.89,167.92 151.68,168.13 151.12,168.13 v1(150.78,167.79)
  BOTTOM w0.203: PR7021.1 149.72,168.43 150.27,168.43 v1(150.37,168.32) 150.65,168.32 150.78,168.2 v1(150.78,167.79) ; v1(160.1,145.03) 160.1,144.85 160.34,144.61 PU7000.23
3602_VCC: length 4
  TOP w0.508: v1(160.16,140.19) 160.26,140.09 v1(160.84,140.09) PC7026.1 161.73,140.45 161.33,140.86 PR7064.2
  BOTTOM w0.203: PU7000.13 160.58,140.61 v1(160.16,140.19)
3602_VDIO: length 3.1
  BOTTOM w0.114: PR7019.2 165.79,148.04 164.7,146.95 PU7000.32
3602_VIN: length 6.4
  TOP w0.114: v1(159.46,138.86) 159.54,138.78 v1(159.54,138.1)
  TOP w0.508: v1(159.46,138.86) 159.08,139.25 PC7000.2 158.7,138.74 158.5,138.53 PR7000.1
  BOTTOM w0.203: PU7000.12 161.9,139.26 161.72,139.08 161.5,139.08 161.15,139.43
  BOTTOM w0.508: 161.15,139.43 160.57,139.43 160.01,138.86 v1(159.46,138.86)
3602_VREF: length 64.4
  TOP w0.203: PR7010.1 159.21,145.68 v1(159.77,145.68) ; PR7022.2 168.05,136.37 v1(167.18,135.5) 167.18,134.76 v1(166.75,134.33) 166.4,133.98 165.56,133.98 165.08,134.46 PR7023.2 164.11,135.32 PR7024.2 ; PR7008.1 168.7,143.08 v2(169.31,143.08)
  IN1 w0.203: v1(159.41,134.67) 160.1,134.67 160.87,135.44 164.17,135.44 165.64,133.97 166.39,133.97 v1(166.75,134.33) 167.06,134.01 168.67,134.01 170.52,135.87 170.52,138.58 169.49,139.6 169.49,140.3 169.83,140.64 169.83,142.56 v2(169.31,143.08) 169.83,143.6 169.83,145.7 171.58,147.45 v1(171.58,148.46)
  IN3 w0.203: v1(171.58,148.46) 171.58,149.04 171.06,149.57 171.06,150.26 170.59,150.72 169.93,150.72 168.28,149.07 166.81,149.07 166.31,148.57 164.1,148.57 v1(163.14,149.53) 161.79,148.18 160.73,148.18 160.32,147.77 160.32,146.08 159.92,145.68 v1(159.77,145.68)
  BOTTOM w0.203: v1(163.14,149.53) 163.14,149.23 163.02,149.11 PR7004.1 ; v2(169.31,143.08) 169.28,143.04 168.31,143.04 168.27,143.01 PU7000.42 ; PR7009.1 159.8,134.28 v1(159.41,134.67) ; PR7013.1 170.07,136.75 PR7006.2 170.07,134.68 169.63,134.24 169.07,134.24 168.97,134.13 166.94,134.13 v1(166.75,134.33) ; PR7005.2 171.58,147.43 v1(171.58,148.46)
3602_VRHOT: length 3.5
  BOTTOM w0.114: PU7000.31 164.3,147.26 v1(164.83,147.79) 164.77,147.85 PR7011.1 165.48,148.47 PR7012.1
5213EN_1.8V: length 3
  TOP w0.254: PR566.1 PC581.1 37.67,138.83 36.66,138.83 36.5,138.99 PU3004.7
5213FB_1.8V: length 3.7
  TOP w0.254: PU3004.1 37,143.13 PR567.2 37.4,143.52 PR568.2 PC574.2
5213FB_1.8V_S: length 9
  TOP w0.254: PR569.1 38.63,136.98 38.93,137.28 38.93,140.67 v1(38.89,140.71) 38.89,140.88 PC574.1 38.37,141.62 38.73,141.98 38.73,144.04 38.46,144.3 PR568.1
5213LX_1.8V:
  vias: v1(38.15,137.66)
5213PG_1.8V: length 3.5
  TOP w0.254: PU3004.2 36.5,142.77 36.57,142.84 36.57,144.86 36.5,144.93 PR9256.2
8813BOOT1: length 1.2
  TOP w0.114: PC9008.2 101.13,200.59 v1(101.55,201.01)
8813EN: length 3.7
  TOP w0.254: PC9013.1 99.47,198.51 v2(99.62,198.37) 99.88,198.11 99.88,197.96 PU9000.3
  BOTTOM w0.254: PR9085.2 99.28,197.47 99.09,197.66 v1(99.09,197.74) 99.11,197.76 99.11,197.87 v2(99.62,198.37)
8813ILIM: length 3.7
  TOP w0.254: PU9000.12 100.98,193.54 v2(101.35,193.16)
  BOTTOM w0.254: PR9032.2 99.98,194.49 99.52,194.03 v1(99.52,193.8) 99.9,193.42 PC9030.1 100.62,193.16 v2(101.35,193.16)
8813ISEN1: length 3.1
  TOP w0.254: PU9000.15 v2(103.38,193.75)
  BOTTOM w0.254: PR9013.2 104.21,193.75 v2(103.38,193.75) 103.38,194.16 102.88,194.67
8813ISEN2: length 2.9
  TOP w0.254: v2(103.38,193.14) 103.28,193.24 103.17,193.24 102.87,193.54 102.87,193.55 PU9000.14
  BOTTOM w0.254: v2(103.38,193.14) 103.28,193.24 103.17,193.24 102.87,193.54 102.87,193.56 PR9025.2
8813LGAT1: length 5.4
  TOP w0.254: PU9000.23 102.36,197.95 102.71,198.3 v3(102.71,198.87)
  BOTTOM w0.61: PR9011.1 102.29,198.32 102.71,198.74 v3(102.71,198.87) v1(103.44,199.6) 103.74,199.9 103.74,200.42 103.36,200.81 PQ9000.8
8813LGAT2: length 12.1
  TOP w0.254: v3(104.42,197.1) 104.17,197.35 103.91,197.35 PU9000.20
  IN4 w0.61: v3(112.89,196.03) 105.5,196.03 v3(104.42,197.1)
  BOTTOM w0.114: v1(104.42,196.39) v3(104.42,197.1)
  BOTTOM w0.61: v3(112.89,196.03) 112.3,196.03 112.07,195.79 PQ9001.8
8813PG: length 2.1
  TOP w0.254: PU9000.16 103.56,194.28 103.59,194.28 103.77,194.1 PR9008.2 PR9009.2
8813PHASE1: length 5
  IN4 w0.61: v3(103.76,203.02) 103.76,203 101.86,201.6 v3(101.86,199.03)
  vias: v1(103.81,203.96)
8813PHASE2: length 1
  TOP w0.61: v3(106.38,197.16) 105.71,197.16 PC9020.1
  vias: v1(105.49,197.91)
8813PSI: length 4.6
  TOP w0.254: PR9018.2 PR9016.2 97.48,198.49 PR9022.2 98.62,197.89 99.24,197.89 PU9000.4
8813PVCC: length 4.8
  TOP w0.114: PR9001.2 105.74,199.39 v1(105.74,198.37)
  TOP w0.254: PR9001.2 104.97,199.09 104.93,199.09 PC9000.1 103.97,198.13 103.97,198.12 PU9000.21
8813REFADJ: length 1.8
  TOP w0.254: PU9000.6 98.8,196.91 98.11,196.91 PR9023.2
8813REFIN: length 6.8
  TOP w0.254: 95.08,195.46 95.08,196.41 PR9024.2 94.44,196.57 v1(94.42,196.54) ; 95.08,195.46 PR9027.1 ; 95.08,195.46 95.6,195.98 96.4,195.98 96.56,195.82 96.56,195.71 PC9026.1 98.01,195.45 98.24,195.22 98.95,195.22 PU9000.7
8813RGN: length 4.1
  TOP w0.203: PR9029.1 99.32,192.48 99.06,192.74 98.76,192.74 PC9029.1
  TOP w0.254: PC9029.1 98.64,193.21 PC9028.2 99.63,193.77 PU9000.10
8813TON: length 1.7
  TOP w0.203: PU9000.9 99.15,194 PR9002.1
8813UGATE1: length 3.2
  TOP w0.254: v3(100.28,199.06) 100.28,198.26 PU9000.2
  BOTTOM w0.61: PR9006.1 v1(99.47,199.06) v3(100.28,199.06)
8813UGATE1_1: length 2.8
  BOTTOM w0.61: PQ9000.1 96.65,200.81 v1(96.52,200.68) 96.52,200 96.88,199.64 96.88,199.37 PR9006.2
8813UGATE2: length 11.6
  IN4 w0.61: v3(104.47,194.81) 104.47,193.11 105.89,191.69 v3(112.75,191.69)
  BOTTOM w0.61: v3(112.75,191.69) 113.25,192.19 PR9014.1
8813UGATE2_1: length 1.7
  BOTTOM w0.61: PQ9001.1 113.22,190.62 PR9014.2
9336ADJ: length 3.4
  BOTTOM w0.508: PR9081.2 99.24,185.52 98.96,185.24 PR9082.2 98.92,184.91 99.29,184.91 99.59,184.6 99.99,184.6 PU9003.5
9336DRV: length 15.3
  IN2 w0.508: v1(93.38,193.04) 95.45,193.04 96.45,192.05 98.48,192.05 98.99,191.54 98.99,190.58 98.56,190.15 98.56,189.19 99,188.74 99.88,188.74 v1(100,188.87)
  BOTTOM w0.508: PQ9008.4 93.02,192.68 v1(93.38,193.04) ; PU9003.6 100.36,185.96 100.2,186.12 PR9080.1 100.2,187.68 PD9001.1 100.43,188.45 v1(100,188.87)
24780_ACDET: length 8.6
  TOP w0.254: v1(162.42,122.27) 162.79,121.9 PR9275.2 163.5,121.56 PR211.2 164.13,121.3 164.7,121.87 v1(164.7,122.12) 163.89,122.92 PR31.2
  BOTTOM w0.152: v1(162.42,122.27) 161.91,121.76 160.19,121.76 160.02,121.93 159.25,121.93 159.09,121.77 PU1.6
24780_ACDRV: length 4.5
  BOTTOM w0.152: PR29.2 161.47,122.79 160.46,122.79 160.21,122.54 159,122.54 158.29,121.84 PU1.4
24780_ACN: length 140.8
  TOP w0.114: v1(157.44,124.26) 157.61,124.43 v1(158.12,124.43) ; PR2.2 v1(77.27,199.77)
  IN3 w0.102: v1(77.27,199.77) 77.65,200.15 90.4,200.15 91.32,199.23 91.32,193.07 94.92,189.47 97.85,189.47 99.69,187.63 102.09,187.63 104.15,185.57 110.23,185.57 110.87,184.93 114.88,184.93 116.22,183.59 116.22,177.06 122.32,170.96 123.53,170.96 127.01,167.48 127.01,165.3 130.36,161.95 130.36,159.57 132.13,157.81 132.13,156.49 133,155.62 135.69,155.62 136.17,156.1 137.57,156.1 140.01,153.65 140.01,149.73 140.88,148.86 140.88,133.57 141.87,132.57 142.9,132.57 143.6,131.87 146.45,131.87 148.26,130.06 148.26,129.31 150.35,127.23 150.35,125.46 151.33,124.48 157.22,124.48 v1(157.44,124.26)
  BOTTOM w0.114: v1(157.44,124.26) 157.75,124.26 PC35.1
  BOTTOM w0.152: PC35.1 157.44,123.32 PC25.2 157.44,122.28 157.19,122.03 157.19,121.91 157.09,121.81 PU1.1
24780_ACP: length 146.2
  TOP w0.114: v1(160,125.04) 160,124.77 v1(160.33,124.45) ; PR1.2 v1(76.38,199.77)
  IN3 w0.102: v1(76.38,199.77) 76.81,199.34 77.45,199.34 78.03,199.92 90.31,199.92 91.1,199.13 91.1,192.97 94.83,189.24 97.76,189.24 99.6,187.39 102,187.39 104.06,185.34 110.14,185.34 110.77,184.71 114.78,184.71 115.99,183.5 115.99,176.97 122.22,170.73 123.44,170.73 126.78,167.39 126.78,165.21 130.13,161.85 130.13,159.48 131.9,157.71 131.9,156.39 132.9,155.39 135.79,155.39 136.26,155.87 137.47,155.87 139.78,153.56 139.78,149.64 140.65,148.77 140.65,133.47 141.78,132.34 142.8,132.34 143.5,131.65 146.36,131.65 148.04,129.97 148.04,129.21 150.12,127.13 150.12,125.37 151.24,124.25 156.84,124.25 157.26,123.83 159.71,123.83 v1(160.33,124.45)
  BOTTOM w0.114: PC36.2 159.06,123.98 159.86,123.98 160.32,124.45 v1(160.33,124.45)
  BOTTOM w0.152: PU1.2 157.49,121.9 158.22,122.63 PC25.1 158.22,123.14 PC36.2
24780_BATDRV: length 12
  TOP w0.381: v1(157.99,116.3) 157.44,115.75 154.69,115.75 153.61,114.66 150.94,114.66 v1(150.7,114.91) 150.7,114.93 149.66,115.97 PR4.2
  BOTTOM w0.152: PU1.18 158.29,116.6 v1(157.99,116.3)
24780_BATSRC: length 14.2
  TOP w0.381: v1(158.65,116.28) 158.65,116.06 157.7,115.11 155.01,115.11 154.04,114.13 150.23,114.13 v1(148.44,115.92) 148.23,116.14 PR7.2
  BOTTOM w0.152: v1(158.65,116.28) 158.69,116.32 PU1.17
24780_BM#: length 2.8
  BOTTOM w0.152: PU1.16 159.09,116.91 159.23,116.77 160.26,116.77 160.84,116.19 PR9.1
24780_BST: length 0.9
  TOP w0.508: v3(154.94,119.4) 154.84,119.5 PR11.1
24780_CMPIN: length 3.3
  TOP w0.152: PR207.1 161.8,118.61 v1(161.98,118.44) 161.98,118.26 161.84,118.12 v1(161.38,118.12)
  BOTTOM w0.152: PU1.13 160.95,118.55 v1(161.38,118.12)
24780_CMPOUT: length 5.1
  BOTTOM w0.114: PR15.1 163.79,115.85 v1(163.99,116.05)
  BOTTOM w0.152: PR15.1 162.12,116.55 162.12,117.26 161.71,117.67 161.06,117.67 160.59,118.15 PU1.14
24780_CMSRC: length 3.3
  BOTTOM w0.152: PR28.2 159.33,123.33 v1(159.08,123.09) 158.68,122.68 158.68,122.65 157.89,121.87 PU1.3
24780_DH: length 9
  TOP w0.114: v1(148.69,119.4) 148.4,119.4 v1(148.09,119.1)
  IN1 w0.508: v1(148.09,119.1) 152.82,119.1 153.94,120.21 v3(154.94,120.21)
  BOTTOM w0.381: 148.53,118.66 PQ30.4
  BOTTOM w0.508: v1(148.09,119.1) 148.53,118.66
24780_DL: length 5.7
  TOP w0.508: v3(155.4,118.18) v1(153.86,116.65) 153.58,116.36 153.58,115.69 153.19,115.3 v1(152,115.3)
  BOTTOM w0.508: PQ29.4 151.88,115.18 v1(152,115.3)
24780_ILIM: length 6
  BOTTOM w0.114: PR204.1 153.88,114.53 v1(153.88,113.48)
  BOTTOM w0.152: PU1.21 156.67,117.35 155.51,116.19 PC8.2 PR206.1 154.54,115.71 154.56,115.69 PR204.1
24780_LX: length 20.6
  TOP w0.114: v1(144.92,112.94) 144.92,112.48 v1(145.11,112.29)
  TOP w0.508: v3(155.43,120.85) 155.27,121.01 PC15.1
  IN1 w0.508: v1(144.92,112.94) 147.07,112.94 148.68,114.55 152.64,114.55 154.62,116.53 156.34,116.53 156.82,117.01 156.82,117.77 156.41,118.18 156.41,120.32 155.88,120.85 v3(155.43,120.85)
24780_SRN: length 24.7
  TOP w0.114: PR208.1 138.74,111.17 138.9,111.01 139.13,111.01 v1(139.42,110.72)
  BOTTOM w0.152: PC3.1 158.05,115.51 157.76,115.8 PR6.2 ; PC3.1 157.79,114.77 157.79,114.41 155.65,112.27 154.38,112.27 153.96,111.86 151.54,111.86 v1(151.08,111.4) 150.62,111.86 148.92,111.86 148.44,111.38 141.04,111.38 140.23,110.57 139.56,110.57 v1(139.42,110.72) ; PC3.1 PC4.2
24780_SRP: length 22.3
  TOP w0.114: PR210.2 139.68,111.43 v1(140.04,111.07)
  BOTTOM w0.152: v1(140.04,111.07) 140.29,111.07 140.91,111.69 148.31,111.69 148.79,112.16 150.58,112.16 v1(151.08,112.67) 151.59,112.16 153.84,112.16 154.25,112.58 155.53,112.58 157.49,114.54 157.49,114.82 PC3.2 PC6.2 156.44,115.15 PR5.2
24780_VCC:
  vias: v1(156.26,121.97)
+1.03_GFX: length 20.2
  TOP w0.305: v2(135.03,198.5) 135.28,198.24 C366.1
  TOP w0.381: C354.1 142.34,209.66 v1(142.02,209.98)
  IN2 w0.508: v1(95.1,198.35) 95.1,196.44 96.85,194.69 96.85,194.31 98.35,192.81 98.79,192.81 99.75,191.85 99.75,190.27 99.32,189.84 v1(99.32,189.51)
  BOTTOM w0.305: U8.AE26 140.42,202.27 v2(140.83,202.68) 141.22,202.29 U8.AE27 ; U8.AA22 136.73,198.5 v2(135.03,198.5) ; U8.AC24 138.82,200.67 v2(138.46,201.04) ; U8.AD25 v2(140.03,201.85) ; U8.AB23 v2(137.63,200.14)
  BOTTOM w0.508: v1(99.32,189.51) 99.24,189.43 PR9081.1
  vias: v1(94.34,199.06) v1(94.44,198.35) v1(95,199.06) v1(95.18,197.13) v1(142.12,210.66)
+601_VCC:
  vias: v1(225.56,113.56) v1(226.22,113.56) v1(232.49,117.12) v1(234.14,117.37) v1(235,117.07)
+AZA_VDD: length 12.8
  IN3 w0.508: v1(16.51,35.19) 16.51,34.75 16.88,34.39 22.51,34.39 23.56,35.44 v1(23.56,36.43) 24.6,36.43 v1(25.03,36)
  BOTTOM w0.203: v1(16.51,35.19) U20.36
  BOTTOM w0.254: R478.2 22.95,37.33 23.17,37.11 23.17,36.81 v1(23.56,36.43)
  vias: v1(25.78,40.23)
+CRT_VDDA33: length 22.8
  TOP w0.203: 26.78,153.42 27.33,152.88 U67.20
  TOP w0.254: 26.78,153.42 26.41,153.8 C20012.1 26.41,154.17 v1(26.05,154.53)
  TOP w0.508: R25533.1 31.32,145.56 30.28,146.6 v1(30.28,147) R1616.1 R458.1
  BOTTOM w0.508: v1(26.05,154.53) 28.59,151.99 28.59,150.61 29.35,149.85 29.35,147.92 v1(30.28,147) 32.77,149.48 v1(34.1,149.48)
  vias: v1(33.79,150.11)
+FB_PLLAVDD: length 32.6
  TOP w0.254: C455.2 132.51,186.72 v2(132.8,187.01)
  TOP w0.305: v2(137.6,187.79) 137.51,187.7 C453.2
  TOP w0.381: v2(135.92,192.65) 135.92,191.98 C454.2
  IN2 w0.508: v1(114.93,194.54) 116.31,194.54 117.41,193.44 117.41,191.42 119.96,188.87 125.06,188.87 125.58,188.36 126.64,188.36 127.37,189.08 127.93,189.08 129.43,187.58 132.07,187.58 ; 135.05,188.18 135.05,191.79 v2(135.92,192.65)
  BOTTOM w0.305: U8.P22 137.07,193.15 136.71,192.78 136.04,192.78 v2(135.92,192.65) ; U8.H22 137.2,188.19 v2(137.6,187.79)
  BOTTOM w0.381: v2(132.8,187.01) 132.75,186.96 132.72,186.96 132.25,186.49 U8.F16
  vias: v1(114.07,194.66)
+G_SEN_PW: length 28.9
  TOP w0.254: v1(145.7,211.79) 145.57,211.66 v1(145.57,211.1) 144.43,211.1 142.8,212.73 U6515.3 ; U6515.7 143.3,216.47 143.7,216.87 v1(143.7,217.21) ; R25621.2 139.55,214.65 139.8,214.9 U6515.11
  TOP w0.508: v1(141.08,217.2) 141.08,216.85 140.42,216.2 C20133.1 139.11,216.2 139.09,216.18 C20134.1 R25621.2
  IN4 w0.508: v1(143.7,217.21) 143.7,216.92 143.35,216.57 141.87,216.57 141.25,217.2 v1(141.08,217.2) 141.08,216.88 140.44,216.25 140.44,213.67 141.55,212.56 143.15,212.56 144.35,211.36 145.27,211.36 v1(145.7,211.79)
+MOD_VUP: length 7.4
  TOP w0.508: v1(61.29,98.07) 61.29,97.7 60.99,97.41 59.95,97.41 59.64,97.1 v1(58.85,97.1) 57.26,95.51 R67565.1
  BOTTOM w0.114: v1(61.29,98.07) 61.7,98.48 CN58.12
+PBA_PWR: length 7
  BOTTOM w0.508: R608.1 v1(105.03,107.36) 106.51,108.84 Q32.1 107.71,108.84 107.77,108.78 C749.2 109.02,108.78 109.66,108.15 R25295.1
+PBA_PWR_C: length 163.1
  TOP w0.508: v1(100.47,95.85) 100.47,96.26 100.04,96.69 v1(98.2,96.69) 96.75,95.25 94.67,95.25 94.33,94.91 v1(94.33,94.59)
  IN2 w0.508: v1(100.47,95.85) 100.51,95.8 104.04,95.8 105.13,96.9 117.55,96.9 117.9,96.54 121.18,96.54 121.62,96.98 138.06,96.98 138.43,96.62 150.09,96.62 150.83,95.88 152.86,95.88 153.58,95.17 179.58,95.17 181.99,97.58 182.86,97.58 183.75,96.69 192.74,96.69 193.52,97.48 194.89,97.48 196.5,95.86 205.33,95.86 209.21,99.74 v1(209.41,99.74)
  BOTTOM w0.254: CN52.1 210.35,100.03 210.07,99.74 v1(209.41,99.74)
  BOTTOM w0.305: CN14.8 73.45,98.98 73.3,98.83 73.3,98.56
  BOTTOM w0.508: v1(100.47,95.85) 100.65,96.03 100.65,99.27 99.5,100.42 99.5,101.4 98.88,102.02 98.88,104.56 99.65,105.33 99.65,106.71 99.97,107.03 R614.1 ; v1(94.33,94.59) 94.33,94.86 93.74,95.45 92.78,95.45 91.92,94.59 77.39,94.59 76.56,95.42 76.56,97.06 75.75,97.87 74.96,97.87 74.81,97.72 73.76,97.72 73.3,98.18 73.3,98.56
+PBA_PWR_R: length 5.7
  BOTTOM w0.508: Q32.3 v1(103.81,108.99) 104.05,108.75 R608.2 C753.2 C752.2 101.43,108.14 R614.2
+PSWOUT: length 23.9
  TOP w0.381: 222.24,98.73 222.09,98.73 221.54,98.18 U6509.11
  TOP w0.508: v1(222.52,99.42) 222.98,99.42 C20042.1 222.96,98.73 222.24,98.73 ; R25554.2 224.51,95.02 v1(224.79,94.73) ; v1(215.87,99.3) C20050.2 C20051.1 215.87,103.78 v1(215.95,103.87) F2.1
  IN4 w0.508: v1(215.87,99.3) 216.8,100.23 219.88,100.23 220.69,99.42 v1(222.52,99.42) 222.86,99.42 223.61,98.67 223.61,95.74 224.33,95.02 224.51,95.02 v1(224.79,94.73)
+SENSOR_POWER: length 160.3
  TOP w0.079: U6516.C2 154.87,213.39 154.87,212.62
  TOP w0.114: 154.87,212.29 154.87,212.62
  TOP w0.152: 155.06,212.1 154.87,212.29
  TOP w0.254: 155.06,212.1 155.48,211.68 v1(155.76,211.68)
  TOP w0.381: v1(114.83,199.39) v1(115.52,199.39) 116.05,198.86 116.05,198.8 118.71,196.14 v1(119.29,196.14) ; v1(158.3,214.48) 157.75,214.48 R25635.1 ; Q6567.2 150.38,215.81 150.37,215.8 v1(150.32,215.8) 150.27,215.8 150.26,215.81 Q6567.5 ; R25623.2 141.87,209.13 141.87,208.61 141.47,208.22 v1(141.47,207.43) ; v1(135.7,212.46) 135.61,212.37 132.76,212.37 132.31,212.82 Q6540.2 131.82,214.85 R25634.1 132.35,215.72 132.82,216.19 v1(132.82,217.2)
  TOP w0.508: v1(135.7,212.46) C20135.1 135.7,213.6 135.53,213.77 R25625.2 ; R25622.2 R25625.2 ; R25625.2 137.12,214.53 R25621.1
  IN1 w0.381: v1(132.82,217.2) 132.82,216.89 132.39,216.46 128.52,216.46 124.7,212.63 120.59,212.63 119.73,211.77 119.73,211.11 120.11,210.73 120.11,209.67 119.24,208.81 118.47,208.81 115.17,205.51 115.17,199.72 v1(114.83,199.39)
  IN2 w0.508: v1(148.23,210.35) 148.23,210.09 148.77,209.55 149.91,209.55 151.26,210.89 151.26,212.76 v1(150.5,213.52)
  IN3 w0.381: v1(119.29,196.14) 118.99,195.84 118.99,193.24 119.79,192.44 119.79,190.05 121.17,188.67 121.17,187.16 120.75,186.74 120.75,181.73 117.65,178.63 v1(117.65,177.2) ; v1(156.09,217.04) 156.09,217.01 158.3,214.8 v1(158.3,214.48) 157.68,214.48 157.02,213.83 157.02,212.94 v1(155.76,211.68)
  IN3 w0.508: v1(150.32,215.8) 150.32,215.61 150.5,215.43 v1(150.5,213.52) ; v1(135.7,212.46) 135.7,210.19 136.1,209.79 136.1,208.03 137.77,206.35 139.54,206.35 140.62,207.43 v1(141.47,207.43) 142.48,208.44 144.16,208.44 144.46,208.74 144.46,209.04 144.77,209.34 145.21,209.34 145.66,209.79 145.66,210.31 146.1,210.75 146.98,210.75 147.37,210.35 v1(148.23,210.35)
  BOTTOM w0.254: R25636.1 150.5,215.81 150.38,215.81 150.37,215.8 v1(150.32,215.8)
  BOTTOM w0.381: v1(156.09,217.04) 157.1,216.02 157.1,214.31 156.6,213.8 155.34,213.8 D13093.1 ; R25633.1 155.91,211.83 v1(155.76,211.68) ; R67877.2 150.29,213.31 v1(150.5,213.52) ; Q6569.2 100.94,181.76 101.24,181.46 101.26,181.46 101.27,181.46 101.27,181.46 101.91,181.46 102.15,181.23 103.23,181.23 103.39,181.06 Q6539.5 103.39,178.77 105.09,177.08 R25631.1 105.1,176.67 R25629.1 106.45,176.32 116.98,176.32 117.65,176.98 v1(117.65,177.2)
  BOTTOM w0.508: v1(155.76,211.68) 155.59,211.51 C20139.1 155.6,210.83 C20138.1 155.6,209.35 154.95,208.7 152.15,208.7 151.81,208.36 150.6,208.36 149.67,209.29 148.19,209.29 R67876.2 147.66,210.08 147.95,210.08 v1(148.23,210.35)
+SMDDR_VREF_DIMM: length 9
  TOP w0.508: 45.32,128.2 45.32,127.61 45.13,127.43 C265.1 R243.1 45.09,126.01 R241.2 45.09,124.09 44.68,123.68 R67574.1 43.77,123.33 v1(43.77,122.86) 44.16,122.47 R242.2
  BOTTOM w0.254: JDIM1.164 45.58,128.82 v1(45.99,129.24)
+SMDDR_VREF_DQ1_M1: length 19.2
  TOP w0.508: C20102.1 R25615.1 R25612.2 56.18,125.09 56.44,124.83 R67514.2 ; R67575.1 43.81,126.2 43.6,125.99 v1(43.29,125.99)
  IN3 w0.508: v1(43.29,125.99) 43.85,125.99 44.79,126.93 50.96,126.93 51.16,126.74 53.23,126.74 54.95,128.45 v1(54.95,128.77)
  BOTTOM w0.254: JDIM02.164 55,128.82 v1(54.95,128.77)
  vias: v1(55.65,128.62)
+TS_PWR:
  vias: v1(70.53,192.07) v1(70.51,191.23) v1(71.15,191.82)
+USBPWR1:
  vias: v1(16.36,111.19) v1(16.37,110.53) v1(17.03,111.21) v1(17.04,110.55) v1(17.01,109.87) v1(21.52,95.04) v3(20.86,95.61) v3(21.59,95.86)
+USBPWRD2:
  vias: v1(210.67,111.68) v1(210.85,114.53) v1(210.92,112.34) v1(211.33,111.68) v1(211.64,112.34) v1(218.73,105.07) v1(218.73,104.41) v1(218.73,103.75) v1(219.42,105.07) v1(219.42,104.41) v1(219.42,103.75) v1(226.91,124.66) v1(226.89,123.91) v1(227.5,124.97) v1(227.5,124.29) v1(227.49,123.63)
+VAC_IN: length 96.2
  TOP w0.254: PR8001.1 54.28,200.28 54.79,200.78 55.67,200.78 56.47,201.58
  TOP w0.508: v1(28.69,116.38) PD8002.2 29.68,113.61 PD8006.2
  IN3 w0.508: v1(39.48,191.65) 40.82,190.31 40.82,183.57 38.89,181.64 37.47,181.64 31.66,175.82 v1(28.44,175.82)
  IN4 w0.508: v1(28.69,116.38) 27.69,117.38 27.69,123.09 28.61,124.01 28.61,128.93 27.59,129.95 27.59,134.19 28.33,134.92 28.33,139.8 25.55,142.58 25.55,146.51 26.06,147.03 26.06,150.46 24.94,151.58 24.94,153.26 25.32,153.64 25.32,163.45 26.72,164.86 26.72,166.03 28.44,167.75 v1(28.44,175.82)
  vias: v1(12.3,196.65) v1(12.69,199.25) v1(12.82,198.57) v1(12.88,197.87) v1(12.87,197.16) v1(13.5,198.98) v1(57.61,199.23) v1(57.61,198.5) v1(58.32,199.26) v1(58.32,198.55) v1(59.03,199.26) v1(59.01,198.55) v1(59.06,196.52) v1(59.72,199.26) v1(59.72,198.57)
+VGPU_CORE: length 71
  TOP w0.356: v2(132.99,189.48) 133.26,189.74 C372.2 ; C369.2 130.7,189.74 v2(130.84,189.61) ; C407.2 129.45,190.02 v2(129.04,189.62)
  TOP w0.381: v1(116.51,197.44) 115.26,198.69 113.46,198.69 112.49,199.66 C422.2 112.05,200.29 v3(112.05,201.21) ; C406.2 126.77,189.6 v2(126.72,189.64)
  BOTTOM w0.254: U8.T16 132.52,195.07 132.14,194.69 v2(131.85,194.69) 131.85,194.48 U8.R15 131.52,194.15 131.27,193.89 v2(131.27,193.67) 131.04,193.67 130.52,193.15 U8.P14 130.07,192.69 v2(130.07,192.65) 130.02,192.65 129.52,192.15 U8.N13 129.34,192.15 v2(128.96,191.77) 128.52,191.33 U8.M12 128.44,191.15 127.96,190.67 v2(127.96,190.62) 127.91,190.62 127.52,190.23 U8.L11 127.26,190.15 126.8,189.68 126.78,189.68 126.74,189.64 v2(126.72,189.64) ; U8.M16 132.38,191.15 132.08,190.84 v2(132.08,190.77) ; v2(127,197.48) 126.67,197.15 U8.V10
  BOTTOM w0.305: v2(132.61,197.86) 132.52,197.77 U8.V16 v2(132.09,196.72) U8.U15 131.27,195.89 v2(131.27,195.65) 130.76,195.15 U8.T14 130.12,194.75 v2(130.12,194.55) 129.92,194.55 U8.R13 128.98,193.61 v2(128.98,193.59) 128.97,193.59 U8.P12 128.52,193.15 128.02,192.65 v2(127.97,192.65) 127.97,192.6 127.52,192.15 U8.N11 127.23,192.15 v2(126.75,191.66) 126.52,191.44 U8.M10 ; U8.K14 130.52,189.29 v2(130.84,189.61) 131.38,190.15 U8.L15 132.08,190.71 v2(132.08,190.77) ; v2(133.88,188.72) 134.31,189.15 U8.K18 ; v2(133.86,197.58) 134.11,197.58 134.52,197.17 U8.V18 ; U8.M16 132.58,191.15 v2(133.1,191.66) 133.15,191.66 133.52,192.04 U8.N17 134.03,192.65 v2(134.31,192.65) 134.31,192.94 U8.P18 ; v2(130.07,197.61) 130.52,197.16 U8.V14 v2(130.02,196.64) U8.U13 129.52,196.04 129.18,195.7 129.16,195.7 v2(128.93,195.7) 128.93,195.45 128.63,195.15 U8.T12 128.02,194.65 v2(127.92,194.65) 127.52,194.25 U8.R11 127.22,194.15 v2(126.72,193.65) 126.52,193.44 U8.P10 ; U8.V12 v2(128.02,196.65) U8.U11 127.25,196.15 v2(126.79,195.68) 126.79,195.41 U8.T10 125.6,195.15 v2(125.53,195.22) ; v2(133.04,195.4) 133.52,195.87 U8.U17 ; U8.K16 132.66,189.15 v2(132.99,189.48) 132.99,189.62 U8.L17 v2(134.13,190.76) U8.M18 ; U8.T18 134.31,194.94 v2(134.31,194.64) 134.01,194.64 133.76,194.39 133.76,194.39 U8.R17 133.05,193.68 v2(133.05,193.48) 132.85,193.48 U8.P16 132.52,193.15 132.03,192.65 v2(131.98,192.65) 131.98,192.61 U8.N15 131.52,192.15 131.27,191.89 v2(131.27,191.64) 131.01,191.64 U8.M14 130.38,191.15 v2(130.08,190.84) 130.08,190.7 U8.L13 129.52,190.12 129.04,189.65 v2(129.04,189.62) 129.02,189.62 128.55,189.15 U8.K12
  BOTTOM w0.356: v2(126.72,189.64) 126.52,189.44 U8.K10
  BOTTOM w0.381: PR9026.1 114.88,188.68 114.88,193.45 115.62,194.19 115.62,194.86 115.07,195.41 115.07,197.02 115.49,197.44 v1(116.51,197.44)
  vias: v1(113.31,206.65) v1(125.53,194.51) v1(130.44,206.69) v1(130.72,205.48) v1(130.72,204.72) v1(131.1,206.69) v1(131.48,205.48) v1(131.48,204.72) v1(131.76,206.69) v1(132.27,205.48) v1(132.27,204.72) v1(132.83,215.33) v1(133.02,205.48) v1(133.02,204.72) v1(133.5,215.33) v1(133.78,205.48) v1(133.76,204.77) v1(134.24,217.21) v1(134.16,215.34) v1(134.48,205.48) v1(134.45,204.77) v1(134.82,215.34) v1(134.9,217.21) v1(135.17,209.38) v1(135.18,208.21) v1(135.16,206.85) v1(135.56,217.21) v1(136.22,217.21) v1(136.41,212.53) v1(136.54,213.2) v1(137.07,212.55) v1(137.55,217.21) v1(138.21,217.21) v1(138.87,217.21) v1(139.23,208.23) v1(139.33,213.19) v1(139.33,212.53) v1(139.99,213.19) v1(139.99,212.53) v2(124.64,206.18) v2(125.98,201.82) v2(126.05,205.42) v3(109.58,212.32) v3(110.34,212.34) v3(110.34,211.58) v3(110.34,210.82) v3(110.37,216.15) v3(110.37,215.39) v3(110.37,213.1) v3(110.37,208.53) v3(110.37,207.77) v3(110.37,207.01) v3(110.37,206.24) v3(110.76,216.84) v3(111.13,216.15) v3(111.13,215.39) v3(111.13,214.63) v3(111.13,213.86) v3(111.13,213.1) v3(111.1,212.34) v3(111.1,211.58) v3(111.1,210.82) v3(111.1,210.05) v3(111.13,209.29) v3(111.13,208.53) v3(111.13,207.77) v3(111.13,207.01) v3(111.13,206.24) v3(111.28,201.98) v3(111.26,201.21) v3(111.44,205.51) v3(111.89,216.15) v3(111.89,215.39) v3(111.89,214.63) v3(111.86,210.82) v3(111.86,210.05) v3(111.89,209.29) v3(111.89,208.53) v3(111.89,207.77) v3(111.89,207.01) v3(111.89,206.24) v3(112.05,201.98) v3(112.65,209.29) v3(112.65,208.53) v3(112.68,205.89) v3(113.94,205.63) v3(113.91,204.84)
