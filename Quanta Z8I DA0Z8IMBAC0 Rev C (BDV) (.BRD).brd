# Allegro board Quanta Z8I DA0Z8IMBAC0 Rev C (BDV) (.BRD).brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI1_SI_TPM: length 1.6
  TOP w0.114: R597.2 85.08,97.81 U33.21
PCH_SPI1_SO: length 117.9
  TOP w0.114: v1(87.8,104.13) 87.39,104.55 86.14,104.55 85.91,104.32 85.91,103.9 85.62,103.6 84.52,103.6 83.94,103.02 81.86,103.02 81.39,102.55 80.48,102.55 79.48,101.55 79.48,98.84 79.57,98.75 79.57,96.4 81.05,94.93 81.74,94.93 81.94,95.13 R583.1 R598.1
  IN1 w0.089: v1(87.8,104.13) 87.49,103.83 87.49,102.7 90.54,99.65 96.06,99.65 99.17,102.76 104.36,102.76 104.73,102.39 109.49,102.39 110.04,102.94 116.49,102.94 117.92,101.51 117.92,101.13 119.2,99.86 134.35,99.86 134.66,99.55 v1(134.66,99.19)
  BOTTOM w0.079: U1.CF37 100.13,126.35 99.27,126.35 99.13,126.21 98.14,126.21 97.39,125.46 95.34,125.46 95.12,125.24 95.02,125.24
  BOTTOM w0.114: R108.2 135.65,108.4 136.34,107.71 136.34,106.16 137.24,105.25 137.24,101.47 136.55,100.78 136.26,100.78 v1(134.66,99.19) ; v1(87.8,104.13) 87.8,104.59 88.24,105.03 88.24,109.07 88.07,109.25 86.93,109.25 86.82,109.35 86.82,109.62 86.97,109.76 88.02,109.76 88.24,109.99 88.24,110.96 88.37,111.09 88.37,116.87 88.89,117.39 88.89,120.02 94.11,125.24 95.02,125.24
PCH_SPI1_SO_R: length 51.8
  TOP w0.114: v1(162.72,108.43) 162.72,109.42 162.96,109.66 U37.103 162.96,112.11 163.23,112.38 163.9,112.38 164.42,112.9 R25316.1
  IN3 w0.102: v1(132.53,107.21) 133.38,107.21 133.48,107.11 133.48,106.82 133.38,106.72 132.65,106.72 132.53,106.6 132.53,106.38 132.68,106.23 136.89,106.23 138.43,104.69 139.18,104.69 139.42,104.44 148.68,104.44 149.35,105.11 150.18,105.11 151.84,106.77 151.84,109.11 152.19,109.45 159.11,109.45 160.61,107.95 162.23,107.95 v1(162.72,108.43)
  BOTTOM w0.114: v1(132.53,107.21) 132.53,107.7 132.71,107.88 133.81,107.88 134.28,108.35 R108.1 134.2,108.48 132.69,108.48 TP17.1 131.42,107.67 130.99,108.1 CN59.2 U6528.2 CN60.2 U6526.2
PCH_SPI1_SO_TPM: length 1.9
  TOP w0.114: R598.2 84.07,95.53 84.86,96.32 U33.24
PCH_SPI_CS0#: length 96.4
  IN1 w0.089: v1(135.4,99.22) 134.99,99.63 134.89,99.63 134.44,100.07 119.29,100.07 118.14,101.22 118.14,101.6 116.58,103.16 109.95,103.16 109.4,102.61 104.82,102.61 104.45,102.97 99.08,102.97 96.12,100.02 91.88,100.02 v1(88.86,103.04)
  BOTTOM w0.079: U1.CG36 99.97,125.8 99.54,125.37 99.17,125.37 97.82,124.02 97.82,123.71 97.21,123.11 95.02,123.11
  BOTTOM w0.114: R106.2 133.04,108.9 135.49,108.9 136.58,107.81 136.58,106.26 137.48,105.35 137.48,101.37 135.4,99.3 v1(135.4,99.22) ; 95.02,123.11 93.38,123.11 90.99,120.73 90.99,117.48 89.34,115.83 89.34,114.96 88.61,114.23 88.61,111.34 89.24,110.71 89.24,109.93 88.59,109.27 88.59,104.69 88.94,104.35 88.94,103.11 v1(88.86,103.04)
PCH_SPI_CS0#_R: length 51.3
  TOP w0.114: v1(164.04,108.43) 164.04,109.43 163.76,109.7 U37.101
  IN3 w0.102: v1(164.04,108.43) 163.24,107.63 160.6,107.63 159.01,109.22 152.28,109.22 152.07,109.01 152.07,106.68 150.28,104.88 149.45,104.88 148.78,104.21 139.33,104.21 139.09,104.45 138.35,104.45 136.8,106 130.55,106 130.37,106.19 130.37,106.65 130.49,106.77 131.78,106.77 131.93,106.92 131.93,108.77 v1(131.99,108.82)
  BOTTOM w0.114: v1(131.99,108.82) 132.5,109.34 132.56,109.34 132.95,109.72 R106.1 132.04,109.77 TP14.1 131.4,109.68 131.09,109.37 CN59.1 U6528.1 CN60.1 U6526.1
PCH_SPI_IO2: length 74
  IN1 w0.089: v1(116.8,101.22) 116.54,101.48 116.54,102 116.03,102.51 110.22,102.51 109.67,101.96 104.55,101.96 104.18,102.33 99.35,102.33 96.24,99.22 90.36,99.22 86.9,102.68 86.9,103.54 v1(86.39,104.05)
  BOTTOM w0.079: 95.01,125.79 97.25,125.79 98,126.54 98.99,126.54 99.13,126.69 99.81,126.69 100.02,126.9 100.29,126.9 100.73,126.73 101.9,126.73 U1.CF34
  BOTTOM w0.114: v1(116.8,101.22) 117.53,100.49 117.53,100.17 117.63,100.07 118.7,99 R220.1 119.56,99 120.05,98.51 R110.1 ; v1(86.39,104.05) 86.13,104.31 86.13,109.6 86.75,110.22 86.75,113.13 87.84,114.23 87.84,117.03 88.41,117.59 88.41,120.22 93.97,125.79 95.01,125.79
PCH_SPI_IO3: length 79
  IN4 w0.089: v2(99.42,125.75) 99.42,124.96 97.83,123.37 97.83,123.04 96.7,121.92 96.7,120.28 95.47,119.05 95.47,116.48 94.4,115.41 94.4,113 96.27,111.13 100.93,111.13 102.1,109.97 103.3,109.97 103.95,109.31 105.44,109.31 106.33,108.42 107.77,108.42 110.05,106.14 110.39,106.14 111.15,105.38 111.15,104.19 110.82,103.86 v1(110.82,100.91)
  BOTTOM w0.079: U1.CG34 101.6,126.06 101.11,126.06 100.98,126.03 100.74,126.03 100.68,126.06 100.45,126.06 100.34,126.01 99.68,126.01 v2(99.42,125.75)
  BOTTOM w0.114: R109.1 116.1,106.21 115.84,105.96 115.84,104.85 115.1,104.1 115.1,96.77 114.96,96.64 114.49,96.64 114.38,96.75 114.38,99.56 114.18,99.76 113.83,99.76 113.71,99.64 113.71,96.81 113.6,96.7 113.15,96.7 113.04,96.81 113.04,99.72 112.95,99.8 112.5,99.8 112.37,99.68 112.37,96.81 112.29,96.73 111.87,96.73 111.74,96.85 111.74,99.49 111.64,99.59 111.15,99.59 111.04,99.48 111.04,96.85 110.92,96.73 110.34,96.73 110.22,96.85 110.22,100.72 110.41,100.91 v1(110.82,100.91)
PCH_SUSPWRDNACK: length 132.6
  TOP w0.114: v1(73.49,93.34) 72.7,94.13 72.7,97.08 73.31,97.69 73.31,99.15 74.12,99.96 74.12,104.01 76.55,106.44 76.55,116.32 76.85,116.63 76.85,119.15 76.65,119.35 76.65,122.12 78.38,123.86 v1(79,123.86) R39.2 ; v1(151.44,96.57) 151.98,96.57 154.07,98.66 154.6,98.66 154.88,98.94 154.88,101.25 154.18,101.95 154.18,103.08 154.78,103.68 154.78,104.16 154.49,104.44 153.47,104.44 153.19,104.16 153.19,103.78 152.91,103.5 152.5,103.5 152.07,103.94 U37.15
  IN1 w0.089: v1(151.44,96.57) 150.58,96.57 150.28,96.87 139.07,96.87 138.38,97.56 134.05,97.56 132.98,98.62 114.86,98.62 113.78,97.54 108.53,97.54 106.7,95.71 102.54,95.71 101.42,96.83 98.61,96.83 98.2,96.42 92.99,96.42 92.3,95.74 78.03,95.74 77.49,96.28 75.64,96.28 75.03,95.67 74.63,95.67 73.49,94.53 v1(73.49,93.34)
PCIE_CLKREQ_LAN#: length 166.3
  TOP w0.102: 100.74,124.42 100.74,125.09 101.53,125.87 102.3,125.87 102.68,126.26 104.43,126.26 v2(104.82,126.64)
  TOP w0.114: v1(27.92,158.87) 27.65,158.87 Q6531.3 24.56,159.66 R25444.1 R25446.1 ; v1(74.65,94.95) 74.6,95 v1(74.6,95.68) 74.61,95.68 74.61,97.7 75.03,98.12 75.03,99.23 75.28,99.48 75.28,103.52 76.32,104.56 77.24,104.56 78.94,106.27 78.94,106.46 79.58,107.09 79.58,108.19 78.72,109.05 78.72,114.84 82.69,118.82 86.91,118.82 87.21,119.11 88.22,119.11 89,119.89 R155.1 90.73,119.89 92.57,121.72 92.84,121.72 93.83,122.71 95.8,122.71 96.26,123.18 96.26,123.73 96.44,123.91 98.04,123.91 98.81,123.14 99.46,123.14 100.74,124.42
  IN4 w0.089: v1(27.92,158.87) 27.92,158.88 29.14,158.88 32.02,156 32.02,151.42 30.84,150.24 30.84,146.22 30.24,145.63 30.24,129.99 30.78,129.45 30.78,123.94 32.53,122.19 32.53,114.77 35.04,112.26 35.04,110.62 35.47,110.19 35.47,102.35 38.07,99.75 42.89,99.75 43.52,100.38 48.85,100.38 54.14,95.09 56.57,95.09 57.79,93.88 67.91,93.88 68.99,94.95 v1(74.65,94.95)
  BOTTOM w0.079: v2(104.82,126.64) 104.53,126.93 U1.CE30
PCIE_CLKREQ_SSD#: length 151.2
  TOP w0.102: 100.74,125.47 101.44,126.18 102.13,126.18 102.66,126.7 v2(102.82,126.7)
  TOP w0.114: 100.74,125.47 99.23,123.96 98.81,123.96 98.65,124.13 96.35,124.13 96.05,123.82 96.05,123.27 95.71,122.93 93.59,122.93 92.8,122.14 92.4,122.14 90.59,120.34 88.86,120.34 88.05,119.53 87.03,119.53 86.74,119.24 82.92,119.24 R159.1 82.68,119.39 78.3,115.01 78.3,108.88 79.16,108.02 79.16,107.26 78.53,106.63 78.53,106.44 77.07,104.98 76.15,104.98 74.87,103.7 74.87,99.65 74.61,99.4 74.61,98.3 74.19,97.87 74.19,96.18 74.02,96.01 74.02,93.27 v1(75.34,91.94) 75.92,91.36 v1(75.92,91.34)
  IN4 w0.089: v1(25.88,71.32) 25.88,71.33 25.88,77.31 24.88,78.32 24.88,84 23.25,85.63 23.25,87.6 22.27,88.58 22.27,90.98 22.2,91.04 22.2,94.62 22.93,95.35 22.93,95.98 24.16,97.21 24.79,97.21 26.52,98.94 31.79,98.94 31.94,99.09 33.08,99.09 36.53,95.64 44.79,95.64 44.91,95.51 48.25,95.51 48.95,94.81 48.95,91.27 49.77,90.45 75.02,90.45 v1(75.92,91.34)
  BOTTOM w0.079: U1.CE32 103.13,127.02 v2(102.82,126.7)
  BOTTOM w0.114: v1(25.88,71.32) 25.38,70.82 22.1,70.82 21.1,71.82 CN16.52
PCIE_CLKREQ_VGA#: length 92.7
  TOP w0.102: 100.79,124.16 101.08,124.45 101.08,124.9 101.86,125.68 102.38,125.68 102.76,126.07 103.32,126.07 103.58,125.8 v2(103.58,125.67)
  TOP w0.114: 100.79,124.16 99.55,122.92 96.31,122.92 95.83,122.44 94.03,122.44 92.9,121.3 92.74,121.3 90.93,119.49 90.46,119.49 88.73,117.76 R25493.1
  IN4 w0.089: v1(109.08,178.38) 109.08,175.05 107.56,173.54 107.56,171.44 108.44,170.56 108.44,167.17 107.42,166.15 107.42,152.04 109.28,150.17 109.28,138.26 108.74,137.71 108.1,137.71 107.75,137.36 107.75,135.46 106.58,134.29 105.56,134.29 104.6,133.32 103.96,133.32 103.53,132.89 103.35,132.89 102.82,132.37 102.82,132.17 102.21,131.56 102.21,129.97 102.26,129.92 102.26,129.59 102.13,129.46 102.13,127.48 102.26,127.35 102.26,126.54 102.64,126.16 103.17,126.16 103.58,125.74 v2(103.58,125.67)
  BOTTOM w0.079: U1.CF32 103.24,126.1 103.58,125.76 v2(103.58,125.67)
  BOTTOM w0.114: v1(109.08,178.38) 109.16,178.38 110.31,179.53 110.31,180.66 112.46,182.81 112.46,185.46 v1(112.37,185.54) 112.37,186.16 112.67,186.46 112.67,186.85 111.97,187.55 Q9.3 112.19,187.95 112.38,187.95 112.7,188.28 R25487.1
PCIE_CLKREQ_WLAN#: length 127.4
  TOP w0.079: v2(104.17,125.67) 104.17,125.37 104.06,125.26 102.41,125.26 102.41,125.26
  TOP w0.102: 102.41,125.26 101.75,125.26 101.36,124.87 101.36,124.3 100.94,123.88
  TOP w0.114: 100.94,123.88 99.76,122.7 96.4,122.7 95.71,122.02 94.05,122.02 91.08,119.05 90.61,119.05 88.83,117.27 87.57,117.27 v1(87.36,117.48) R154.1 ; v1(186.45,111.9) 186.03,111.9 Q63.3
  IN4 w0.089: v2(104.17,125.67) 104.55,126.06 107.2,126.06 107.4,125.85 107.4,124.29 107.43,124.26 108.04,124.26 110.24,122.06 111.6,122.06 112.82,120.84 115.92,120.84 116.55,120.21 116.85,120.21 117.27,119.8 117.27,117.57 117.39,117.45 117.39,115.39 118.34,114.44 118.34,112.89 119.43,111.8 119.9,111.8 120.87,110.83 120.87,109.5 122.8,107.56 124.35,107.56 124.84,107.08 128.15,107.08 131.46,103.77 131.85,103.77 133.36,102.26 135.79,102.26 135.89,102.36 136.96,102.36 137.51,101.81 141.46,101.81 142.01,101.26 144.6,101.26 144.81,101.46 147.38,101.46 147.7,101.14 150.91,101.14 151.52,101.74 155.15,101.74 156.06,100.83 165.7,100.83 167.65,102.78 169.22,102.78 169.75,102.25 170.85,102.25 172.09,103.48 178.87,103.48 184.79,109.4 184.79,110.24 v1(186.45,111.9)
  BOTTOM w0.079: v2(104.17,125.67) 104.15,125.7 104.15,125.84 U1.CF31
PCIE_RCOMP: length 2
  TOP w0.102: R139.2 120.07,125.9 120.03,125.9 119.64,125.9 v2(119.15,126.4)
  BOTTOM w0.079: U1.CE6 119.17,126.45 119.17,126.42 v2(119.15,126.4)
PCIE_RCOMP_P: length 2
  TOP w0.102: v2(119.76,126.39) 119.76,126.23 119.89,126.11 120.45,126.11 120.73,125.83 R139.1
  BOTTOM w0.079: v2(119.76,126.39) 119.79,126.39 119.81,126.41 119.81,126.44 U1.CE5
PCIE_REQ_LAN#_R: length 11.1
  TOP w0.114: R25445.1 28.49,160.98 Q6531.1 28.05,160.61 27.61,161.05 24.81,161.05 24.63,161.23 23.84,161.23 R25446.2 23.3,160.98 22.9,161.38 22.9,162.04 23.02,162.15 v1(23.02,162.4) 22.76,162.4 22.53,162.18 22.29,162.18 22.19,162.28 U6521.48
PCIE_RXN9_LAN: length 166.3
  TOP w0.102: v1(18.08,159.37) 18.01,159.37 17.71,159.67 17.71,160.48 17.84,160.6 18.03,160.6 C96306.2
  IN1 w0.102: v2(120.34,133.71) 120.22,133.58 120.22,133.51 120.43,133.3 120.92,133.3 120.98,133.24 121.79,133.24 123.56,135.01 124.72,135.01 125.05,135.34 126,135.34 126.94,136.27 126.94,139.25 126.1,140.09 122.88,140.09 122.31,140.66 122.31,141.38 120.04,143.65 120.04,145.09 120.62,145.67 120.62,146.16 120.78,146.32 120.78,151.02 120.88,151.13 120.88,152.53 120.78,152.64 120.78,155.88 120.88,155.98 120.88,157.11 120.79,157.2 120.79,158.48 120.95,158.64 120.95,160.16 120.03,161.08 118.39,161.08 117.75,161.72 117.75,166.18 117.15,166.79 117.02,166.79 116.11,167.7 112.68,167.7 108.34,172.04 106.33,172.04 102.97,168.68 72.25,168.68 65.53,175.4 63.37,175.4 62.42,176.35 58.83,176.35 57.7,175.22 50.93,175.22 50.42,175.73 44.7,175.73 38.74,169.76 38.74,168.45 37.88,167.59 37.88,166.7 35.18,164 35.18,163.41 34.39,162.62 32.02,162.62 31.76,162.36 29.76,162.36 27.26,159.86 25.1,159.86 24.66,159.42 22.69,159.42 22.3,159.03 19.41,159.03 18.43,160.01 17.98,160.01 17.76,159.79 17.76,159.63 18.03,159.37 v1(18.08,159.37)
  BOTTOM w0.079: v2(120.34,133.71) 120.61,133.44 120.61,133.17 120.52,133.08 120.35,133.08 U1.BP5
PCIE_RXN10_WLAN: length 101.1
  IN4 w0.102: v2(119.85,134.72) 120.03,134.53 120.03,134.41 119.93,134.31 116.85,134.31 116.57,134.59 116.02,134.59 115.7,134.26 115.7,133.12 115.27,132.69 115.09,132.69 114.86,132.47 114.86,131.26 114.66,131.06 114.66,129.86 115.27,129.25 115.62,129.25 116.38,128.49 116.38,128.06 116.84,127.61 120.12,127.61 120.68,127.04 120.68,126.01 121.04,125.65 123.81,125.65 124.03,125.43 124.03,122.57 125.46,121.14 125.46,120.63 126.38,119.72 126.55,119.72 128.61,117.66 129.08,117.66 130.06,116.67 131.49,116.67 132.12,116.04 132.47,116.04 133.86,114.66 133.86,111.04 136.57,108.33 141.77,108.33 142.33,108.89 144.22,108.89 144.9,108.2 150.2,108.2 150.42,107.97 153.39,107.97 153.88,108.45 153.88,108.89 154.18,109.19 160.41,109.19 160.74,109.52 166.63,109.52 168.82,111.71 169.3,111.71 170.46,112.86 170.93,112.86 173.67,115.59 173.67,116.18 174.28,116.79 174.67,116.79 174.82,116.64 174.82,116.46 v1(174.57,116.21)
  BOTTOM w0.079: U1.BN6 119.85,134.51 v2(119.85,134.72)
  BOTTOM w0.102: CN17.43 183.11,113.15 182.96,113.3 182.47,113.3 182.12,112.95 180.84,112.95 180.06,113.73 179.22,113.73 177.69,115.25 175.25,115.25 174.84,115.66 174.84,115.94 v1(174.57,116.21)
PCIE_RXN13_SSD: length 137.9
  IN1 w0.102: v2(119.19,136.37) 119.31,136.37 119.42,136.48 119.42,136.62 119.27,136.77 114.27,136.77 111.71,134.21 111.71,129.64 111.33,129.25 111.07,129.25 110.17,128.35 110.17,127.28 109.76,126.87 108.68,126.87 107.87,126.06 101.01,126.06 99,124.04 93.96,124.04 87.63,117.72 87.02,117.72 85.5,116.2 81.3,116.2 80.08,114.98 79.02,114.98 77.03,112.99 75.93,112.99 70.32,107.38 70.32,105.87 65.09,100.65 63.46,100.65 62.66,99.85 56.72,99.85 55.89,99.02 51.58,99.02 50.85,99.76 45.06,99.76 44.49,100.34 41.23,100.34 40.92,100.02 30.8,100.02 30.7,99.92 30.7,99.65 v1(30.9,99.46)
  BOTTOM w0.079: v2(119.19,136.37) 119.19,135.94 119.27,135.87 119.35,135.87 U1.BK6
  BOTTOM w0.102: v1(30.9,99.46) 30.63,99.2 30.63,98.36 29.5,97.23 28.21,97.23 24.89,93.91 24.89,93.11 24.62,92.84 24.62,89.02 27.41,86.23 27.93,86.23 28.41,85.74 32.43,85.74 33.72,84.45 33.72,82.86 33.78,82.8 R2652.1
PCIE_RXN13_SSD_C: length 3
  BOTTOM w0.102: R2652.2 33.82,82.09 33.82,81.74 33.5,81.42 32.79,81.42 32.7,81.33 32.7,81.22 32.85,81.07 CN16.5
PCIE_RXN14_SSD: length 136.4
  IN1 w0.102: v1(28.88,99.46) 28.61,99.46 28.52,99.56 28.52,99.76 28.72,99.97 29.02,99.97 29.8,100.75 35.18,100.75 36.04,101.61 36.89,101.61 37.49,101.01 44.68,101.01 45.32,100.37 51.28,100.37 52.01,99.64 55.64,99.64 56.47,100.46 62.41,100.46 63.52,101.57 65.16,101.57 69.71,106.12 69.71,107.63 75.78,113.71 76.62,113.71 78.68,115.77 80.01,115.77 81.05,116.81 85.2,116.81 86.75,118.35 87.41,118.35 94.63,125.57 97.66,125.57 98.31,126.23 100.12,126.23 101.58,127.68 103.84,127.68 103.98,127.82 108.66,127.82 109.39,128.55 109.39,133.14 109.96,133.71 109.96,134.08 110.89,135.01 110.89,135.39 113.3,137.8 118.71,137.8 118.86,137.64 119.05,137.64 119.15,137.54 v2(119.15,137.38)
  BOTTOM w0.079: v2(119.15,137.38) 119.17,137.37 119.17,136.87 119.25,136.79 119.36,136.79 U1.BJ6
  BOTTOM w0.102: v1(28.88,99.46) 28.68,99.46 28.57,99.36 28.57,98.46 24.26,94.15 24.26,93.44 24.01,93.18 24.01,88.77 27.16,85.61 27.61,85.61 28.45,84.77 29.49,84.77 29.88,84.38 29.88,83.79 30.2,83.47 30.2,82.85 30.28,82.77 R2654.1
PCIE_RXN14_SSD_C: length 2.4
  BOTTOM w0.102: CN16.17 29.85,81.07 29.7,81.22 29.7,81.3 30.27,81.87 30.27,82.04 R2654.2
PCIE_RXN15_SSD: length 145.7
  IN1 w0.102: v2(120.43,138.29) 120.43,138.45 120.01,138.87 119.02,138.87 118.85,139.03 113.65,139.03 113.33,138.7 113.02,138.7 110.03,135.72 110.03,135.31 109.14,134.42 109.14,134.11 108.96,133.92 107.5,133.92 107.11,133.53 107.11,132.45 107.28,132.28 107.28,131.6 106.47,130.79 101.01,130.79 97.13,126.91 94.81,126.91 87.07,119.17 85.83,119.17 84.37,117.71 80.79,117.71 79.74,116.65 78.32,116.65 76.2,114.52 75.45,114.52 68.88,107.96 68.88,106.5 64.77,102.39 63.19,102.39 62.07,101.28 54.18,101.28 53.71,101.75 52.62,101.75 52.15,101.28 45.56,101.28 44.54,102.3 43.49,102.3 43.15,102.64 35.59,102.64 35.01,102.06 31.72,102.06 31.27,101.6 29.93,101.6 29.64,101.9 28.33,101.9 27.9,101.47 26.19,101.47 25.61,100.88 25.61,99.39 22.32,96.1 22.32,94.93 21.68,94.29 21.68,93.05 19.48,90.85 19.48,88.01 19.25,87.78 19.25,85.03 22.11,82.17 25.52,82.17 26.88,83.52 26.99,83.52 v1(27.22,83.29)
  BOTTOM w0.079: U1.BG5 120.17,138.03 v2(120.43,138.29)
  BOTTOM w0.102: v1(27.22,83.29) 26.99,83.52 26.92,83.52 26.63,83.24 26.63,83.13 R2656.1
PCIE_RXN15_SSD_C: length 2.1
  BOTTOM w0.102: R2656.2 26.73,82.06 26.73,81.26 26.85,81.14 CN16.29
PCIE_RXN16_SSD: length 141.4
  IN1 w0.102: v2(120.42,139.29) 120.22,139.49 120.22,139.6 119.98,139.84 118.02,139.84 117.83,140.03 112.9,140.03 109.34,136.46 109.34,135.88 108.39,134.93 107.03,134.93 105.6,133.5 105.11,133.5 104.67,133.07 104.67,132.88 104.36,132.57 103.25,132.57 103.1,132.72 100.84,132.72 98.85,130.73 97.69,130.73 86.81,119.84 85.63,119.84 84.1,118.32 80.53,118.32 79.47,117.26 77.83,117.26 75.71,115.13 75.14,115.13 64.22,104.22 64.22,103.47 63.84,103.08 63.02,103.08 61.82,101.89 54.43,101.89 53.96,102.35 52.36,102.35 51.89,101.89 45.81,101.89 44.79,102.91 43.75,102.91 43.37,103.29 35.31,103.29 34.75,102.73 26.15,102.73 24.88,101.45 24.88,99.55 23.44,98.11 21.77,98.11 18.34,94.68 18.34,88.29 17.85,87.8 17.85,87.38 18.15,87.08 18.3,87.08 v1(18.53,86.85)
  BOTTOM w0.079: v2(120.42,139.29) 120.17,139.04 U1.BE5
  BOTTOM w0.102: v1(18.53,86.85) 18.78,87.1 19.2,87.1 19.36,87.26 20.69,87.26 21.66,86.28 21.66,84.37 22.21,83.82 22.21,83.1 R646.1
PCIE_RXN16_SSD_C: length 3.1
  BOTTOM w0.102: CN16.43 23.35,81.12 23.5,81.27 23.5,81.41 23.37,81.53 22.77,81.53 22.21,82.09 22.21,82.22 22.06,82.37 R646.2
PCIE_RXN_LAN_L: length 2.4
  TOP w0.102: C96306.1 17.81,161.6 17.81,161.73 17.91,161.83 18.27,161.83 18.49,162.05 18.49,162.28 18.59,162.38 U6521.39
PCIE_RXP9_LAN: length 166.3
  TOP w0.102: C96307.2 17.51,160.1 17.51,159.56 v1(17.32,159.37)
  IN1 w0.102: v2(119.76,133.71) 119.76,133.68 120.34,133.1 120.83,133.1 120.89,133.04 121.87,133.04 123.64,134.81 124.8,134.81 125.13,135.13 126.09,135.13 127.15,136.19 127.15,139.34 126.19,140.29 122.96,140.29 122.52,140.74 122.52,141.46 120.24,143.73 120.24,145 120.83,145.59 120.83,146.08 120.98,146.23 120.98,150.94 121.09,151.04 121.09,152.62 120.98,152.73 120.98,155.8 121.08,155.9 121.08,157.2 120.99,157.28 120.99,158.39 121.16,158.56 121.16,160.24 120.12,161.29 118.47,161.29 117.96,161.8 117.96,166.27 117.23,166.99 117.11,166.99 116.19,167.91 112.76,167.91 108.43,172.24 106.25,172.24 102.88,168.88 72.34,168.88 65.62,175.6 63.46,175.6 62.51,176.56 58.74,176.56 57.61,175.42 51.02,175.42 50.51,175.93 44.62,175.93 38.54,169.85 38.54,168.54 37.68,167.68 37.68,166.78 34.98,164.08 34.98,163.5 34.3,162.82 31.94,162.82 31.68,162.56 29.68,162.56 27.17,160.06 25.01,160.06 24.58,159.63 22.61,159.63 22.21,159.24 19.49,159.24 18.51,160.21 17.9,160.21 17.56,159.87 17.56,159.61 v1(17.32,159.37)
  BOTTOM w0.079: v2(119.76,133.71) 119.52,133.47 U1.BP6
PCIE_RXP10_WLAN: length 101.1
  IN4 w0.102: v1(175.33,116.21) 175.13,116.21 175.02,116.31 175.02,116.73 174.76,116.99 174.19,116.99 173.46,116.26 173.46,115.68 170.85,113.07 170.37,113.07 169.22,111.91 168.74,111.91 166.55,109.72 160.65,109.72 160.32,109.39 154.1,109.39 153.67,108.97 153.67,108.54 153.31,108.18 150.51,108.18 150.28,108.4 144.99,108.4 144.3,109.09 142.25,109.09 141.69,108.53 136.65,108.53 134.06,111.13 134.06,114.74 132.56,116.24 132.21,116.24 131.57,116.88 130.15,116.88 129.16,117.86 128.7,117.86 126.63,119.92 126.46,119.92 125.67,120.72 125.67,121.22 124.23,122.66 124.23,125.51 123.89,125.85 121.13,125.85 120.89,126.09 120.89,127.13 120.69,127.32 120.68,127.32 120.2,127.8 116.92,127.8 116.58,128.14 116.58,128.57 115.7,129.44 115.35,129.44 114.85,129.94 114.85,130.98 115.06,131.18 115.06,132.39 115.17,132.5 115.35,132.5 115.89,133.04 115.89,134.18 116.1,134.4 116.49,134.4 116.77,134.12 120,134.12 120.22,134.33 120.22,134.62 120.29,134.69 v2(120.45,134.69)
  BOTTOM w0.079: v2(120.45,134.69) 120.17,134.4 U1.BN5
  BOTTOM w0.102: CN17.41 183.04,113.65 182.89,113.5 182.38,113.5 182.04,113.15 180.92,113.15 180.14,113.93 179.3,113.93 177.77,115.46 175.33,115.46 175.04,115.75 175.04,116.1 175.15,116.21 v1(175.33,116.21)
PCIE_RXP13_SSD: length 137.9
  IN1 w0.102: v2(119.81,136.4) 119.63,136.58 119.63,136.7 119.35,136.98 114.19,136.98 111.51,134.29 111.51,129.72 111.24,129.46 110.99,129.46 109.97,128.44 109.97,127.36 109.68,127.07 108.59,127.07 107.79,126.26 100.93,126.26 98.92,124.25 93.87,124.25 87.55,117.92 86.93,117.92 85.42,116.41 81.22,116.41 80,115.19 78.94,115.19 76.95,113.2 75.84,113.2 70.11,107.47 70.11,105.95 65.01,100.85 63.37,100.85 62.58,100.06 56.64,100.06 55.81,99.23 51.67,99.23 50.93,99.96 45.15,99.96 44.57,100.54 41.15,100.54 40.83,100.23 30.72,100.23 30.5,100 30.5,99.74 v1(30.22,99.46)
  BOTTOM w0.079: v2(119.81,136.4) 120.17,136.04 U1.BK5
  BOTTOM w0.102: R2653.1 33.52,83 33.52,84.36 32.34,85.54 28.33,85.54 27.84,86.02 27.33,86.02 24.41,88.94 24.41,92.92 24.68,93.19 24.68,93.99 28.12,97.43 29.42,97.43 30.43,98.45 30.43,99.25 v1(30.22,99.46)
PCIE_RXP13_SSD_C: length 3
  BOTTOM w0.102: R2653.2 33.62,82.04 33.62,81.82 33.42,81.62 32.71,81.62 32.5,81.41 32.5,81.22 32.35,81.07 CN16.7
PCIE_RXP14_SSD: length 136.5
  IN1 w0.102: v2(119.84,137.37) 119.37,137.85 118.95,137.85 118.79,138 113.21,138 110.68,135.47 110.68,135.1 109.75,134.17 109.75,133.79 109.19,133.23 109.19,128.64 108.57,128.02 103.89,128.02 103.76,127.89 101.5,127.89 100.04,126.43 98.22,126.43 97.57,125.78 94.54,125.78 87.32,118.56 86.66,118.56 85.12,117.02 80.97,117.02 79.93,115.98 78.6,115.98 76.54,113.91 75.7,113.91 69.5,107.72 69.5,106.21 65.08,101.78 63.44,101.78 62.33,100.67 56.38,100.67 55.56,99.84 52.1,99.84 51.37,100.57 45.4,100.57 44.76,101.21 37.57,101.21 36.97,101.81 35.95,101.81 35.09,100.95 29.72,100.95 28.94,100.17 28.64,100.17 28.31,99.85 28.31,99.66 v1(28.12,99.46)
  BOTTOM w0.079: U1.BJ5 119.84,137.28 v2(119.84,137.37)
  BOTTOM w0.102: R2655.1 30,82.99 30,83.38 29.68,83.7 29.68,84.29 29.41,84.56 28.37,84.56 27.52,85.41 27.08,85.41 23.8,88.69 23.8,93.27 24.06,93.53 24.06,94.24 28.37,98.54 28.37,99.22 v1(28.12,99.46)
PCIE_RXP14_SSD_C: length 2.4
  BOTTOM w0.102: CN16.19 29.35,81.07 29.5,81.22 29.5,81.39 30.06,81.95 30.06,82.04 R2655.2
PCIE_RXP15_SSD: length 145.7
  IN1 w0.102: v1(27.22,84.06) 27.22,83.88 27.06,83.73 26.79,83.73 25.44,82.37 22.2,82.37 19.45,85.11 19.45,87.7 19.68,87.93 19.68,90.76 21.88,92.96 21.88,94.21 22.52,94.85 22.52,96.02 25.81,99.31 25.81,100.8 26.28,101.26 27.99,101.26 28.42,101.7 29.55,101.7 29.85,101.4 31.35,101.4 31.8,101.85 35.09,101.85 35.68,102.44 43.06,102.44 43.41,102.09 44.46,102.09 45.48,101.07 52.23,101.07 52.7,101.54 53.62,101.54 54.09,101.07 62.16,101.07 63.27,102.18 64.86,102.18 69.08,106.41 69.08,107.87 75.53,114.32 76.28,114.32 78.4,116.44 79.82,116.44 80.88,117.5 84.45,117.5 85.91,118.96 87.15,118.96 94.9,126.71 97.22,126.71 101.1,130.59 106.55,130.59 107.48,131.52 107.48,132.37 107.31,132.54 107.31,133.45 107.58,133.72 109.04,133.72 109.35,134.03 109.35,134.34 110.24,135.23 110.24,135.63 113.11,138.5 113.41,138.5 113.73,138.83 118.77,138.83 118.93,138.66 119.92,138.66 120.04,138.54 120.04,138.35 119.96,138.26 v2(119.83,138.26)
  BOTTOM w0.079: U1.BG6 119.52,137.83 119.6,137.74 119.79,137.74 119.86,137.82 119.86,138.24 v2(119.83,138.26)
  BOTTOM w0.102: R2657.1 26.43,82.95 26.43,83.32 26.84,83.73 27.06,83.73 27.22,83.89 v1(27.22,84.06)
PCIE_RXP15_SSD_C: length 2.1
  BOTTOM w0.102: R2657.2 26.52,82.05 26.52,81.27 26.35,81.1 CN16.31
PCIE_RXP16_SSD: length 141.4
  IN1 w0.102: v1(18.53,87.61) 18.53,87.36 18.46,87.29 18.23,87.29 18.05,87.46 18.05,87.71 18.55,88.2 18.55,94.6 21.86,97.91 23.53,97.91 25.09,99.47 25.09,101.37 26.24,102.52 34.83,102.52 35.39,103.08 43.28,103.08 43.66,102.7 44.71,102.7 45.73,101.68 51.98,101.68 52.45,102.15 53.88,102.15 54.35,101.68 61.91,101.68 63.1,102.88 63.92,102.88 64.43,103.38 64.43,104.13 75.22,114.93 75.79,114.93 77.91,117.05 79.56,117.05 80.61,118.11 84.19,118.11 85.72,119.64 86.89,119.64 97.78,130.53 98.94,130.53 100.93,132.52 103.01,132.52 103.17,132.36 104.45,132.36 104.88,132.79 104.88,132.98 105.19,133.3 105.68,133.3 107.11,134.72 108.47,134.72 109.54,135.79 109.54,136.38 112.99,139.82 117.75,139.82 117.93,139.64 119.9,139.64 120.02,139.51 120.02,139.44 v2(119.83,139.25)
  BOTTOM w0.079: U1.BE6 119.76,138.8 119.94,138.98 119.94,139.15 v2(119.83,139.25)
  BOTTOM w0.102: R647.1 22.53,82.82 22.42,82.94 22.42,83.91 21.87,84.46 21.87,86.36 20.77,87.46 19.28,87.46 19.12,87.3 18.61,87.3 18.53,87.39 v1(18.53,87.61)
PCIE_RXP16_SSD_C: length 3.2
  BOTTOM w0.102: R647.2 22.52,82.37 22.42,82.27 22.42,82.17 22.85,81.74 23.46,81.74 23.7,81.49 23.7,81.26 23.85,81.12 CN16.41
PCIE_RXP_LAN_L: length 2.4
  TOP w0.102: C96307.1 17.6,161.6 17.6,161.81 17.83,162.03 18.19,162.03 18.29,162.13 18.29,162.31 18.19,162.41 U6521.38
PCIE_TXN9_LAN: length 165
  TOP w0.102: v1(19.16,160.41) 19.39,160.64 19.6,160.64 19.88,160.91 19.88,161.58 19.69,161.76 19.69,162.29 19.79,162.39 U6521.42
  IN1 w0.102: v2(128.2,133.61) 128.01,133.81 128.01,140.08 122.96,145.12 122.96,158.81 123.09,158.94 123.09,161.34 121.59,162.83 121.59,164.14 120.19,165.54 120.19,166.87 119.02,168.03 119.02,168.63 117.29,170.36 117.29,171.3 114.95,173.64 110.12,173.64 109.18,174.58 108.46,174.58 108.06,174.18 105.39,174.18 102.68,171.46 99.91,171.46 99.22,170.77 73.11,170.77 65.8,178.09 64.93,178.09 63.84,179.18 60.46,179.18 60.27,179 59.33,179 59.14,179.18 57.41,179.18 55.53,177.3 51.79,177.3 51.16,177.94 43.87,177.94 35.63,169.71 35.05,169.71 34.45,169.11 34.45,167 33.58,166.13 29.66,166.13 28.15,164.62 26.49,164.62 24.56,162.68 18.73,162.68 18.29,162.25 18.29,160.93 18.59,160.63 18.93,160.63 v1(19.16,160.41)
  BOTTOM w0.102: C200.2 126.52,132.06 126.71,132.06 127.02,132.37 127.46,132.37 127.97,132.87 127.97,133.38 v2(128.2,133.61)
PCIE_TXN9_LAN_C: length 4.3
  BOTTOM w0.079: U1.BR2 122.49,133 122.55,132.94 122.55,132.86 122.79,132.63 123.13,132.63 123.3,132.8 124.87,132.8 125.57,132.1 125.71,132.1 C200.1
PCIE_TXN10_WLAN: length 95.7
  IN1 w0.102: v1(175.92,116.71) 176.16,116.47 176.16,116.06 175.24,115.13 173.08,115.13 170.9,112.95 169.79,112.95 169.31,113.43 166.11,113.43 165.35,112.67 160.68,112.67 159.97,111.96 156.76,111.96 156.66,112.06 156.66,113.59 156.44,113.82 155.85,113.82 155.6,113.57 155.6,112.15 155.4,111.96 155.06,111.96 154.91,112.1 154.91,113.05 154.65,113.31 154.06,113.31 153.8,113.05 153.8,112.19 153.6,111.99 150.94,111.99 149.74,110.79 140.69,110.79 140.18,110.29 137.21,110.29 135.49,112.01 135.49,112.91 132,116.39 132,117.38 132.28,117.66 132.28,118.59 132,118.87 132,123.29 130.2,125.09 130.2,127.23 132.68,129.71 132.87,129.71 133.35,130.2 133.35,131.06 132.75,131.66 132.75,133.2 132.25,133.7 131.05,133.7 130.91,133.84 130.91,134.17 130.96,134.22 130.96,134.26 v2(130.96,134.26)
  BOTTOM w0.079: 126.86,134.43 126.84,134.43 126.82,134.4 126.61,134.4 125.57,133.36 123.16,133.36 123.08,133.44 122.78,133.44 122.6,133.39 122.54,133.37 122.46,133.39 122.23,133.44 122.02,133.41 121.78,133.29 121.26,133.22 U1.BR4
  BOTTOM w0.102: v2(130.96,134.26) 130.86,134.26 130.76,134.36 130.76,134.46 130.38,134.84 129.72,134.84 129.31,134.43 126.86,134.43 ; C203.2 180.87,114 180.67,114 180.34,114.34 179.47,114.34 177.94,115.86 176.59,115.86 176.22,116.24 176.22,116.41 v1(175.92,116.71)
PCIE_TXN10_WLAN_C: length 2.9
  BOTTOM w0.102: C203.1 181.51,113.93 181.67,114.09 181.87,114.09 182.58,114.8 182.92,114.8 183.07,114.65 CN17.37
PCIE_TXN13_SSD: length 146.2
  IN1 w0.102: v1(30.62,84.71) 30.4,84.49 28.64,84.49 28.28,84.85 24.97,84.85 24.41,85.42 24.41,86.53 24.83,86.95 24.83,93.43 27.98,96.57 32.96,96.57 34.38,95.15 38.28,95.15 39.06,95.94 44.65,95.94 45.29,95.3 48.02,95.3 49.11,95.49 50.94,96.16 56.47,96.16 57.16,96.85 67.08,96.85 67.46,97.23 68.28,97.23 69.73,98.68 69.73,101.83 78,110.1 80.15,110.1 83.79,113.74 86.45,113.74 86.64,113.54 87.17,113.54 88.19,114.56 89.14,114.56 94.01,119.43 99.75,119.43 100.89,120.57 100.89,120.71 101.37,121.19 103.91,121.19 104.94,122.22 114.77,122.22 116.1,123.56 116.1,128.7 116.86,129.46 116.86,130.55 117.16,130.85 120.31,130.85 121.19,131.73 121.78,131.73 123.07,133.02 124.31,133.02 124.61,133.31 124.61,134.19 v2(124.79,134.36)
  BOTTOM w0.079: v2(124.79,134.36) 124.59,134.56 124.59,134.66 124.35,134.9 122.61,134.9 122.53,134.98 122.35,134.98 122.18,135.15 121.51,135.15 U1.BM4
  BOTTOM w0.102: v1(30.62,84.71) 30.77,84.56 31.49,84.56 32.12,83.93 32.12,83.37 C788.1
PCIE_TXN13_SSD_C: length 3.1
  BOTTOM w0.102: C788.2 32.03,82.45 32.03,81.93 31.73,81.63 31.39,81.63 31.2,81.44 31.2,81.26 31.35,81.11 CN16.11
PCIE_TXN14_SSD: length 145.9
  IN1 w0.102: v2(124.18,135.66) 124,135.83 124,136.07 123.75,136.32 122.7,136.32 120.67,134.29 117.6,134.29 116.69,133.38 116.69,132.25 115.69,131.26 115.69,129.84 114.87,129.01 114.87,123.48 114.43,123.04 104.43,123.04 103.53,122.14 100.74,122.14 100.03,121.43 99.68,121.43 98.79,120.55 98.25,120.55 97.62,121.18 96.83,121.18 96.32,120.67 94.1,120.67 89.38,115.95 88.26,115.95 87.11,114.8 86.45,114.8 86.21,114.56 83.45,114.56 79.89,110.99 77.74,110.99 68.9,102.16 68.9,100.8 68.25,100.15 68.25,98.35 67.94,98.04 67.13,98.04 66.75,97.66 56.83,97.66 56.13,96.97 50.32,96.97 50.1,96.75 48.48,96.75 47.85,96.12 45.64,96.12 45.01,96.75 38.68,96.75 37.89,95.97 34.74,95.97 33.31,97.39 27.64,97.39 23.91,93.66 23.91,90.91 22.71,89.71 22.71,86.99 22.95,86.75 22.95,86.02 22.77,85.85 v1(22.49,85.85)
  BOTTOM w0.079: v2(124.18,135.66) 124.04,135.52 124.04,135.47 123.73,135.16 122.5,135.16 U1.BL2
  BOTTOM w0.102: v1(22.49,85.85) 22.69,85.65 23.41,85.65 24.23,84.82 27.52,84.82 28.64,83.7 28.64,83.29 C790.1
PCIE_TXN14_SSD_C: length 2.6
  BOTTOM w0.102: C790.2 28.5,82.47 28.5,81.8 28.2,81.5 28.2,81.22 28.35,81.07 CN16.23
PCIE_TXN15_SSD: length 143.9
  IN1 w0.102: v2(123.73,136.73) 123.97,136.97 123.97,137.04 123.88,137.13 122.61,137.13 120.57,135.1 116.79,135.1 115.9,134.21 115.9,133.02 115.08,132.2 115.08,131.67 114.03,130.62 114.03,126.36 113.92,126.25 113.92,124.83 113.59,124.5 111.98,124.5 111.86,124.62 109.49,124.62 108.76,123.89 107.34,123.89 107.15,124.07 102.53,124.07 102.45,124 101.79,124 99.83,122.04 93.68,122.04 86.86,115.22 86.28,115.22 86.05,114.98 81.89,114.98 80.33,113.43 79.6,113.43 64.81,98.63 57.23,98.63 55.97,97.37 50.13,97.37 49.91,97.16 48.24,97.16 47.68,96.59 45.76,96.59 45.2,97.16 38.45,97.16 37.69,96.39 34.92,96.39 33.48,97.83 27.46,97.83 23.15,93.53 23.15,92.45 22.24,91.54 22.24,87.03 21.73,86.52 21.73,84.61 22.43,83.91 22.85,83.91 23.01,84.06 v1(23.01,84.25)
  BOTTOM w0.079: v2(123.73,136.73) 123.8,136.73 123.93,136.6 123.93,136.38 123.85,136.3 123.32,136.3 122.99,135.97 122.55,135.8 122.49,135.8 122.31,135.88 122.14,135.88 122.03,135.84 121.94,135.8 121.41,135.71 U1.BL4
  BOTTOM w0.102: C792.1 24.91,83.35 24.91,83.89 24.72,84.09 23.88,84.09 23.76,83.97 23.13,83.97 23.01,84.09 v1(23.01,84.25)
PCIE_TXN15_SSD_C: length 2.5
  BOTTOM w0.102: C792.2 24.94,82.34 24.94,81.89 25.2,81.63 25.2,81.22 25.35,81.07 CN16.35
PCIE_TXN16_SSD: length 149.4
  IN1 w0.102: v2(125.56,136.8) 125.78,137.03 125.78,137.13 125.15,137.76 122.37,137.76 120.32,135.71 114.91,135.71 114.3,135.1 114.3,134.42 113.38,133.5 113.38,131.72 113.49,131.62 113.49,126.67 113.08,126.26 111.7,126.26 111.42,126.54 110.83,126.54 110.5,126.21 109.88,126.21 109.33,125.66 109.33,125.33 108.53,124.53 107.91,124.53 107.37,125.07 101.66,125.07 99.24,122.65 93.43,122.65 87.82,117.05 87.24,117.05 85.78,115.59 81.55,115.59 80.26,114.3 79.31,114.3 77.36,112.35 76.14,112.35 70.94,107.14 70.94,105.63 65.19,99.88 63.76,99.88 63.12,99.24 56.97,99.24 56.14,98.41 50.26,98.41 49.61,97.77 38.25,97.77 36.7,99.32 32.39,99.32 31.81,98.73 26.17,98.73 23.22,95.78 23.22,94.68 22.54,94 22.54,92.7 20.48,90.64 20.48,87.55 20.11,87.18 20.11,85.9 20.24,85.77 20.49,85.77 20.56,85.84 v1(20.56,86.05)
  BOTTOM w0.079: v2(125.56,136.8) 125.22,137.15 123.42,137.15 123.33,137.06 123.33,136.56 123.1,136.33 122.79,136.33 122.78,136.32 122.76,136.32 122.67,136.36 122.41,136.36 122.38,136.34 122.16,136.3 122.03,136.34 121.95,136.38 121.28,136.5 U1.BJ4
  BOTTOM w0.102: v1(20.56,86.05) 20.56,85.88 20.66,85.79 20.75,85.79 20.81,85.72 20.99,85.72 21.23,85.48 21.23,84.4 20.64,83.81 20.64,83.43 20.77,83.31 C794.1
PCIE_TXN16_SSD_C: length 3.6
  BOTTOM w0.102: CN16.47 22.35,81.14 22.2,81.29 22.2,81.49 21.99,81.71 21.39,81.71 20.69,82.41 20.69,82.54 C794.2
PCIE_TXP9_LAN: length 165
  TOP w0.102: U6521.41 19.39,162.38 19.49,162.28 19.49,161.67 19.67,161.49 19.67,161 19.52,160.84 19.04,160.84 18.96,160.92 18.96,161.09 v1(19.15,161.28)
  IN1 w0.102: v2(127.44,133.61) 127.74,133.61 127.8,133.68 127.8,139.99 122.76,145.04 122.76,158.9 122.88,159.02 122.88,161.25 121.39,162.75 121.39,164.05 119.99,165.45 119.99,166.78 118.82,167.95 118.82,168.54 117.09,170.28 117.09,171.22 114.86,173.44 110.03,173.44 109.1,174.38 108.55,174.38 108.14,173.97 105.48,173.97 102.77,171.26 99.99,171.26 99.3,170.57 73.03,170.57 65.71,177.88 64.85,177.88 63.75,178.98 60.54,178.98 60.35,178.79 59.24,178.79 59.06,178.98 57.49,178.98 55.61,177.1 51.71,177.1 51.07,177.74 43.95,177.74 35.72,169.5 35.13,169.5 34.65,169.02 34.65,166.92 33.66,165.93 29.75,165.93 28.24,164.41 26.58,164.41 24.65,162.48 18.81,162.48 18.5,162.17 18.5,161.01 18.67,160.84 19.19,160.84 19.27,160.92 19.27,161.16 v1(19.15,161.28)
  BOTTOM w0.102: v2(127.44,133.61) 127.71,133.61 127.77,133.56 127.77,132.96 127.38,132.57 126.93,132.57 126.63,132.26 126.47,132.26 126.36,132.37 C201.2
PCIE_TXP9_LAN_C: length 4.3
  BOTTOM w0.079: U1.BR1 122.81,132.94 122.81,132.83 122.86,132.78 123.07,132.78 123.24,132.95 124.93,132.95 125.63,132.25 126.02,132.25 126.11,132.34 126.11,132.53 126.03,132.61 C201.1
PCIE_TXP10_WLAN: length 95.8
  IN1 w0.102: v1(176.72,116.71) 176.5,116.71 176.37,116.58 176.37,115.97 175.32,114.93 173.16,114.93 170.98,112.75 169.7,112.75 169.22,113.23 166.2,113.23 165.44,112.47 160.77,112.47 160.06,111.76 156.67,111.76 156.46,111.97 156.46,113.51 156.35,113.61 155.93,113.61 155.8,113.48 155.8,112.07 155.49,111.76 154.97,111.76 154.71,112.02 154.71,112.96 154.56,113.11 154.15,113.11 154,112.96 154,112.11 153.68,111.79 151.03,111.79 149.83,110.59 140.77,110.59 140.27,110.08 137.12,110.08 135.28,111.92 135.28,112.83 131.8,116.31 131.8,117.46 132.08,117.74 132.08,118.51 131.8,118.78 131.8,123.21 130,125.01 130,127.32 132.6,129.92 132.79,129.92 133.15,130.28 133.15,130.97 132.54,131.58 132.54,133.12 132.16,133.5 130.97,133.5 130.71,133.76 130.71,133.98 130.42,134.26 v2(130.33,134.26)
  BOTTOM w0.079: U1.BR3 121.83,133 121.87,133.04 121.87,133.13 121.9,133.16 122.07,133.25 122.22,133.27 122.43,133.22 122.53,133.2 122.55,133.2 122.84,133.28 123.01,133.28 123.09,133.21 125.63,133.21 126.67,134.25 126.82,134.25 126.84,134.22 126.86,134.22
  BOTTOM w0.102: C202.2 181.06,114.33 180.94,114.21 180.76,114.21 180.42,114.54 179.55,114.54 178.03,116.07 176.68,116.07 176.42,116.33 176.42,116.59 176.54,116.71 v1(176.72,116.71) ; v2(130.33,134.26) 130.4,134.26 130.49,134.35 130.49,134.44 130.29,134.64 129.81,134.64 129.39,134.22 126.86,134.22
PCIE_TXP10_WLAN_C: length 2.9
  BOTTOM w0.102: CN17.35 183.11,115.15 182.97,115 182.49,115 181.79,114.3 181.65,114.3 181.51,114.44 C202.1
PCIE_TXP13_SSD: length 146.1
  IN1 w0.102: v2(124.17,134.32) 124.36,134.32 124.41,134.27 124.41,133.4 124.23,133.22 122.98,133.22 121.7,131.93 121.1,131.93 120.22,131.05 117.08,131.05 116.66,130.63 116.66,129.54 115.9,128.78 115.9,123.64 114.68,122.42 104.85,122.42 103.82,121.4 101.29,121.4 100.69,120.8 100.69,120.66 99.67,119.63 93.92,119.63 89.05,114.76 88.1,114.76 87.09,113.75 86.73,113.75 86.53,113.95 83.7,113.95 80.06,110.31 77.92,110.31 69.53,101.92 69.53,98.76 68.2,97.43 67.38,97.43 67,97.05 57.08,97.05 56.39,96.36 50.9,96.36 49.06,95.69 48,95.5 45.37,95.5 44.73,96.14 38.98,96.14 38.19,95.36 34.46,95.36 33.05,96.77 27.89,96.77 24.63,93.51 24.63,87.04 24.2,86.61 24.2,85.33 24.89,84.65 28.2,84.65 28.55,84.29 30.54,84.29 30.66,84.17 30.66,83.99 v1(30.62,83.95)
  BOTTOM w0.079: U1.BM3 121.94,134.92 122.18,134.92 122.28,134.82 122.46,134.82 122.54,134.74 124.29,134.74 124.44,134.59 124.44,134.37 124.39,134.32 v2(124.17,134.32)
  BOTTOM w0.102: v1(30.62,83.95) 30.62,84.13 30.75,84.26 30.81,84.26 30.92,84.36 31.4,84.36 31.92,83.84 31.92,83.31 31.79,83.18 C789.1
PCIE_TXP13_SSD_C: length 3.1
  BOTTOM w0.102: C789.2 31.83,82.45 31.83,82.01 31.65,81.84 31.31,81.84 31,81.53 31,81.22 30.85,81.07 CN16.13
PCIE_TXP14_SSD: length 145.8
  IN1 w0.102: v2(123.53,135.68) 123.71,135.68 123.8,135.77 123.8,135.99 123.67,136.12 122.79,136.12 120.76,134.09 117.68,134.09 116.89,133.29 116.89,132.17 115.9,131.17 115.9,129.75 115.07,128.93 115.07,123.4 114.51,122.84 104.51,122.84 103.61,121.94 100.82,121.94 100.12,121.23 99.76,121.23 98.88,120.34 98.17,120.34 97.53,120.98 96.91,120.98 96.4,120.47 94.18,120.47 89.46,115.75 88.34,115.75 87.19,114.59 86.53,114.59 86.29,114.35 83.53,114.35 79.97,110.79 77.83,110.79 69.11,102.07 69.11,100.72 68.45,100.07 68.45,98.26 68.03,97.84 67.21,97.84 66.83,97.46 56.91,97.46 56.22,96.76 50.41,96.76 50.19,96.55 48.57,96.55 47.93,95.91 45.56,95.91 44.93,96.55 38.76,96.55 37.98,95.76 34.66,95.76 33.23,97.19 27.73,97.19 24.11,93.58 24.11,90.83 22.91,89.62 22.91,87.07 23.15,86.83 23.15,85.94 22.66,85.44 22.52,85.44 22.39,85.31 22.39,85.13 v1(22.49,85.03)
  BOTTOM w0.079: U1.BL1 122.86,135.4 122.94,135.32 123.66,135.32 123.83,135.49 123.83,135.62 123.72,135.73 123.59,135.73 v2(123.53,135.68)
  BOTTOM w0.102: C791.1 28.24,83.18 28.36,83.31 28.36,83.36 28.44,83.44 28.44,83.62 27.44,84.62 24.15,84.62 23.32,85.44 22.73,85.44 22.68,85.39 22.49,85.39 22.4,85.3 22.4,85.12 v1(22.49,85.03)
PCIE_TXP14_SSD_C: length 2.7
  BOTTOM w0.102: C791.2 28.3,82.42 28.3,81.88 28,81.58 28,81.22 27.85,81.07 CN16.25
PCIE_TXP15_SSD: length 143.9
  IN1 w0.102: v1(23.01,83.49) 22.79,83.71 22.35,83.71 21.53,84.53 21.53,86.6 22.04,87.11 22.04,91.63 22.95,92.53 22.95,93.61 27.37,98.04 33.56,98.04 35,96.6 37.6,96.6 38.37,97.36 45.29,97.36 45.85,96.8 47.6,96.8 48.16,97.36 49.83,97.36 50.05,97.58 55.88,97.58 57.14,98.84 64.72,98.84 79.51,113.63 80.25,113.63 81.8,115.18 85.96,115.18 86.2,115.42 86.77,115.42 93.6,122.25 99.75,122.25 101.7,124.2 102.37,124.2 102.44,124.28 107.24,124.28 107.42,124.09 108.67,124.09 109.41,124.82 111.94,124.82 112.06,124.7 113.5,124.7 113.72,124.91 113.72,126.34 113.82,126.44 113.82,130.71 114.88,131.76 114.88,132.28 115.7,133.1 115.7,134.29 116.7,135.3 120.49,135.3 122.52,137.34 123.97,137.34 124.18,137.13 124.18,136.89 v2(124.34,136.73)
  BOTTOM w0.079: v2(124.34,136.73) 124.24,136.63 124.16,136.63 124.08,136.55 124.08,136.31 123.91,136.14 123.39,136.14 123.08,135.83 122.78,135.72 122.77,135.71 122.58,135.63 122.45,135.63 122.27,135.71 122.17,135.71 122.1,135.69 U1.BL3
  BOTTOM w0.102: v1(23.01,83.49) 23.28,83.77 23.85,83.77 23.97,83.89 24.63,83.89 24.71,83.81 24.71,83.32 C793.1
PCIE_TXP15_SSD_C: length 2.5
  BOTTOM w0.102: C793.2 24.74,82.3 24.74,81.8 25,81.55 25,81.22 24.85,81.07 CN16.37
PCIE_TXP16_SSD: length 149.5
  IN1 w0.102: v2(126.17,136.82) 125.99,137.01 125.99,137.22 125.24,137.97 122.29,137.97 120.24,135.91 114.83,135.91 114.1,135.18 114.1,134.5 113.18,133.59 113.18,131.64 113.28,131.53 113.28,126.75 112.99,126.46 111.78,126.46 111.5,126.74 110.75,126.74 110.42,126.41 109.79,126.41 109.12,125.74 109.12,125.41 108.45,124.74 107.99,124.74 107.46,125.28 101.58,125.28 99.16,122.86 93.34,122.86 87.74,117.25 87.16,117.25 85.7,115.79 81.47,115.79 80.18,114.5 79.23,114.5 77.28,112.55 76.06,112.55 70.74,107.23 70.74,105.71 65.1,100.08 63.67,100.08 63.04,99.45 56.89,99.45 56.05,98.61 50.17,98.61 49.53,97.97 38.34,97.97 36.78,99.52 32.31,99.52 31.72,98.94 26.09,98.94 23.02,95.86 23.02,94.77 22.34,94.09 22.34,92.79 20.28,90.73 20.28,87.63 19.91,87.26 19.91,85.82 20.15,85.57 20.32,85.57 v1(20.56,85.33)
  BOTTOM w0.079: U1.BJ3 121.63,136.72 122.1,136.5 122.17,136.47 122.32,136.5 122.38,136.53 122.71,136.53 122.79,136.49 123.03,136.49 123.17,136.63 123.17,137.12 123.36,137.31 125.69,137.31 125.81,137.19
  BOTTOM w0.102: v2(126.17,136.82) 125.81,137.19 ; v1(20.56,85.33) 20.75,85.52 20.9,85.52 21.03,85.39 21.03,84.49 20.44,83.9 20.44,83.5 C795.1
PCIE_TXP16_SSD_C: length 3.6
  BOTTOM w0.102: C795.2 20.49,82.62 20.49,82.33 21.31,81.51 21.9,81.51 22,81.41 22,81.29 21.85,81.14 CN16.49
PCIE_WAKE#: length 359.4
  TOP w0.079: 101.94,132.55 102.23,132.55 102.62,132.16 102.62,132.05 103.05,131.63 103.66,131.63 104.06,131.23 v2(104.21,131.23)
  TOP w0.114: 101.94,132.55 101.64,132.55 100.38,133.81 97.97,133.81 96.77,135.01 93.66,135.01 92.56,133.91 91.16,133.91 90.3,134.77 R33.1 89.85,135.23 89.72,135.36 87.99,135.36 87.95,135.4 87.94,135.4 87.04,136.3 R67883.1 83.3,136.3 v1(83.29,136.29) 77.27,136.29 69.27,128.3 69.27,110.57 66.79,108.08 66.79,104.13 65.47,102.81 60.11,102.81 58.61,101.31 57.24,101.31 55.6,99.67 54.12,99.67 53.11,98.66 53.11,94.4 52.45,93.75 v1(52.45,93.54) ; Q33.3 186.44,109.37 EC13.1 186.03,110.56 186.03,111.09 186.34,111.41 186.63,111.41 v1(187.11,111.9) ; R67506.2 v1(26.83,162.84)
  IN1 w0.089: v1(212.46,106.1) 214,106.1 214.6,106.7 215.81,106.7 216.46,106.05 221.09,106.05 224.23,109.19 224.23,110.66 227.09,113.52 227.09,120.15 226.76,120.48 226.76,120.96 223.83,123.89 v1(223.83,124.25)
  IN4 w0.089: v1(212.46,106.1) 210.49,104.13 210.49,102.58 209.31,101.4 199.38,101.4 188.48,112.3 187.52,112.3 v1(187.11,111.9) 186.71,112.3 186.29,112.3 184.43,110.44 184.43,109.52 183.09,108.19 180.42,108.19 178.86,109.75 176.07,109.75 173.97,107.64 173.97,106.86 170.58,103.47 167.15,103.47 164.85,101.17 156.2,101.17 155.29,102.09 151.32,102.09 151.21,101.97 147.63,101.97 147.46,101.81 144.77,101.81 144.12,102.45 141.5,102.45 141.2,102.16 137.65,102.16 137.1,102.71 135.75,102.71 135.65,102.61 133.5,102.61 132,104.11 131.61,104.11 128.29,107.42 124.98,107.42 124.5,107.91 122.94,107.91 121.21,109.64 121.21,110.97 120.04,112.15 119.57,112.15 119.16,112.56 119.16,114.19 118.46,114.89 118.46,117.4 118.27,117.59 117.79,117.59 117.61,117.77 117.61,119.44 117.55,119.49 117.55,119.78 117.07,120.26 117.07,120.76 116.8,121.04 112.99,121.04 111.78,122.24 110.31,122.24 108.11,124.44 107.99,124.44 107.58,124.85 107.58,125.93 107.27,126.23 107.2,126.23 106.65,126.79 106.65,127.12 106.55,127.22 106.55,127.58 106.19,127.94 104.02,127.94 103.69,128.26 103.69,128.68 103.79,128.77 103.79,130.86 104.16,131.23 v2(104.21,131.23) ; v1(52.45,93.54) 52.45,94.24 48.69,98 43.06,98 42.86,97.8 38.26,97.8 35.29,100.76 34.39,100.76 34,101.15 30.92,104.24 30.92,109.32 31.14,109.54 31.14,115.14 30.67,115.62 30.67,119.73 29.58,120.82 29.58,129.34 28.68,130.24 28.68,131.54 29.3,132.16 29.3,142.62 28.02,143.9 28.02,146.37 29,147.35 29,151.21 28.64,151.56 28.64,153.86 27.19,155.31 27.19,158.31 27,158.5 27,160.95 27.32,161.26 27.32,162.35 v1(26.83,162.84)
  BOTTOM w0.079: U1.BU30 104.21,131.25 v2(104.21,131.23)
  BOTTOM w0.114: v1(223.83,124.25) 223.33,123.75 CN49.9
PD#: length 28.6
  IN4 w0.089: v1(22.77,36.34) 23.38,35.72 23.38,32.99 24.27,32.1 26.23,32.1 29.5,28.84 v1(32.44,28.84)
  BOTTOM w0.102: v1(22.77,36.34) 22.77,36.71 R478.1 22.47,36.88 21.75,36.15 21.58,36.15 21.41,35.99 U20.47
  BOTTOM w0.114: v1(32.44,28.84) R479.1 C595.1 v1(33.46,28.22) 33.08,27.85 31.87,27.85 31.17,27.15 D12.2 28.95,26.14 27.28,26.14 D13.2
PD_ADP_DISCHARGE: length 116
  TOP w0.114: v1(39.05,99.01) 39.48,99.45 PR8015.2
  IN1 w0.089: v1(24.88,46.14) 24.54,45.8 16.84,45.8 16.78,45.74 15.02,45.74 14.43,45.16 5.3,45.16 3.27,47.18 v1(3.27,47.95)
  IN2 w0.102: v1(29.13,101.2) 34.31,101.2 34.58,100.92 35.39,100.92 35.68,101.22 36.84,101.22 v1(39.05,99.01)
  IN4 w0.089: v1(29.13,101.2) 29.13,100.37 28.81,100.05 26.6,100.05 24.5,97.95 23.61,97.95 22.13,96.47 22.13,95.63 21.48,94.98 21.48,94.34 20.58,93.44 20.58,87.33 21.02,86.89 21.02,81.15 19.12,79.25 17.11,79.25 14.39,76.53 13.95,76.53 13.26,75.84 13.26,74.62 13.69,74.19 13.69,73.07 13.57,72.95 12.91,72.95 12.71,72.74 12.71,70.62 13.37,69.95 14.58,69.95 15.86,68.68 15.86,67.35 16.43,66.79 16.43,64.78 17.13,64.07 17.13,55.92 18.58,54.46 18.58,46.66 19.1,46.14 v1(24.88,46.14)
  BOTTOM w0.114: U6523.9 3.37,49.93 3.11,49.67 3.11,48.12 v1(3.27,47.95) ; U6511.20 25.41,47.05 25.52,46.94 25.52,46.36 25.3,46.14 v1(24.88,46.14)
PEDET: length 17.2
  BOTTOM w0.114: Q34.2 22.55,88.92 22.38,88.92 21.77,89.53 21.49,89.53 21.36,89.4 21.36,89.4 21.16,89.2 21.16,88.53 20.72,88.08 18.16,88.08 18.15,88.09 17.38,87.31 v1(17.38,86.84) 17.36,86.82 R654.2 17.12,86.11 16.59,85.57 16.59,83.95 17.2,83.33 17.2,82.71 R649.2 17.61,82.11 16.85,81.34 CN16.69
PEG_RXN5: length 87.7
  TOP w0.102: v1(118.99,198.94) 118.71,198.66 117.57,198.66 115.84,200.39 114.71,200.39 114.56,200.54 114.56,200.67 C358.1
  IN4 w0.102: v2(117.89,130.15) 118.13,130.39 118.13,130.6 118.38,130.85 121.12,130.85 121.28,130.69 122.1,130.69 122.93,131.51 122.93,134.36 122.66,134.63 122.66,135.61 120.95,137.31 120.95,138.33 120.61,138.67 118.86,138.67 117.66,139.87 116,139.87 114.99,140.88 114.99,157.59 115.96,158.56 115.96,160.21 115.65,160.52 115.65,167.39 116.41,168.15 116.41,175.38 118.1,177.07 118.1,178.1 117.78,178.42 117.78,189.45 117.47,189.75 117.47,192.93 118.44,193.9 118.44,197.03 118.28,197.19 118.28,198.42 118.5,198.63 118.68,198.63 v1(118.99,198.94)
  BOTTOM w0.079: U1.BW9 117.57,130.47 v2(117.89,130.15)
PEG_RXN5_C: length 14.2
  TOP w0.102: v2(125.98,200.22) 125.98,200.46 125.93,200.51 124.76,200.51 124.56,200.31 122.26,200.31 121.1,201.46 116.85,201.46 115.8,202.52 114.71,202.52 114.52,202.33 114.52,201.95 114.63,201.84 C358.2
  BOTTOM w0.102: U8.AB9 v2(125.98,200.22)
PEG_RXN6: length 96.9
  TOP w0.102: v1(123.01,208.64) 122.89,208.64 122.77,208.76 122.77,209.01 122.89,209.13 126.56,209.13 126.86,209.43 127.37,209.43 127.49,209.3 127.49,209.14 C384.1
  IN4 w0.102: v1(123.01,208.64) 122.75,208.38 122.75,207.81 119.33,204.39 118.95,204.39 118.39,203.83 118.39,201.42 117.25,200.27 117.25,198.47 117.78,197.94 117.78,194.19 117.04,193.45 117.04,189.57 117.37,189.23 117.37,178.29 115.65,176.57 115.65,171.38 115.09,170.81 115.09,158.39 114.57,157.87 114.57,140.66 116.2,139.02 116.96,139.02 117.73,138.25 117.73,137.55 118.3,136.98 120.71,136.98 122.25,135.44 122.25,134.43 122.55,134.13 122.55,132.2 122.02,131.66 120.82,131.66 120.32,131.17 119.62,131.17 119.4,131.38 119.4,131.57 v2(119.17,131.8)
  BOTTOM w0.079: v2(119.17,131.8) 119.17,131.75 U1.BU6
PEG_RXN6_C: length 9.4
  TOP w0.102: v2(127.61,201.03) 127.8,201.03 127.87,201.11 127.87,201.43 126.89,202.41 126.89,205.51 127.7,206.32 127.7,207.94 127.63,208 C384.2
  BOTTOM w0.102: v2(127.61,201.03) 127.71,200.94 127.71,200.74 127.54,200.58 127.27,200.58 U8.AC10
PEG_RXN7: length 101.3
  TOP w0.102: C6554.1 129.05,210.97 129.05,211.18 128.75,211.48 126.51,211.48 124.99,209.96 123.13,209.96 122.98,210.11 122.98,210.29 v1(123.23,210.55)
  IN4 w0.102: v1(123.23,210.55) 123,210.32 123,210.06 122.7,209.77 121.66,209.77 116.48,204.59 116.48,198.37 117.15,197.7 117.15,194.62 115.13,192.6 115.13,188.74 116.33,187.54 116.33,178.15 114.93,176.76 114.93,171.6 114.38,171.04 114.38,168.03 113.93,167.58 113.93,139.23 116.17,136.98 117.38,136.98 118.38,135.97 120.85,135.97 121.64,135.18 121.64,134.23 121.94,133.92 121.94,132.58 121.49,132.12 120.21,132.12 120.13,132.2 119.82,132.2 119.28,132.73 v2(119.14,132.73)
  BOTTOM w0.079: U1.BT7 118.87,132.47 v2(119.14,132.73)
PEG_RXN7_C: length 10.1
  TOP w0.102: C6554.2 129.03,209.57 129.03,209.15 128.88,209 128.88,207.44 128.8,207.35 128.8,204.85 129.12,204.53 129.12,202.37 128.88,202.13 128.88,201.48 v2(128.46,201.06)
  BOTTOM w0.102: U8.AC11 128.45,201.06 v2(128.46,201.06)
PEG_RXN8: length 107.2
  TOP w0.102: C6557.1 130.14,209.08 130.14,211.3 129.38,212.06 129.04,212.06 128.87,212.23 128.87,212.34 v1(129.11,212.57)
  IN4 w0.102: v1(129.11,212.57) 128.92,212.76 128.92,213 128.69,213.22 127.88,213.22 127.07,212.42 122.15,212.42 120.75,211.02 120.75,210.01 115.62,204.87 115.62,197.19 116.17,196.64 116.17,194.8 114.07,192.69 114.07,186.99 115.51,185.55 115.51,178.59 114.09,177.17 114.09,172.06 113.56,171.53 113.56,168.47 113.03,167.94 113.03,159.02 112.62,158.62 112.62,155.13 112.99,154.76 112.99,138.83 116.66,135.16 119.33,135.16 119.34,135.17 120.56,135.17 120.87,134.87 120.87,134.31 120.73,134.16 120.73,133.49 120.55,133.31 118.75,133.31 118.34,132.91 118.34,132.26 v2(117.88,131.8)
  BOTTOM w0.079: U1.BU9 117.57,131.49 v2(117.88,131.8)
PEG_RXN8_C: length 9.2
  TOP w0.102: v2(129.29,200.24) 129.69,200.65 129.69,201.34 129.91,201.56 129.91,205.04 129.42,205.53 129.42,206.75 130.18,207.51 130.18,207.75 C6557.2
  BOTTOM w0.102: U8.AB12 128.88,199.83 v2(129.29,200.24)
PEG_RXP5: length 87.7
  TOP w0.102: v1(118.99,198.18) 118.71,198.46 117.48,198.46 115.75,200.19 114.62,200.19 114.36,200.45 114.36,200.68 C370.1
  IN4 w0.102: v1(118.99,198.18) 118.74,198.43 118.58,198.43 118.48,198.33 118.48,197.28 118.64,197.11 118.64,193.81 117.68,192.85 117.68,189.84 117.98,189.53 117.98,178.5 118.3,178.19 118.3,176.98 116.61,175.29 116.61,168.07 115.85,167.31 115.85,160.61 116.16,160.3 116.16,158.47 115.19,157.51 115.19,140.97 116.09,140.07 117.74,140.07 118.95,138.87 120.7,138.87 121.15,138.42 121.15,137.4 122.86,135.69 122.86,134.7 123.12,134.44 123.12,131.43 122.18,130.49 121.2,130.49 121.04,130.66 118.46,130.66 118.32,130.52 118.32,130.37 v2(118.55,130.14)
  BOTTOM w0.079: v2(118.55,130.14) 118.22,130.47 U1.BW8
PEG_RXP5_C: length 14.2
  TOP w0.102: v2(125.98,201.04) 125.66,200.71 124.68,200.71 124.48,200.51 122.34,200.51 121.19,201.66 116.94,201.66 115.88,202.72 114.62,202.72 114.31,202.41 114.31,202.17 C370.2
  BOTTOM w0.102: v2(125.98,201.04) 126.37,200.65 U8.AC9
PEG_RXP6: length 96.9
  TOP w0.102: v1(122.33,208.66) 122.57,208.9 122.57,209.1 122.8,209.33 126.48,209.33 126.77,209.63 127.45,209.63 127.7,209.39 127.7,209.24 C382.1
  IN4 w0.102: v1(122.33,208.66) 122.54,208.44 122.54,207.89 119.24,204.59 118.86,204.59 118.19,203.91 118.19,201.5 117.04,200.36 117.04,198.38 117.58,197.85 117.58,194.27 116.83,193.53 116.83,189.49 117.17,189.15 117.17,178.38 115.45,176.66 115.45,171.46 114.88,170.89 114.88,158.47 114.37,157.95 114.37,140.57 116.12,138.82 116.88,138.82 117.53,138.17 117.53,137.47 118.22,136.78 120.62,136.78 122.06,135.34 122.06,134.35 122.35,134.06 122.35,132.26 121.94,131.85 120.74,131.85 120.24,131.36 119.7,131.36 119.59,131.46 119.59,131.55 v2(119.83,131.8)
  BOTTOM w0.079: v2(119.83,131.8) 119.83,131.74 U1.BU5
